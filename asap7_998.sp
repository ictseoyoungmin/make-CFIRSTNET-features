R0 n1_M2_60_60 n1_M2_1140_60 0.988200
R1 n1_M2_1140_60 n1_M2_2220_60 0.988200
R2 n1_M2_2220_60 n1_M2_3300_60 0.988200
R3 n1_M2_3300_60 n1_M2_4380_60 0.988200
R4 n1_M2_4380_60 n1_M2_5460_60 0.988200
R5 n1_M2_5460_60 n1_M2_6540_60 0.988200
R6 n1_M2_6540_60 n1_M2_7620_60 0.988200
R7 n1_M2_7620_60 n1_M2_8700_60 0.988200
R8 n1_M2_8700_60 n1_M2_9780_60 0.988200
R9 n1_M2_9780_60 n1_M2_10860_60 0.988200
R10 n1_M2_10860_60 n1_M2_11940_60 0.988200
R11 n1_M2_11940_60 n1_M2_13020_60 0.988200
R12 n1_M2_13020_60 n1_M2_14100_60 0.988200
R13 n1_M2_14100_60 n1_M2_15180_60 0.988200
R14 n1_M2_15180_60 n1_M2_16260_60 0.988200
R15 n1_M2_16260_60 n1_M2_17340_60 0.988200
R16 n1_M2_17340_60 n1_M2_18420_60 0.988200
R17 n1_M2_18420_60 n1_M2_19500_60 0.988200
R18 n1_M2_19500_60 n1_M2_20580_60 0.988200
R19 n1_M2_20580_60 n1_M2_21660_60 0.988200
R20 n1_M2_21660_60 n1_M2_22740_60 0.988200
R21 n1_M2_22740_60 n1_M2_23820_60 0.988200
R22 n1_M2_23820_60 n1_M2_24900_60 0.988200
R23 n1_M2_24900_60 n1_M2_25980_60 0.988200
R24 n1_M2_25980_60 n1_M2_27060_60 0.988200
R25 n1_M2_27060_60 n1_M2_28140_60 0.988200
R26 n1_M2_28140_60 n1_M2_29220_60 0.988200
R27 n1_M2_29220_60 n1_M2_30300_60 0.988200
R28 n1_M2_30300_60 n1_M2_31380_60 0.988200
R29 n1_M2_31380_60 n1_M2_32460_60 0.988200
R30 n1_M2_32460_60 n1_M2_33540_60 0.988200
R31 n1_M2_33540_60 n1_M2_34620_60 0.988200
R32 n1_M2_34620_60 n1_M2_35700_60 0.988200
R33 n1_M2_35700_60 n1_M2_36780_60 0.988200
R34 n1_M2_36780_60 n1_M2_37860_60 0.988200
R35 n1_M2_37860_60 n1_M2_38940_60 0.988200
R36 n1_M2_38940_60 n1_M2_40020_60 0.988200
R37 n1_M2_40020_60 n1_M2_41100_60 0.988200
R38 n1_M2_41100_60 n1_M2_42180_60 0.988200
R39 n1_M2_42180_60 n1_M2_43260_60 0.988200
R40 n1_M2_43260_60 n1_M2_44340_60 0.988200
R41 n1_M2_44340_60 n1_M2_45420_60 0.988200
R42 n1_M2_45420_60 n1_M2_46500_60 0.988200
R43 n1_M2_46500_60 n1_M2_47580_60 0.988200
R44 n1_M2_47580_60 n1_M2_48660_60 0.988200
R45 n1_M2_48660_60 n1_M2_49740_60 0.988200
R46 n1_M2_49740_60 n1_M2_50820_60 0.988200
R47 n1_M2_50820_60 n1_M2_51900_60 0.988200
R48 n1_M2_51900_60 n1_M2_52980_60 0.988200
R49 n1_M2_52980_60 n1_M2_54060_60 0.988200
R50 n1_M2_54060_60 n1_M2_55140_60 0.988200
R51 n1_M2_55140_60 n1_M2_56220_60 0.988200
R52 n1_M2_56220_60 n1_M2_57300_60 0.988200
R53 n1_M2_57300_60 n1_M2_58380_60 0.988200
R54 n1_M2_58380_60 n1_M2_59460_60 0.988200
R55 n1_M2_59460_60 n1_M2_60540_60 0.988200
R56 n1_M2_60540_60 n1_M2_61620_60 0.988200
R57 n1_M2_61620_60 n1_M2_62700_60 0.988200
R58 n1_M2_62700_60 n1_M2_63780_60 0.988200
R59 n1_M2_63780_60 n1_M2_64860_60 0.988200
R60 n1_M2_64860_60 n1_M2_65940_60 0.988200
R61 n1_M2_65940_60 n1_M2_67020_60 0.988200
R62 n1_M2_67020_60 n1_M2_68100_60 0.988200
R63 n1_M2_68100_60 n1_M2_69180_60 0.988200
R64 n1_M2_69180_60 n1_M2_70260_60 0.988200
R65 n1_M2_70260_60 n1_M2_71340_60 0.988200
R66 n1_M2_71340_60 n1_M2_72420_60 0.988200
R67 n1_M2_72420_60 n1_M2_73500_60 0.988200
R68 n1_M2_73500_60 n1_M2_74580_60 0.988200
R69 n1_M2_74580_60 n1_M2_75660_60 0.988200
R70 n1_M2_75660_60 n1_M2_76740_60 0.988200
R71 n1_M2_76740_60 n1_M2_77820_60 0.988200
R72 n1_M2_77820_60 n1_M2_78900_60 0.988200
R73 n1_M2_78900_60 n1_M2_79980_60 0.988200
R74 n1_M2_79980_60 n1_M2_81060_60 0.988200
R75 n1_M2_81060_60 n1_M2_82140_60 0.988200
R76 n1_M2_82140_60 n1_M2_83220_60 0.988200
R77 n1_M2_83220_60 n1_M2_84300_60 0.988200
R78 n1_M2_84300_60 n1_M2_85380_60 0.988200
R79 n1_M2_85380_60 n1_M2_86460_60 0.988200
R80 n1_M2_86460_60 n1_M2_87540_60 0.988200
R81 n1_M2_87540_60 n1_M2_88620_60 0.988200
R82 n1_M2_88620_60 n1_M2_89700_60 0.988200
R83 n1_M2_89700_60 n1_M2_90780_60 0.988200
R84 n1_M2_90780_60 n1_M2_91860_60 0.988200
R85 n1_M2_91860_60 n1_M2_92940_60 0.988200
R86 n1_M2_92940_60 n1_M2_94020_60 0.988200
R87 n1_M2_94020_60 n1_M2_95100_60 0.988200
R88 n1_M2_95100_60 n1_M2_96180_60 0.988200
R89 n1_M2_96180_60 n1_M2_97260_60 0.988200
R90 n1_M2_97260_60 n1_M2_98340_60 0.988200
R91 n1_M2_98340_60 n1_M2_99420_60 0.988200
R92 n1_M2_99420_60 n1_M2_100500_60 0.988200
R93 n1_M2_100500_60 n1_M2_101580_60 0.988200
R94 n1_M2_101580_60 n1_M2_102660_60 0.988200
R95 n1_M2_102660_60 n1_M2_103740_60 0.988200
R96 n1_M2_103740_60 n1_M2_104820_60 0.988200
R97 n1_M2_104820_60 n1_M2_105900_60 0.988200
R98 n1_M2_105900_60 n1_M2_106980_60 0.988200
R99 n1_M2_106980_60 n1_M2_108060_60 0.988200
R100 n1_M2_108060_60 n1_M2_109140_60 0.988200
R101 n1_M2_109140_60 n1_M2_110220_60 0.988200
R102 n1_M2_110220_60 n1_M2_111300_60 0.988200
R103 n1_M2_111300_60 n1_M2_112380_60 0.988200
R104 n1_M2_112380_60 n1_M2_113460_60 0.988200
R105 n1_M2_113460_60 n1_M2_114540_60 0.988200
R106 n1_M2_114540_60 n1_M2_115620_60 0.988200
R107 n1_M2_115620_60 n1_M2_116700_60 0.988200
R108 n1_M2_116700_60 n1_M2_117780_60 0.988200
R109 n1_M2_117780_60 n1_M2_118860_60 0.988200
R110 n1_M2_118860_60 n1_M2_119940_60 0.988200
R111 n1_M2_119940_60 n1_M2_121020_60 0.988200
R112 n1_M2_121020_60 n1_M2_122100_60 0.988200
R113 n1_M2_122100_60 n1_M2_123180_60 0.988200
R114 n1_M2_123180_60 n1_M2_124260_60 0.988200
R115 n1_M2_124260_60 n1_M2_125340_60 0.988200
R116 n1_M2_125340_60 n1_M2_126420_60 0.988200
R117 n1_M2_126420_60 n1_M2_127500_60 0.988200
R118 n1_M2_127500_60 n1_M2_128580_60 0.988200
R119 n1_M2_128580_60 n1_M2_129660_60 0.988200
R120 n1_M2_60_1140 n1_M2_1140_1140 0.988200
R121 n1_M2_1140_1140 n1_M2_2220_1140 0.988200
R122 n1_M2_2220_1140 n1_M2_3300_1140 0.988200
R123 n1_M2_3300_1140 n1_M2_4380_1140 0.988200
R124 n1_M2_4380_1140 n1_M2_5460_1140 0.988200
R125 n1_M2_5460_1140 n1_M2_6540_1140 0.988200
R126 n1_M2_6540_1140 n1_M2_7620_1140 0.988200
R127 n1_M2_7620_1140 n1_M2_8700_1140 0.988200
R128 n1_M2_8700_1140 n1_M2_9780_1140 0.988200
R129 n1_M2_9780_1140 n1_M2_10860_1140 0.988200
R130 n1_M2_10860_1140 n1_M2_11940_1140 0.988200
R131 n1_M2_11940_1140 n1_M2_13020_1140 0.988200
R132 n1_M2_13020_1140 n1_M2_14100_1140 0.988200
R133 n1_M2_14100_1140 n1_M2_15180_1140 0.988200
R134 n1_M2_15180_1140 n1_M2_16260_1140 0.988200
R135 n1_M2_16260_1140 n1_M2_17340_1140 0.988200
R136 n1_M2_17340_1140 n1_M2_18420_1140 0.988200
R137 n1_M2_18420_1140 n1_M2_19500_1140 0.988200
R138 n1_M2_19500_1140 n1_M2_20580_1140 0.988200
R139 n1_M2_20580_1140 n1_M2_21660_1140 0.988200
R140 n1_M2_21660_1140 n1_M2_22740_1140 0.988200
R141 n1_M2_22740_1140 n1_M2_23820_1140 0.988200
R142 n1_M2_23820_1140 n1_M2_24900_1140 0.988200
R143 n1_M2_24900_1140 n1_M2_25980_1140 0.988200
R144 n1_M2_25980_1140 n1_M2_27060_1140 0.988200
R145 n1_M2_27060_1140 n1_M2_28140_1140 0.988200
R146 n1_M2_28140_1140 n1_M2_29220_1140 0.988200
R147 n1_M2_29220_1140 n1_M2_30300_1140 0.988200
R148 n1_M2_30300_1140 n1_M2_31380_1140 0.988200
R149 n1_M2_31380_1140 n1_M2_32460_1140 0.988200
R150 n1_M2_32460_1140 n1_M2_33540_1140 0.988200
R151 n1_M2_33540_1140 n1_M2_34620_1140 0.988200
R152 n1_M2_34620_1140 n1_M2_35700_1140 0.988200
R153 n1_M2_35700_1140 n1_M2_36780_1140 0.988200
R154 n1_M2_36780_1140 n1_M2_37860_1140 0.988200
R155 n1_M2_37860_1140 n1_M2_38940_1140 0.988200
R156 n1_M2_38940_1140 n1_M2_40020_1140 0.988200
R157 n1_M2_40020_1140 n1_M2_41100_1140 0.988200
R158 n1_M2_41100_1140 n1_M2_42180_1140 0.988200
R159 n1_M2_42180_1140 n1_M2_43260_1140 0.988200
R160 n1_M2_43260_1140 n1_M2_44340_1140 0.988200
R161 n1_M2_44340_1140 n1_M2_45420_1140 0.988200
R162 n1_M2_45420_1140 n1_M2_46500_1140 0.988200
R163 n1_M2_46500_1140 n1_M2_47580_1140 0.988200
R164 n1_M2_47580_1140 n1_M2_48660_1140 0.988200
R165 n1_M2_48660_1140 n1_M2_49740_1140 0.988200
R166 n1_M2_49740_1140 n1_M2_50820_1140 0.988200
R167 n1_M2_50820_1140 n1_M2_51900_1140 0.988200
R168 n1_M2_51900_1140 n1_M2_52980_1140 0.988200
R169 n1_M2_52980_1140 n1_M2_54060_1140 0.988200
R170 n1_M2_54060_1140 n1_M2_55140_1140 0.988200
R171 n1_M2_55140_1140 n1_M2_56220_1140 0.988200
R172 n1_M2_56220_1140 n1_M2_57300_1140 0.988200
R173 n1_M2_57300_1140 n1_M2_58380_1140 0.988200
R174 n1_M2_58380_1140 n1_M2_59460_1140 0.988200
R175 n1_M2_59460_1140 n1_M2_60540_1140 0.988200
R176 n1_M2_60540_1140 n1_M2_61620_1140 0.988200
R177 n1_M2_61620_1140 n1_M2_62700_1140 0.988200
R178 n1_M2_62700_1140 n1_M2_63780_1140 0.988200
R179 n1_M2_63780_1140 n1_M2_64860_1140 0.988200
R180 n1_M2_64860_1140 n1_M2_65940_1140 0.988200
R181 n1_M2_65940_1140 n1_M2_67020_1140 0.988200
R182 n1_M2_67020_1140 n1_M2_68100_1140 0.988200
R183 n1_M2_68100_1140 n1_M2_69180_1140 0.988200
R184 n1_M2_69180_1140 n1_M2_70260_1140 0.988200
R185 n1_M2_70260_1140 n1_M2_71340_1140 0.988200
R186 n1_M2_71340_1140 n1_M2_72420_1140 0.988200
R187 n1_M2_72420_1140 n1_M2_73500_1140 0.988200
R188 n1_M2_73500_1140 n1_M2_74580_1140 0.988200
R189 n1_M2_74580_1140 n1_M2_75660_1140 0.988200
R190 n1_M2_75660_1140 n1_M2_76740_1140 0.988200
R191 n1_M2_76740_1140 n1_M2_77820_1140 0.988200
R192 n1_M2_77820_1140 n1_M2_78900_1140 0.988200
R193 n1_M2_78900_1140 n1_M2_79980_1140 0.988200
R194 n1_M2_79980_1140 n1_M2_81060_1140 0.988200
R195 n1_M2_81060_1140 n1_M2_82140_1140 0.988200
R196 n1_M2_82140_1140 n1_M2_83220_1140 0.988200
R197 n1_M2_83220_1140 n1_M2_84300_1140 0.988200
R198 n1_M2_84300_1140 n1_M2_85380_1140 0.988200
R199 n1_M2_85380_1140 n1_M2_86460_1140 0.988200
R200 n1_M2_86460_1140 n1_M2_87540_1140 0.988200
R201 n1_M2_87540_1140 n1_M2_88620_1140 0.988200
R202 n1_M2_88620_1140 n1_M2_89700_1140 0.988200
R203 n1_M2_89700_1140 n1_M2_90780_1140 0.988200
R204 n1_M2_90780_1140 n1_M2_91860_1140 0.988200
R205 n1_M2_91860_1140 n1_M2_92940_1140 0.988200
R206 n1_M2_92940_1140 n1_M2_94020_1140 0.988200
R207 n1_M2_94020_1140 n1_M2_95100_1140 0.988200
R208 n1_M2_95100_1140 n1_M2_96180_1140 0.988200
R209 n1_M2_96180_1140 n1_M2_97260_1140 0.988200
R210 n1_M2_97260_1140 n1_M2_98340_1140 0.988200
R211 n1_M2_98340_1140 n1_M2_99420_1140 0.988200
R212 n1_M2_99420_1140 n1_M2_100500_1140 0.988200
R213 n1_M2_100500_1140 n1_M2_101580_1140 0.988200
R214 n1_M2_101580_1140 n1_M2_102660_1140 0.988200
R215 n1_M2_102660_1140 n1_M2_103740_1140 0.988200
R216 n1_M2_103740_1140 n1_M2_104820_1140 0.988200
R217 n1_M2_104820_1140 n1_M2_105900_1140 0.988200
R218 n1_M2_105900_1140 n1_M2_106980_1140 0.988200
R219 n1_M2_106980_1140 n1_M2_108060_1140 0.988200
R220 n1_M2_108060_1140 n1_M2_109140_1140 0.988200
R221 n1_M2_109140_1140 n1_M2_110220_1140 0.988200
R222 n1_M2_110220_1140 n1_M2_111300_1140 0.988200
R223 n1_M2_111300_1140 n1_M2_112380_1140 0.988200
R224 n1_M2_112380_1140 n1_M2_113460_1140 0.988200
R225 n1_M2_113460_1140 n1_M2_114540_1140 0.988200
R226 n1_M2_114540_1140 n1_M2_115620_1140 0.988200
R227 n1_M2_115620_1140 n1_M2_116700_1140 0.988200
R228 n1_M2_116700_1140 n1_M2_117780_1140 0.988200
R229 n1_M2_117780_1140 n1_M2_118860_1140 0.988200
R230 n1_M2_118860_1140 n1_M2_119940_1140 0.988200
R231 n1_M2_119940_1140 n1_M2_121020_1140 0.988200
R232 n1_M2_121020_1140 n1_M2_122100_1140 0.988200
R233 n1_M2_122100_1140 n1_M2_123180_1140 0.988200
R234 n1_M2_123180_1140 n1_M2_124260_1140 0.988200
R235 n1_M2_124260_1140 n1_M2_125340_1140 0.988200
R236 n1_M2_125340_1140 n1_M2_126420_1140 0.988200
R237 n1_M2_126420_1140 n1_M2_127500_1140 0.988200
R238 n1_M2_127500_1140 n1_M2_128580_1140 0.988200
R239 n1_M2_128580_1140 n1_M2_129660_1140 0.988200
R240 n1_M2_60_2220 n1_M2_1140_2220 0.988200
R241 n1_M2_1140_2220 n1_M2_2220_2220 0.988200
R242 n1_M2_2220_2220 n1_M2_3300_2220 0.988200
R243 n1_M2_3300_2220 n1_M2_4380_2220 0.988200
R244 n1_M2_4380_2220 n1_M2_5460_2220 0.988200
R245 n1_M2_5460_2220 n1_M2_6540_2220 0.988200
R246 n1_M2_6540_2220 n1_M2_7620_2220 0.988200
R247 n1_M2_7620_2220 n1_M2_8700_2220 0.988200
R248 n1_M2_8700_2220 n1_M2_9780_2220 0.988200
R249 n1_M2_9780_2220 n1_M2_10860_2220 0.988200
R250 n1_M2_10860_2220 n1_M2_11940_2220 0.988200
R251 n1_M2_11940_2220 n1_M2_13020_2220 0.988200
R252 n1_M2_13020_2220 n1_M2_14100_2220 0.988200
R253 n1_M2_14100_2220 n1_M2_15180_2220 0.988200
R254 n1_M2_15180_2220 n1_M2_16260_2220 0.988200
R255 n1_M2_16260_2220 n1_M2_17340_2220 0.988200
R256 n1_M2_17340_2220 n1_M2_18420_2220 0.988200
R257 n1_M2_18420_2220 n1_M2_19500_2220 0.988200
R258 n1_M2_19500_2220 n1_M2_20580_2220 0.988200
R259 n1_M2_20580_2220 n1_M2_21660_2220 0.988200
R260 n1_M2_21660_2220 n1_M2_22740_2220 0.988200
R261 n1_M2_22740_2220 n1_M2_23820_2220 0.988200
R262 n1_M2_23820_2220 n1_M2_24900_2220 0.988200
R263 n1_M2_24900_2220 n1_M2_25980_2220 0.988200
R264 n1_M2_25980_2220 n1_M2_27060_2220 0.988200
R265 n1_M2_27060_2220 n1_M2_28140_2220 0.988200
R266 n1_M2_28140_2220 n1_M2_29220_2220 0.988200
R267 n1_M2_29220_2220 n1_M2_30300_2220 0.988200
R268 n1_M2_30300_2220 n1_M2_31380_2220 0.988200
R269 n1_M2_31380_2220 n1_M2_32460_2220 0.988200
R270 n1_M2_32460_2220 n1_M2_33540_2220 0.988200
R271 n1_M2_33540_2220 n1_M2_34620_2220 0.988200
R272 n1_M2_34620_2220 n1_M2_35700_2220 0.988200
R273 n1_M2_35700_2220 n1_M2_36780_2220 0.988200
R274 n1_M2_36780_2220 n1_M2_37860_2220 0.988200
R275 n1_M2_37860_2220 n1_M2_38940_2220 0.988200
R276 n1_M2_38940_2220 n1_M2_40020_2220 0.988200
R277 n1_M2_40020_2220 n1_M2_41100_2220 0.988200
R278 n1_M2_41100_2220 n1_M2_42180_2220 0.988200
R279 n1_M2_42180_2220 n1_M2_43260_2220 0.988200
R280 n1_M2_43260_2220 n1_M2_44340_2220 0.988200
R281 n1_M2_44340_2220 n1_M2_45420_2220 0.988200
R282 n1_M2_45420_2220 n1_M2_46500_2220 0.988200
R283 n1_M2_46500_2220 n1_M2_47580_2220 0.988200
R284 n1_M2_47580_2220 n1_M2_48660_2220 0.988200
R285 n1_M2_48660_2220 n1_M2_49740_2220 0.988200
R286 n1_M2_49740_2220 n1_M2_50820_2220 0.988200
R287 n1_M2_50820_2220 n1_M2_51900_2220 0.988200
R288 n1_M2_51900_2220 n1_M2_52980_2220 0.988200
R289 n1_M2_52980_2220 n1_M2_54060_2220 0.988200
R290 n1_M2_54060_2220 n1_M2_55140_2220 0.988200
R291 n1_M2_55140_2220 n1_M2_56220_2220 0.988200
R292 n1_M2_56220_2220 n1_M2_57300_2220 0.988200
R293 n1_M2_57300_2220 n1_M2_58380_2220 0.988200
R294 n1_M2_58380_2220 n1_M2_59460_2220 0.988200
R295 n1_M2_59460_2220 n1_M2_60540_2220 0.988200
R296 n1_M2_60540_2220 n1_M2_61620_2220 0.988200
R297 n1_M2_61620_2220 n1_M2_62700_2220 0.988200
R298 n1_M2_62700_2220 n1_M2_63780_2220 0.988200
R299 n1_M2_63780_2220 n1_M2_64860_2220 0.988200
R300 n1_M2_64860_2220 n1_M2_65940_2220 0.988200
R301 n1_M2_65940_2220 n1_M2_67020_2220 0.988200
R302 n1_M2_67020_2220 n1_M2_68100_2220 0.988200
R303 n1_M2_68100_2220 n1_M2_69180_2220 0.988200
R304 n1_M2_69180_2220 n1_M2_70260_2220 0.988200
R305 n1_M2_70260_2220 n1_M2_71340_2220 0.988200
R306 n1_M2_71340_2220 n1_M2_72420_2220 0.988200
R307 n1_M2_72420_2220 n1_M2_73500_2220 0.988200
R308 n1_M2_73500_2220 n1_M2_74580_2220 0.988200
R309 n1_M2_74580_2220 n1_M2_75660_2220 0.988200
R310 n1_M2_75660_2220 n1_M2_76740_2220 0.988200
R311 n1_M2_76740_2220 n1_M2_77820_2220 0.988200
R312 n1_M2_77820_2220 n1_M2_78900_2220 0.988200
R313 n1_M2_78900_2220 n1_M2_79980_2220 0.988200
R314 n1_M2_79980_2220 n1_M2_81060_2220 0.988200
R315 n1_M2_81060_2220 n1_M2_82140_2220 0.988200
R316 n1_M2_82140_2220 n1_M2_83220_2220 0.988200
R317 n1_M2_83220_2220 n1_M2_84300_2220 0.988200
R318 n1_M2_84300_2220 n1_M2_85380_2220 0.988200
R319 n1_M2_85380_2220 n1_M2_86460_2220 0.988200
R320 n1_M2_86460_2220 n1_M2_87540_2220 0.988200
R321 n1_M2_87540_2220 n1_M2_88620_2220 0.988200
R322 n1_M2_88620_2220 n1_M2_89700_2220 0.988200
R323 n1_M2_89700_2220 n1_M2_90780_2220 0.988200
R324 n1_M2_90780_2220 n1_M2_91860_2220 0.988200
R325 n1_M2_91860_2220 n1_M2_92940_2220 0.988200
R326 n1_M2_92940_2220 n1_M2_94020_2220 0.988200
R327 n1_M2_94020_2220 n1_M2_95100_2220 0.988200
R328 n1_M2_95100_2220 n1_M2_96180_2220 0.988200
R329 n1_M2_96180_2220 n1_M2_97260_2220 0.988200
R330 n1_M2_97260_2220 n1_M2_98340_2220 0.988200
R331 n1_M2_98340_2220 n1_M2_99420_2220 0.988200
R332 n1_M2_99420_2220 n1_M2_100500_2220 0.988200
R333 n1_M2_100500_2220 n1_M2_101580_2220 0.988200
R334 n1_M2_101580_2220 n1_M2_102660_2220 0.988200
R335 n1_M2_102660_2220 n1_M2_103740_2220 0.988200
R336 n1_M2_103740_2220 n1_M2_104820_2220 0.988200
R337 n1_M2_104820_2220 n1_M2_105900_2220 0.988200
R338 n1_M2_105900_2220 n1_M2_106980_2220 0.988200
R339 n1_M2_106980_2220 n1_M2_108060_2220 0.988200
R340 n1_M2_108060_2220 n1_M2_109140_2220 0.988200
R341 n1_M2_109140_2220 n1_M2_110220_2220 0.988200
R342 n1_M2_110220_2220 n1_M2_111300_2220 0.988200
R343 n1_M2_111300_2220 n1_M2_112380_2220 0.988200
R344 n1_M2_112380_2220 n1_M2_113460_2220 0.988200
R345 n1_M2_113460_2220 n1_M2_114540_2220 0.988200
R346 n1_M2_114540_2220 n1_M2_115620_2220 0.988200
R347 n1_M2_115620_2220 n1_M2_116700_2220 0.988200
R348 n1_M2_116700_2220 n1_M2_117780_2220 0.988200
R349 n1_M2_117780_2220 n1_M2_118860_2220 0.988200
R350 n1_M2_118860_2220 n1_M2_119940_2220 0.988200
R351 n1_M2_119940_2220 n1_M2_121020_2220 0.988200
R352 n1_M2_121020_2220 n1_M2_122100_2220 0.988200
R353 n1_M2_122100_2220 n1_M2_123180_2220 0.988200
R354 n1_M2_123180_2220 n1_M2_124260_2220 0.988200
R355 n1_M2_124260_2220 n1_M2_125340_2220 0.988200
R356 n1_M2_125340_2220 n1_M2_126420_2220 0.988200
R357 n1_M2_126420_2220 n1_M2_127500_2220 0.988200
R358 n1_M2_127500_2220 n1_M2_128580_2220 0.988200
R359 n1_M2_128580_2220 n1_M2_129660_2220 0.988200
R360 n1_M2_60_3300 n1_M2_1140_3300 0.988200
R361 n1_M2_1140_3300 n1_M2_2220_3300 0.988200
R362 n1_M2_2220_3300 n1_M2_3300_3300 0.988200
R363 n1_M2_3300_3300 n1_M2_4380_3300 0.988200
R364 n1_M2_4380_3300 n1_M2_5460_3300 0.988200
R365 n1_M2_5460_3300 n1_M2_6540_3300 0.988200
R366 n1_M2_6540_3300 n1_M2_7620_3300 0.988200
R367 n1_M2_7620_3300 n1_M2_8700_3300 0.988200
R368 n1_M2_8700_3300 n1_M2_9780_3300 0.988200
R369 n1_M2_9780_3300 n1_M2_10860_3300 0.988200
R370 n1_M2_10860_3300 n1_M2_11940_3300 0.988200
R371 n1_M2_11940_3300 n1_M2_13020_3300 0.988200
R372 n1_M2_13020_3300 n1_M2_14100_3300 0.988200
R373 n1_M2_14100_3300 n1_M2_15180_3300 0.988200
R374 n1_M2_15180_3300 n1_M2_16260_3300 0.988200
R375 n1_M2_16260_3300 n1_M2_17340_3300 0.988200
R376 n1_M2_17340_3300 n1_M2_18420_3300 0.988200
R377 n1_M2_18420_3300 n1_M2_19500_3300 0.988200
R378 n1_M2_19500_3300 n1_M2_20580_3300 0.988200
R379 n1_M2_20580_3300 n1_M2_21660_3300 0.988200
R380 n1_M2_21660_3300 n1_M2_22740_3300 0.988200
R381 n1_M2_22740_3300 n1_M2_23820_3300 0.988200
R382 n1_M2_23820_3300 n1_M2_24900_3300 0.988200
R383 n1_M2_24900_3300 n1_M2_25980_3300 0.988200
R384 n1_M2_25980_3300 n1_M2_27060_3300 0.988200
R385 n1_M2_27060_3300 n1_M2_28140_3300 0.988200
R386 n1_M2_28140_3300 n1_M2_29220_3300 0.988200
R387 n1_M2_29220_3300 n1_M2_30300_3300 0.988200
R388 n1_M2_30300_3300 n1_M2_31380_3300 0.988200
R389 n1_M2_31380_3300 n1_M2_32460_3300 0.988200
R390 n1_M2_32460_3300 n1_M2_33540_3300 0.988200
R391 n1_M2_33540_3300 n1_M2_34620_3300 0.988200
R392 n1_M2_34620_3300 n1_M2_35700_3300 0.988200
R393 n1_M2_35700_3300 n1_M2_36780_3300 0.988200
R394 n1_M2_36780_3300 n1_M2_37860_3300 0.988200
R395 n1_M2_37860_3300 n1_M2_38940_3300 0.988200
R396 n1_M2_38940_3300 n1_M2_40020_3300 0.988200
R397 n1_M2_40020_3300 n1_M2_41100_3300 0.988200
R398 n1_M2_41100_3300 n1_M2_42180_3300 0.988200
R399 n1_M2_42180_3300 n1_M2_43260_3300 0.988200
R400 n1_M2_43260_3300 n1_M2_44340_3300 0.988200
R401 n1_M2_44340_3300 n1_M2_45420_3300 0.988200
R402 n1_M2_45420_3300 n1_M2_46500_3300 0.988200
R403 n1_M2_46500_3300 n1_M2_47580_3300 0.988200
R404 n1_M2_47580_3300 n1_M2_48660_3300 0.988200
R405 n1_M2_48660_3300 n1_M2_49740_3300 0.988200
R406 n1_M2_49740_3300 n1_M2_50820_3300 0.988200
R407 n1_M2_50820_3300 n1_M2_51900_3300 0.988200
R408 n1_M2_51900_3300 n1_M2_52980_3300 0.988200
R409 n1_M2_52980_3300 n1_M2_54060_3300 0.988200
R410 n1_M2_54060_3300 n1_M2_55140_3300 0.988200
R411 n1_M2_55140_3300 n1_M2_56220_3300 0.988200
R412 n1_M2_56220_3300 n1_M2_57300_3300 0.988200
R413 n1_M2_57300_3300 n1_M2_58380_3300 0.988200
R414 n1_M2_58380_3300 n1_M2_59460_3300 0.988200
R415 n1_M2_59460_3300 n1_M2_60540_3300 0.988200
R416 n1_M2_60540_3300 n1_M2_61620_3300 0.988200
R417 n1_M2_61620_3300 n1_M2_62700_3300 0.988200
R418 n1_M2_62700_3300 n1_M2_63780_3300 0.988200
R419 n1_M2_63780_3300 n1_M2_64860_3300 0.988200
R420 n1_M2_64860_3300 n1_M2_65940_3300 0.988200
R421 n1_M2_65940_3300 n1_M2_67020_3300 0.988200
R422 n1_M2_67020_3300 n1_M2_68100_3300 0.988200
R423 n1_M2_68100_3300 n1_M2_69180_3300 0.988200
R424 n1_M2_69180_3300 n1_M2_70260_3300 0.988200
R425 n1_M2_70260_3300 n1_M2_71340_3300 0.988200
R426 n1_M2_71340_3300 n1_M2_72420_3300 0.988200
R427 n1_M2_72420_3300 n1_M2_73500_3300 0.988200
R428 n1_M2_73500_3300 n1_M2_74580_3300 0.988200
R429 n1_M2_74580_3300 n1_M2_75660_3300 0.988200
R430 n1_M2_75660_3300 n1_M2_76740_3300 0.988200
R431 n1_M2_76740_3300 n1_M2_77820_3300 0.988200
R432 n1_M2_77820_3300 n1_M2_78900_3300 0.988200
R433 n1_M2_78900_3300 n1_M2_79980_3300 0.988200
R434 n1_M2_79980_3300 n1_M2_81060_3300 0.988200
R435 n1_M2_81060_3300 n1_M2_82140_3300 0.988200
R436 n1_M2_82140_3300 n1_M2_83220_3300 0.988200
R437 n1_M2_83220_3300 n1_M2_84300_3300 0.988200
R438 n1_M2_84300_3300 n1_M2_85380_3300 0.988200
R439 n1_M2_85380_3300 n1_M2_86460_3300 0.988200
R440 n1_M2_86460_3300 n1_M2_87540_3300 0.988200
R441 n1_M2_87540_3300 n1_M2_88620_3300 0.988200
R442 n1_M2_88620_3300 n1_M2_89700_3300 0.988200
R443 n1_M2_89700_3300 n1_M2_90780_3300 0.988200
R444 n1_M2_90780_3300 n1_M2_91860_3300 0.988200
R445 n1_M2_91860_3300 n1_M2_92940_3300 0.988200
R446 n1_M2_92940_3300 n1_M2_94020_3300 0.988200
R447 n1_M2_94020_3300 n1_M2_95100_3300 0.988200
R448 n1_M2_95100_3300 n1_M2_96180_3300 0.988200
R449 n1_M2_96180_3300 n1_M2_97260_3300 0.988200
R450 n1_M2_97260_3300 n1_M2_98340_3300 0.988200
R451 n1_M2_98340_3300 n1_M2_99420_3300 0.988200
R452 n1_M2_99420_3300 n1_M2_100500_3300 0.988200
R453 n1_M2_100500_3300 n1_M2_101580_3300 0.988200
R454 n1_M2_101580_3300 n1_M2_102660_3300 0.988200
R455 n1_M2_102660_3300 n1_M2_103740_3300 0.988200
R456 n1_M2_103740_3300 n1_M2_104820_3300 0.988200
R457 n1_M2_104820_3300 n1_M2_105900_3300 0.988200
R458 n1_M2_105900_3300 n1_M2_106980_3300 0.988200
R459 n1_M2_106980_3300 n1_M2_108060_3300 0.988200
R460 n1_M2_108060_3300 n1_M2_109140_3300 0.988200
R461 n1_M2_109140_3300 n1_M2_110220_3300 0.988200
R462 n1_M2_110220_3300 n1_M2_111300_3300 0.988200
R463 n1_M2_111300_3300 n1_M2_112380_3300 0.988200
R464 n1_M2_112380_3300 n1_M2_113460_3300 0.988200
R465 n1_M2_113460_3300 n1_M2_114540_3300 0.988200
R466 n1_M2_114540_3300 n1_M2_115620_3300 0.988200
R467 n1_M2_115620_3300 n1_M2_116700_3300 0.988200
R468 n1_M2_116700_3300 n1_M2_117780_3300 0.988200
R469 n1_M2_117780_3300 n1_M2_118860_3300 0.988200
R470 n1_M2_118860_3300 n1_M2_119940_3300 0.988200
R471 n1_M2_119940_3300 n1_M2_121020_3300 0.988200
R472 n1_M2_121020_3300 n1_M2_122100_3300 0.988200
R473 n1_M2_122100_3300 n1_M2_123180_3300 0.988200
R474 n1_M2_123180_3300 n1_M2_124260_3300 0.988200
R475 n1_M2_124260_3300 n1_M2_125340_3300 0.988200
R476 n1_M2_125340_3300 n1_M2_126420_3300 0.988200
R477 n1_M2_126420_3300 n1_M2_127500_3300 0.988200
R478 n1_M2_127500_3300 n1_M2_128580_3300 0.988200
R479 n1_M2_128580_3300 n1_M2_129660_3300 0.988200
R480 n1_M2_60_4380 n1_M2_1140_4380 0.988200
R481 n1_M2_1140_4380 n1_M2_2220_4380 0.988200
R482 n1_M2_2220_4380 n1_M2_3300_4380 0.988200
R483 n1_M2_3300_4380 n1_M2_4380_4380 0.988200
R484 n1_M2_4380_4380 n1_M2_5460_4380 0.988200
R485 n1_M2_5460_4380 n1_M2_6540_4380 0.988200
R486 n1_M2_6540_4380 n1_M2_7620_4380 0.988200
R487 n1_M2_7620_4380 n1_M2_8700_4380 0.988200
R488 n1_M2_8700_4380 n1_M2_9780_4380 0.988200
R489 n1_M2_9780_4380 n1_M2_10860_4380 0.988200
R490 n1_M2_10860_4380 n1_M2_11940_4380 0.988200
R491 n1_M2_11940_4380 n1_M2_13020_4380 0.988200
R492 n1_M2_13020_4380 n1_M2_14100_4380 0.988200
R493 n1_M2_14100_4380 n1_M2_15180_4380 0.988200
R494 n1_M2_15180_4380 n1_M2_16260_4380 0.988200
R495 n1_M2_16260_4380 n1_M2_17340_4380 0.988200
R496 n1_M2_17340_4380 n1_M2_18420_4380 0.988200
R497 n1_M2_18420_4380 n1_M2_19500_4380 0.988200
R498 n1_M2_19500_4380 n1_M2_20580_4380 0.988200
R499 n1_M2_20580_4380 n1_M2_21660_4380 0.988200
R500 n1_M2_21660_4380 n1_M2_22740_4380 0.988200
R501 n1_M2_22740_4380 n1_M2_23820_4380 0.988200
R502 n1_M2_23820_4380 n1_M2_24900_4380 0.988200
R503 n1_M2_24900_4380 n1_M2_25980_4380 0.988200
R504 n1_M2_25980_4380 n1_M2_27060_4380 0.988200
R505 n1_M2_27060_4380 n1_M2_28140_4380 0.988200
R506 n1_M2_28140_4380 n1_M2_29220_4380 0.988200
R507 n1_M2_29220_4380 n1_M2_30300_4380 0.988200
R508 n1_M2_30300_4380 n1_M2_31380_4380 0.988200
R509 n1_M2_31380_4380 n1_M2_32460_4380 0.988200
R510 n1_M2_32460_4380 n1_M2_33540_4380 0.988200
R511 n1_M2_33540_4380 n1_M2_34620_4380 0.988200
R512 n1_M2_34620_4380 n1_M2_35700_4380 0.988200
R513 n1_M2_35700_4380 n1_M2_36780_4380 0.988200
R514 n1_M2_36780_4380 n1_M2_37860_4380 0.988200
R515 n1_M2_37860_4380 n1_M2_38940_4380 0.988200
R516 n1_M2_38940_4380 n1_M2_40020_4380 0.988200
R517 n1_M2_40020_4380 n1_M2_41100_4380 0.988200
R518 n1_M2_41100_4380 n1_M2_42180_4380 0.988200
R519 n1_M2_42180_4380 n1_M2_43260_4380 0.988200
R520 n1_M2_43260_4380 n1_M2_44340_4380 0.988200
R521 n1_M2_44340_4380 n1_M2_45420_4380 0.988200
R522 n1_M2_45420_4380 n1_M2_46500_4380 0.988200
R523 n1_M2_46500_4380 n1_M2_47580_4380 0.988200
R524 n1_M2_47580_4380 n1_M2_48660_4380 0.988200
R525 n1_M2_48660_4380 n1_M2_49740_4380 0.988200
R526 n1_M2_49740_4380 n1_M2_50820_4380 0.988200
R527 n1_M2_50820_4380 n1_M2_51900_4380 0.988200
R528 n1_M2_51900_4380 n1_M2_52980_4380 0.988200
R529 n1_M2_52980_4380 n1_M2_54060_4380 0.988200
R530 n1_M2_54060_4380 n1_M2_55140_4380 0.988200
R531 n1_M2_55140_4380 n1_M2_56220_4380 0.988200
R532 n1_M2_56220_4380 n1_M2_57300_4380 0.988200
R533 n1_M2_57300_4380 n1_M2_58380_4380 0.988200
R534 n1_M2_58380_4380 n1_M2_59460_4380 0.988200
R535 n1_M2_59460_4380 n1_M2_60540_4380 0.988200
R536 n1_M2_60540_4380 n1_M2_61620_4380 0.988200
R537 n1_M2_61620_4380 n1_M2_62700_4380 0.988200
R538 n1_M2_62700_4380 n1_M2_63780_4380 0.988200
R539 n1_M2_63780_4380 n1_M2_64860_4380 0.988200
R540 n1_M2_64860_4380 n1_M2_65940_4380 0.988200
R541 n1_M2_65940_4380 n1_M2_67020_4380 0.988200
R542 n1_M2_67020_4380 n1_M2_68100_4380 0.988200
R543 n1_M2_68100_4380 n1_M2_69180_4380 0.988200
R544 n1_M2_69180_4380 n1_M2_70260_4380 0.988200
R545 n1_M2_70260_4380 n1_M2_71340_4380 0.988200
R546 n1_M2_71340_4380 n1_M2_72420_4380 0.988200
R547 n1_M2_72420_4380 n1_M2_73500_4380 0.988200
R548 n1_M2_73500_4380 n1_M2_74580_4380 0.988200
R549 n1_M2_74580_4380 n1_M2_75660_4380 0.988200
R550 n1_M2_75660_4380 n1_M2_76740_4380 0.988200
R551 n1_M2_76740_4380 n1_M2_77820_4380 0.988200
R552 n1_M2_77820_4380 n1_M2_78900_4380 0.988200
R553 n1_M2_78900_4380 n1_M2_79980_4380 0.988200
R554 n1_M2_79980_4380 n1_M2_81060_4380 0.988200
R555 n1_M2_81060_4380 n1_M2_82140_4380 0.988200
R556 n1_M2_82140_4380 n1_M2_83220_4380 0.988200
R557 n1_M2_83220_4380 n1_M2_84300_4380 0.988200
R558 n1_M2_84300_4380 n1_M2_85380_4380 0.988200
R559 n1_M2_85380_4380 n1_M2_86460_4380 0.988200
R560 n1_M2_86460_4380 n1_M2_87540_4380 0.988200
R561 n1_M2_87540_4380 n1_M2_88620_4380 0.988200
R562 n1_M2_88620_4380 n1_M2_89700_4380 0.988200
R563 n1_M2_89700_4380 n1_M2_90780_4380 0.988200
R564 n1_M2_90780_4380 n1_M2_91860_4380 0.988200
R565 n1_M2_91860_4380 n1_M2_92940_4380 0.988200
R566 n1_M2_92940_4380 n1_M2_94020_4380 0.988200
R567 n1_M2_94020_4380 n1_M2_95100_4380 0.988200
R568 n1_M2_95100_4380 n1_M2_96180_4380 0.988200
R569 n1_M2_96180_4380 n1_M2_97260_4380 0.988200
R570 n1_M2_97260_4380 n1_M2_98340_4380 0.988200
R571 n1_M2_98340_4380 n1_M2_99420_4380 0.988200
R572 n1_M2_99420_4380 n1_M2_100500_4380 0.988200
R573 n1_M2_100500_4380 n1_M2_101580_4380 0.988200
R574 n1_M2_101580_4380 n1_M2_102660_4380 0.988200
R575 n1_M2_102660_4380 n1_M2_103740_4380 0.988200
R576 n1_M2_103740_4380 n1_M2_104820_4380 0.988200
R577 n1_M2_104820_4380 n1_M2_105900_4380 0.988200
R578 n1_M2_105900_4380 n1_M2_106980_4380 0.988200
R579 n1_M2_106980_4380 n1_M2_108060_4380 0.988200
R580 n1_M2_108060_4380 n1_M2_109140_4380 0.988200
R581 n1_M2_109140_4380 n1_M2_110220_4380 0.988200
R582 n1_M2_110220_4380 n1_M2_111300_4380 0.988200
R583 n1_M2_111300_4380 n1_M2_112380_4380 0.988200
R584 n1_M2_112380_4380 n1_M2_113460_4380 0.988200
R585 n1_M2_113460_4380 n1_M2_114540_4380 0.988200
R586 n1_M2_114540_4380 n1_M2_115620_4380 0.988200
R587 n1_M2_115620_4380 n1_M2_116700_4380 0.988200
R588 n1_M2_116700_4380 n1_M2_117780_4380 0.988200
R589 n1_M2_117780_4380 n1_M2_118860_4380 0.988200
R590 n1_M2_118860_4380 n1_M2_119940_4380 0.988200
R591 n1_M2_119940_4380 n1_M2_121020_4380 0.988200
R592 n1_M2_121020_4380 n1_M2_122100_4380 0.988200
R593 n1_M2_122100_4380 n1_M2_123180_4380 0.988200
R594 n1_M2_123180_4380 n1_M2_124260_4380 0.988200
R595 n1_M2_124260_4380 n1_M2_125340_4380 0.988200
R596 n1_M2_125340_4380 n1_M2_126420_4380 0.988200
R597 n1_M2_126420_4380 n1_M2_127500_4380 0.988200
R598 n1_M2_127500_4380 n1_M2_128580_4380 0.988200
R599 n1_M2_128580_4380 n1_M2_129660_4380 0.988200
R600 n1_M2_60_5460 n1_M2_1140_5460 0.988200
R601 n1_M2_1140_5460 n1_M2_2220_5460 0.988200
R602 n1_M2_2220_5460 n1_M2_3300_5460 0.988200
R603 n1_M2_3300_5460 n1_M2_4380_5460 0.988200
R604 n1_M2_4380_5460 n1_M2_5460_5460 0.988200
R605 n1_M2_5460_5460 n1_M2_6540_5460 0.988200
R606 n1_M2_6540_5460 n1_M2_7620_5460 0.988200
R607 n1_M2_7620_5460 n1_M2_8700_5460 0.988200
R608 n1_M2_8700_5460 n1_M2_9780_5460 0.988200
R609 n1_M2_9780_5460 n1_M2_10860_5460 0.988200
R610 n1_M2_10860_5460 n1_M2_11940_5460 0.988200
R611 n1_M2_11940_5460 n1_M2_13020_5460 0.988200
R612 n1_M2_13020_5460 n1_M2_14100_5460 0.988200
R613 n1_M2_14100_5460 n1_M2_15180_5460 0.988200
R614 n1_M2_15180_5460 n1_M2_16260_5460 0.988200
R615 n1_M2_16260_5460 n1_M2_17340_5460 0.988200
R616 n1_M2_17340_5460 n1_M2_18420_5460 0.988200
R617 n1_M2_18420_5460 n1_M2_19500_5460 0.988200
R618 n1_M2_19500_5460 n1_M2_20580_5460 0.988200
R619 n1_M2_20580_5460 n1_M2_21660_5460 0.988200
R620 n1_M2_21660_5460 n1_M2_22740_5460 0.988200
R621 n1_M2_22740_5460 n1_M2_23820_5460 0.988200
R622 n1_M2_23820_5460 n1_M2_24900_5460 0.988200
R623 n1_M2_24900_5460 n1_M2_25980_5460 0.988200
R624 n1_M2_25980_5460 n1_M2_27060_5460 0.988200
R625 n1_M2_27060_5460 n1_M2_28140_5460 0.988200
R626 n1_M2_28140_5460 n1_M2_29220_5460 0.988200
R627 n1_M2_29220_5460 n1_M2_30300_5460 0.988200
R628 n1_M2_30300_5460 n1_M2_31380_5460 0.988200
R629 n1_M2_31380_5460 n1_M2_32460_5460 0.988200
R630 n1_M2_32460_5460 n1_M2_33540_5460 0.988200
R631 n1_M2_33540_5460 n1_M2_34620_5460 0.988200
R632 n1_M2_34620_5460 n1_M2_35700_5460 0.988200
R633 n1_M2_35700_5460 n1_M2_36780_5460 0.988200
R634 n1_M2_36780_5460 n1_M2_37860_5460 0.988200
R635 n1_M2_37860_5460 n1_M2_38940_5460 0.988200
R636 n1_M2_38940_5460 n1_M2_40020_5460 0.988200
R637 n1_M2_40020_5460 n1_M2_41100_5460 0.988200
R638 n1_M2_41100_5460 n1_M2_42180_5460 0.988200
R639 n1_M2_42180_5460 n1_M2_43260_5460 0.988200
R640 n1_M2_43260_5460 n1_M2_44340_5460 0.988200
R641 n1_M2_44340_5460 n1_M2_45420_5460 0.988200
R642 n1_M2_45420_5460 n1_M2_46500_5460 0.988200
R643 n1_M2_46500_5460 n1_M2_47580_5460 0.988200
R644 n1_M2_47580_5460 n1_M2_48660_5460 0.988200
R645 n1_M2_48660_5460 n1_M2_49740_5460 0.988200
R646 n1_M2_49740_5460 n1_M2_50820_5460 0.988200
R647 n1_M2_50820_5460 n1_M2_51900_5460 0.988200
R648 n1_M2_51900_5460 n1_M2_52980_5460 0.988200
R649 n1_M2_52980_5460 n1_M2_54060_5460 0.988200
R650 n1_M2_54060_5460 n1_M2_55140_5460 0.988200
R651 n1_M2_55140_5460 n1_M2_56220_5460 0.988200
R652 n1_M2_56220_5460 n1_M2_57300_5460 0.988200
R653 n1_M2_57300_5460 n1_M2_58380_5460 0.988200
R654 n1_M2_58380_5460 n1_M2_59460_5460 0.988200
R655 n1_M2_59460_5460 n1_M2_60540_5460 0.988200
R656 n1_M2_60540_5460 n1_M2_61620_5460 0.988200
R657 n1_M2_61620_5460 n1_M2_62700_5460 0.988200
R658 n1_M2_62700_5460 n1_M2_63780_5460 0.988200
R659 n1_M2_63780_5460 n1_M2_64860_5460 0.988200
R660 n1_M2_64860_5460 n1_M2_65940_5460 0.988200
R661 n1_M2_65940_5460 n1_M2_67020_5460 0.988200
R662 n1_M2_67020_5460 n1_M2_68100_5460 0.988200
R663 n1_M2_68100_5460 n1_M2_69180_5460 0.988200
R664 n1_M2_69180_5460 n1_M2_70260_5460 0.988200
R665 n1_M2_70260_5460 n1_M2_71340_5460 0.988200
R666 n1_M2_71340_5460 n1_M2_72420_5460 0.988200
R667 n1_M2_72420_5460 n1_M2_73500_5460 0.988200
R668 n1_M2_73500_5460 n1_M2_74580_5460 0.988200
R669 n1_M2_74580_5460 n1_M2_75660_5460 0.988200
R670 n1_M2_75660_5460 n1_M2_76740_5460 0.988200
R671 n1_M2_76740_5460 n1_M2_77820_5460 0.988200
R672 n1_M2_77820_5460 n1_M2_78900_5460 0.988200
R673 n1_M2_78900_5460 n1_M2_79980_5460 0.988200
R674 n1_M2_79980_5460 n1_M2_81060_5460 0.988200
R675 n1_M2_81060_5460 n1_M2_82140_5460 0.988200
R676 n1_M2_82140_5460 n1_M2_83220_5460 0.988200
R677 n1_M2_83220_5460 n1_M2_84300_5460 0.988200
R678 n1_M2_84300_5460 n1_M2_85380_5460 0.988200
R679 n1_M2_85380_5460 n1_M2_86460_5460 0.988200
R680 n1_M2_86460_5460 n1_M2_87540_5460 0.988200
R681 n1_M2_87540_5460 n1_M2_88620_5460 0.988200
R682 n1_M2_88620_5460 n1_M2_89700_5460 0.988200
R683 n1_M2_89700_5460 n1_M2_90780_5460 0.988200
R684 n1_M2_90780_5460 n1_M2_91860_5460 0.988200
R685 n1_M2_91860_5460 n1_M2_92940_5460 0.988200
R686 n1_M2_92940_5460 n1_M2_94020_5460 0.988200
R687 n1_M2_94020_5460 n1_M2_95100_5460 0.988200
R688 n1_M2_95100_5460 n1_M2_96180_5460 0.988200
R689 n1_M2_96180_5460 n1_M2_97260_5460 0.988200
R690 n1_M2_97260_5460 n1_M2_98340_5460 0.988200
R691 n1_M2_98340_5460 n1_M2_99420_5460 0.988200
R692 n1_M2_99420_5460 n1_M2_100500_5460 0.988200
R693 n1_M2_100500_5460 n1_M2_101580_5460 0.988200
R694 n1_M2_101580_5460 n1_M2_102660_5460 0.988200
R695 n1_M2_102660_5460 n1_M2_103740_5460 0.988200
R696 n1_M2_103740_5460 n1_M2_104820_5460 0.988200
R697 n1_M2_104820_5460 n1_M2_105900_5460 0.988200
R698 n1_M2_105900_5460 n1_M2_106980_5460 0.988200
R699 n1_M2_106980_5460 n1_M2_108060_5460 0.988200
R700 n1_M2_108060_5460 n1_M2_109140_5460 0.988200
R701 n1_M2_109140_5460 n1_M2_110220_5460 0.988200
R702 n1_M2_110220_5460 n1_M2_111300_5460 0.988200
R703 n1_M2_111300_5460 n1_M2_112380_5460 0.988200
R704 n1_M2_112380_5460 n1_M2_113460_5460 0.988200
R705 n1_M2_113460_5460 n1_M2_114540_5460 0.988200
R706 n1_M2_114540_5460 n1_M2_115620_5460 0.988200
R707 n1_M2_115620_5460 n1_M2_116700_5460 0.988200
R708 n1_M2_116700_5460 n1_M2_117780_5460 0.988200
R709 n1_M2_117780_5460 n1_M2_118860_5460 0.988200
R710 n1_M2_118860_5460 n1_M2_119940_5460 0.988200
R711 n1_M2_119940_5460 n1_M2_121020_5460 0.988200
R712 n1_M2_121020_5460 n1_M2_122100_5460 0.988200
R713 n1_M2_122100_5460 n1_M2_123180_5460 0.988200
R714 n1_M2_123180_5460 n1_M2_124260_5460 0.988200
R715 n1_M2_124260_5460 n1_M2_125340_5460 0.988200
R716 n1_M2_125340_5460 n1_M2_126420_5460 0.988200
R717 n1_M2_126420_5460 n1_M2_127500_5460 0.988200
R718 n1_M2_127500_5460 n1_M2_128580_5460 0.988200
R719 n1_M2_128580_5460 n1_M2_129660_5460 0.988200
R720 n1_M2_60_6540 n1_M2_1140_6540 0.988200
R721 n1_M2_1140_6540 n1_M2_2220_6540 0.988200
R722 n1_M2_2220_6540 n1_M2_3300_6540 0.988200
R723 n1_M2_3300_6540 n1_M2_4380_6540 0.988200
R724 n1_M2_4380_6540 n1_M2_5460_6540 0.988200
R725 n1_M2_5460_6540 n1_M2_6540_6540 0.988200
R726 n1_M2_6540_6540 n1_M2_7620_6540 0.988200
R727 n1_M2_7620_6540 n1_M2_8700_6540 0.988200
R728 n1_M2_8700_6540 n1_M2_9780_6540 0.988200
R729 n1_M2_9780_6540 n1_M2_10860_6540 0.988200
R730 n1_M2_10860_6540 n1_M2_11940_6540 0.988200
R731 n1_M2_11940_6540 n1_M2_13020_6540 0.988200
R732 n1_M2_13020_6540 n1_M2_14100_6540 0.988200
R733 n1_M2_14100_6540 n1_M2_15180_6540 0.988200
R734 n1_M2_15180_6540 n1_M2_16260_6540 0.988200
R735 n1_M2_16260_6540 n1_M2_17340_6540 0.988200
R736 n1_M2_17340_6540 n1_M2_18420_6540 0.988200
R737 n1_M2_18420_6540 n1_M2_19500_6540 0.988200
R738 n1_M2_19500_6540 n1_M2_20580_6540 0.988200
R739 n1_M2_20580_6540 n1_M2_21660_6540 0.988200
R740 n1_M2_21660_6540 n1_M2_22740_6540 0.988200
R741 n1_M2_22740_6540 n1_M2_23820_6540 0.988200
R742 n1_M2_23820_6540 n1_M2_24900_6540 0.988200
R743 n1_M2_24900_6540 n1_M2_25980_6540 0.988200
R744 n1_M2_25980_6540 n1_M2_27060_6540 0.988200
R745 n1_M2_27060_6540 n1_M2_28140_6540 0.988200
R746 n1_M2_28140_6540 n1_M2_29220_6540 0.988200
R747 n1_M2_29220_6540 n1_M2_30300_6540 0.988200
R748 n1_M2_30300_6540 n1_M2_31380_6540 0.988200
R749 n1_M2_31380_6540 n1_M2_32460_6540 0.988200
R750 n1_M2_32460_6540 n1_M2_33540_6540 0.988200
R751 n1_M2_33540_6540 n1_M2_34620_6540 0.988200
R752 n1_M2_34620_6540 n1_M2_35700_6540 0.988200
R753 n1_M2_35700_6540 n1_M2_36780_6540 0.988200
R754 n1_M2_36780_6540 n1_M2_37860_6540 0.988200
R755 n1_M2_37860_6540 n1_M2_38940_6540 0.988200
R756 n1_M2_38940_6540 n1_M2_40020_6540 0.988200
R757 n1_M2_40020_6540 n1_M2_41100_6540 0.988200
R758 n1_M2_41100_6540 n1_M2_42180_6540 0.988200
R759 n1_M2_42180_6540 n1_M2_43260_6540 0.988200
R760 n1_M2_43260_6540 n1_M2_44340_6540 0.988200
R761 n1_M2_44340_6540 n1_M2_45420_6540 0.988200
R762 n1_M2_45420_6540 n1_M2_46500_6540 0.988200
R763 n1_M2_46500_6540 n1_M2_47580_6540 0.988200
R764 n1_M2_47580_6540 n1_M2_48660_6540 0.988200
R765 n1_M2_48660_6540 n1_M2_49740_6540 0.988200
R766 n1_M2_49740_6540 n1_M2_50820_6540 0.988200
R767 n1_M2_50820_6540 n1_M2_51900_6540 0.988200
R768 n1_M2_51900_6540 n1_M2_52980_6540 0.988200
R769 n1_M2_52980_6540 n1_M2_54060_6540 0.988200
R770 n1_M2_54060_6540 n1_M2_55140_6540 0.988200
R771 n1_M2_55140_6540 n1_M2_56220_6540 0.988200
R772 n1_M2_56220_6540 n1_M2_57300_6540 0.988200
R773 n1_M2_57300_6540 n1_M2_58380_6540 0.988200
R774 n1_M2_58380_6540 n1_M2_59460_6540 0.988200
R775 n1_M2_59460_6540 n1_M2_60540_6540 0.988200
R776 n1_M2_60540_6540 n1_M2_61620_6540 0.988200
R777 n1_M2_61620_6540 n1_M2_62700_6540 0.988200
R778 n1_M2_62700_6540 n1_M2_63780_6540 0.988200
R779 n1_M2_63780_6540 n1_M2_64860_6540 0.988200
R780 n1_M2_64860_6540 n1_M2_65940_6540 0.988200
R781 n1_M2_65940_6540 n1_M2_67020_6540 0.988200
R782 n1_M2_67020_6540 n1_M2_68100_6540 0.988200
R783 n1_M2_68100_6540 n1_M2_69180_6540 0.988200
R784 n1_M2_69180_6540 n1_M2_70260_6540 0.988200
R785 n1_M2_70260_6540 n1_M2_71340_6540 0.988200
R786 n1_M2_71340_6540 n1_M2_72420_6540 0.988200
R787 n1_M2_72420_6540 n1_M2_73500_6540 0.988200
R788 n1_M2_73500_6540 n1_M2_74580_6540 0.988200
R789 n1_M2_74580_6540 n1_M2_75660_6540 0.988200
R790 n1_M2_75660_6540 n1_M2_76740_6540 0.988200
R791 n1_M2_76740_6540 n1_M2_77820_6540 0.988200
R792 n1_M2_77820_6540 n1_M2_78900_6540 0.988200
R793 n1_M2_78900_6540 n1_M2_79980_6540 0.988200
R794 n1_M2_79980_6540 n1_M2_81060_6540 0.988200
R795 n1_M2_81060_6540 n1_M2_82140_6540 0.988200
R796 n1_M2_82140_6540 n1_M2_83220_6540 0.988200
R797 n1_M2_83220_6540 n1_M2_84300_6540 0.988200
R798 n1_M2_84300_6540 n1_M2_85380_6540 0.988200
R799 n1_M2_85380_6540 n1_M2_86460_6540 0.988200
R800 n1_M2_86460_6540 n1_M2_87540_6540 0.988200
R801 n1_M2_87540_6540 n1_M2_88620_6540 0.988200
R802 n1_M2_88620_6540 n1_M2_89700_6540 0.988200
R803 n1_M2_89700_6540 n1_M2_90780_6540 0.988200
R804 n1_M2_90780_6540 n1_M2_91860_6540 0.988200
R805 n1_M2_91860_6540 n1_M2_92940_6540 0.988200
R806 n1_M2_92940_6540 n1_M2_94020_6540 0.988200
R807 n1_M2_94020_6540 n1_M2_95100_6540 0.988200
R808 n1_M2_95100_6540 n1_M2_96180_6540 0.988200
R809 n1_M2_96180_6540 n1_M2_97260_6540 0.988200
R810 n1_M2_97260_6540 n1_M2_98340_6540 0.988200
R811 n1_M2_98340_6540 n1_M2_99420_6540 0.988200
R812 n1_M2_99420_6540 n1_M2_100500_6540 0.988200
R813 n1_M2_100500_6540 n1_M2_101580_6540 0.988200
R814 n1_M2_101580_6540 n1_M2_102660_6540 0.988200
R815 n1_M2_102660_6540 n1_M2_103740_6540 0.988200
R816 n1_M2_103740_6540 n1_M2_104820_6540 0.988200
R817 n1_M2_104820_6540 n1_M2_105900_6540 0.988200
R818 n1_M2_105900_6540 n1_M2_106980_6540 0.988200
R819 n1_M2_106980_6540 n1_M2_108060_6540 0.988200
R820 n1_M2_108060_6540 n1_M2_109140_6540 0.988200
R821 n1_M2_109140_6540 n1_M2_110220_6540 0.988200
R822 n1_M2_110220_6540 n1_M2_111300_6540 0.988200
R823 n1_M2_111300_6540 n1_M2_112380_6540 0.988200
R824 n1_M2_112380_6540 n1_M2_113460_6540 0.988200
R825 n1_M2_113460_6540 n1_M2_114540_6540 0.988200
R826 n1_M2_114540_6540 n1_M2_115620_6540 0.988200
R827 n1_M2_115620_6540 n1_M2_116700_6540 0.988200
R828 n1_M2_116700_6540 n1_M2_117780_6540 0.988200
R829 n1_M2_117780_6540 n1_M2_118860_6540 0.988200
R830 n1_M2_118860_6540 n1_M2_119940_6540 0.988200
R831 n1_M2_119940_6540 n1_M2_121020_6540 0.988200
R832 n1_M2_121020_6540 n1_M2_122100_6540 0.988200
R833 n1_M2_122100_6540 n1_M2_123180_6540 0.988200
R834 n1_M2_123180_6540 n1_M2_124260_6540 0.988200
R835 n1_M2_124260_6540 n1_M2_125340_6540 0.988200
R836 n1_M2_125340_6540 n1_M2_126420_6540 0.988200
R837 n1_M2_126420_6540 n1_M2_127500_6540 0.988200
R838 n1_M2_127500_6540 n1_M2_128580_6540 0.988200
R839 n1_M2_128580_6540 n1_M2_129660_6540 0.988200
R840 n1_M2_60_7620 n1_M2_1140_7620 0.988200
R841 n1_M2_1140_7620 n1_M2_2220_7620 0.988200
R842 n1_M2_2220_7620 n1_M2_3300_7620 0.988200
R843 n1_M2_3300_7620 n1_M2_4380_7620 0.988200
R844 n1_M2_4380_7620 n1_M2_5460_7620 0.988200
R845 n1_M2_5460_7620 n1_M2_6540_7620 0.988200
R846 n1_M2_6540_7620 n1_M2_7620_7620 0.988200
R847 n1_M2_7620_7620 n1_M2_8700_7620 0.988200
R848 n1_M2_8700_7620 n1_M2_9780_7620 0.988200
R849 n1_M2_9780_7620 n1_M2_10860_7620 0.988200
R850 n1_M2_10860_7620 n1_M2_11940_7620 0.988200
R851 n1_M2_11940_7620 n1_M2_13020_7620 0.988200
R852 n1_M2_13020_7620 n1_M2_14100_7620 0.988200
R853 n1_M2_14100_7620 n1_M2_15180_7620 0.988200
R854 n1_M2_15180_7620 n1_M2_16260_7620 0.988200
R855 n1_M2_16260_7620 n1_M2_17340_7620 0.988200
R856 n1_M2_17340_7620 n1_M2_18420_7620 0.988200
R857 n1_M2_18420_7620 n1_M2_19500_7620 0.988200
R858 n1_M2_19500_7620 n1_M2_20580_7620 0.988200
R859 n1_M2_20580_7620 n1_M2_21660_7620 0.988200
R860 n1_M2_21660_7620 n1_M2_22740_7620 0.988200
R861 n1_M2_22740_7620 n1_M2_23820_7620 0.988200
R862 n1_M2_23820_7620 n1_M2_24900_7620 0.988200
R863 n1_M2_24900_7620 n1_M2_25980_7620 0.988200
R864 n1_M2_25980_7620 n1_M2_27060_7620 0.988200
R865 n1_M2_27060_7620 n1_M2_28140_7620 0.988200
R866 n1_M2_28140_7620 n1_M2_29220_7620 0.988200
R867 n1_M2_29220_7620 n1_M2_30300_7620 0.988200
R868 n1_M2_30300_7620 n1_M2_31380_7620 0.988200
R869 n1_M2_31380_7620 n1_M2_32460_7620 0.988200
R870 n1_M2_32460_7620 n1_M2_33540_7620 0.988200
R871 n1_M2_33540_7620 n1_M2_34620_7620 0.988200
R872 n1_M2_34620_7620 n1_M2_35700_7620 0.988200
R873 n1_M2_35700_7620 n1_M2_36780_7620 0.988200
R874 n1_M2_36780_7620 n1_M2_37860_7620 0.988200
R875 n1_M2_37860_7620 n1_M2_38940_7620 0.988200
R876 n1_M2_38940_7620 n1_M2_40020_7620 0.988200
R877 n1_M2_40020_7620 n1_M2_41100_7620 0.988200
R878 n1_M2_41100_7620 n1_M2_42180_7620 0.988200
R879 n1_M2_42180_7620 n1_M2_43260_7620 0.988200
R880 n1_M2_43260_7620 n1_M2_44340_7620 0.988200
R881 n1_M2_44340_7620 n1_M2_45420_7620 0.988200
R882 n1_M2_45420_7620 n1_M2_46500_7620 0.988200
R883 n1_M2_46500_7620 n1_M2_47580_7620 0.988200
R884 n1_M2_47580_7620 n1_M2_48660_7620 0.988200
R885 n1_M2_48660_7620 n1_M2_49740_7620 0.988200
R886 n1_M2_49740_7620 n1_M2_50820_7620 0.988200
R887 n1_M2_50820_7620 n1_M2_51900_7620 0.988200
R888 n1_M2_51900_7620 n1_M2_52980_7620 0.988200
R889 n1_M2_52980_7620 n1_M2_54060_7620 0.988200
R890 n1_M2_54060_7620 n1_M2_55140_7620 0.988200
R891 n1_M2_55140_7620 n1_M2_56220_7620 0.988200
R892 n1_M2_56220_7620 n1_M2_57300_7620 0.988200
R893 n1_M2_57300_7620 n1_M2_58380_7620 0.988200
R894 n1_M2_58380_7620 n1_M2_59460_7620 0.988200
R895 n1_M2_59460_7620 n1_M2_60540_7620 0.988200
R896 n1_M2_60540_7620 n1_M2_61620_7620 0.988200
R897 n1_M2_61620_7620 n1_M2_62700_7620 0.988200
R898 n1_M2_62700_7620 n1_M2_63780_7620 0.988200
R899 n1_M2_63780_7620 n1_M2_64860_7620 0.988200
R900 n1_M2_64860_7620 n1_M2_65940_7620 0.988200
R901 n1_M2_65940_7620 n1_M2_67020_7620 0.988200
R902 n1_M2_67020_7620 n1_M2_68100_7620 0.988200
R903 n1_M2_68100_7620 n1_M2_69180_7620 0.988200
R904 n1_M2_69180_7620 n1_M2_70260_7620 0.988200
R905 n1_M2_70260_7620 n1_M2_71340_7620 0.988200
R906 n1_M2_71340_7620 n1_M2_72420_7620 0.988200
R907 n1_M2_72420_7620 n1_M2_73500_7620 0.988200
R908 n1_M2_73500_7620 n1_M2_74580_7620 0.988200
R909 n1_M2_74580_7620 n1_M2_75660_7620 0.988200
R910 n1_M2_75660_7620 n1_M2_76740_7620 0.988200
R911 n1_M2_76740_7620 n1_M2_77820_7620 0.988200
R912 n1_M2_77820_7620 n1_M2_78900_7620 0.988200
R913 n1_M2_78900_7620 n1_M2_79980_7620 0.988200
R914 n1_M2_79980_7620 n1_M2_81060_7620 0.988200
R915 n1_M2_81060_7620 n1_M2_82140_7620 0.988200
R916 n1_M2_82140_7620 n1_M2_83220_7620 0.988200
R917 n1_M2_83220_7620 n1_M2_84300_7620 0.988200
R918 n1_M2_84300_7620 n1_M2_85380_7620 0.988200
R919 n1_M2_85380_7620 n1_M2_86460_7620 0.988200
R920 n1_M2_86460_7620 n1_M2_87540_7620 0.988200
R921 n1_M2_87540_7620 n1_M2_88620_7620 0.988200
R922 n1_M2_88620_7620 n1_M2_89700_7620 0.988200
R923 n1_M2_89700_7620 n1_M2_90780_7620 0.988200
R924 n1_M2_90780_7620 n1_M2_91860_7620 0.988200
R925 n1_M2_91860_7620 n1_M2_92940_7620 0.988200
R926 n1_M2_92940_7620 n1_M2_94020_7620 0.988200
R927 n1_M2_94020_7620 n1_M2_95100_7620 0.988200
R928 n1_M2_95100_7620 n1_M2_96180_7620 0.988200
R929 n1_M2_96180_7620 n1_M2_97260_7620 0.988200
R930 n1_M2_97260_7620 n1_M2_98340_7620 0.988200
R931 n1_M2_98340_7620 n1_M2_99420_7620 0.988200
R932 n1_M2_99420_7620 n1_M2_100500_7620 0.988200
R933 n1_M2_100500_7620 n1_M2_101580_7620 0.988200
R934 n1_M2_101580_7620 n1_M2_102660_7620 0.988200
R935 n1_M2_102660_7620 n1_M2_103740_7620 0.988200
R936 n1_M2_103740_7620 n1_M2_104820_7620 0.988200
R937 n1_M2_104820_7620 n1_M2_105900_7620 0.988200
R938 n1_M2_105900_7620 n1_M2_106980_7620 0.988200
R939 n1_M2_106980_7620 n1_M2_108060_7620 0.988200
R940 n1_M2_108060_7620 n1_M2_109140_7620 0.988200
R941 n1_M2_109140_7620 n1_M2_110220_7620 0.988200
R942 n1_M2_110220_7620 n1_M2_111300_7620 0.988200
R943 n1_M2_111300_7620 n1_M2_112380_7620 0.988200
R944 n1_M2_112380_7620 n1_M2_113460_7620 0.988200
R945 n1_M2_113460_7620 n1_M2_114540_7620 0.988200
R946 n1_M2_114540_7620 n1_M2_115620_7620 0.988200
R947 n1_M2_115620_7620 n1_M2_116700_7620 0.988200
R948 n1_M2_116700_7620 n1_M2_117780_7620 0.988200
R949 n1_M2_117780_7620 n1_M2_118860_7620 0.988200
R950 n1_M2_118860_7620 n1_M2_119940_7620 0.988200
R951 n1_M2_119940_7620 n1_M2_121020_7620 0.988200
R952 n1_M2_121020_7620 n1_M2_122100_7620 0.988200
R953 n1_M2_122100_7620 n1_M2_123180_7620 0.988200
R954 n1_M2_123180_7620 n1_M2_124260_7620 0.988200
R955 n1_M2_124260_7620 n1_M2_125340_7620 0.988200
R956 n1_M2_125340_7620 n1_M2_126420_7620 0.988200
R957 n1_M2_126420_7620 n1_M2_127500_7620 0.988200
R958 n1_M2_127500_7620 n1_M2_128580_7620 0.988200
R959 n1_M2_128580_7620 n1_M2_129660_7620 0.988200
R960 n1_M2_60_8700 n1_M2_1140_8700 0.988200
R961 n1_M2_1140_8700 n1_M2_2220_8700 0.988200
R962 n1_M2_2220_8700 n1_M2_3300_8700 0.988200
R963 n1_M2_3300_8700 n1_M2_4380_8700 0.988200
R964 n1_M2_4380_8700 n1_M2_5460_8700 0.988200
R965 n1_M2_5460_8700 n1_M2_6540_8700 0.988200
R966 n1_M2_6540_8700 n1_M2_7620_8700 0.988200
R967 n1_M2_7620_8700 n1_M2_8700_8700 0.988200
R968 n1_M2_8700_8700 n1_M2_9780_8700 0.988200
R969 n1_M2_9780_8700 n1_M2_10860_8700 0.988200
R970 n1_M2_10860_8700 n1_M2_11940_8700 0.988200
R971 n1_M2_11940_8700 n1_M2_13020_8700 0.988200
R972 n1_M2_13020_8700 n1_M2_14100_8700 0.988200
R973 n1_M2_14100_8700 n1_M2_15180_8700 0.988200
R974 n1_M2_15180_8700 n1_M2_16260_8700 0.988200
R975 n1_M2_16260_8700 n1_M2_17340_8700 0.988200
R976 n1_M2_17340_8700 n1_M2_18420_8700 0.988200
R977 n1_M2_18420_8700 n1_M2_19500_8700 0.988200
R978 n1_M2_19500_8700 n1_M2_20580_8700 0.988200
R979 n1_M2_20580_8700 n1_M2_21660_8700 0.988200
R980 n1_M2_21660_8700 n1_M2_22740_8700 0.988200
R981 n1_M2_22740_8700 n1_M2_23820_8700 0.988200
R982 n1_M2_23820_8700 n1_M2_24900_8700 0.988200
R983 n1_M2_24900_8700 n1_M2_25980_8700 0.988200
R984 n1_M2_25980_8700 n1_M2_27060_8700 0.988200
R985 n1_M2_27060_8700 n1_M2_28140_8700 0.988200
R986 n1_M2_28140_8700 n1_M2_29220_8700 0.988200
R987 n1_M2_29220_8700 n1_M2_30300_8700 0.988200
R988 n1_M2_30300_8700 n1_M2_31380_8700 0.988200
R989 n1_M2_31380_8700 n1_M2_32460_8700 0.988200
R990 n1_M2_32460_8700 n1_M2_33540_8700 0.988200
R991 n1_M2_33540_8700 n1_M2_34620_8700 0.988200
R992 n1_M2_34620_8700 n1_M2_35700_8700 0.988200
R993 n1_M2_35700_8700 n1_M2_36780_8700 0.988200
R994 n1_M2_36780_8700 n1_M2_37860_8700 0.988200
R995 n1_M2_37860_8700 n1_M2_38940_8700 0.988200
R996 n1_M2_38940_8700 n1_M2_40020_8700 0.988200
R997 n1_M2_40020_8700 n1_M2_41100_8700 0.988200
R998 n1_M2_41100_8700 n1_M2_42180_8700 0.988200
R999 n1_M2_42180_8700 n1_M2_43260_8700 0.988200
R1000 n1_M2_43260_8700 n1_M2_44340_8700 0.988200
R1001 n1_M2_44340_8700 n1_M2_45420_8700 0.988200
R1002 n1_M2_45420_8700 n1_M2_46500_8700 0.988200
R1003 n1_M2_46500_8700 n1_M2_47580_8700 0.988200
R1004 n1_M2_47580_8700 n1_M2_48660_8700 0.988200
R1005 n1_M2_48660_8700 n1_M2_49740_8700 0.988200
R1006 n1_M2_49740_8700 n1_M2_50820_8700 0.988200
R1007 n1_M2_50820_8700 n1_M2_51900_8700 0.988200
R1008 n1_M2_51900_8700 n1_M2_52980_8700 0.988200
R1009 n1_M2_52980_8700 n1_M2_54060_8700 0.988200
R1010 n1_M2_54060_8700 n1_M2_55140_8700 0.988200
R1011 n1_M2_55140_8700 n1_M2_56220_8700 0.988200
R1012 n1_M2_56220_8700 n1_M2_57300_8700 0.988200
R1013 n1_M2_57300_8700 n1_M2_58380_8700 0.988200
R1014 n1_M2_58380_8700 n1_M2_59460_8700 0.988200
R1015 n1_M2_59460_8700 n1_M2_60540_8700 0.988200
R1016 n1_M2_60540_8700 n1_M2_61620_8700 0.988200
R1017 n1_M2_61620_8700 n1_M2_62700_8700 0.988200
R1018 n1_M2_62700_8700 n1_M2_63780_8700 0.988200
R1019 n1_M2_63780_8700 n1_M2_64860_8700 0.988200
R1020 n1_M2_64860_8700 n1_M2_65940_8700 0.988200
R1021 n1_M2_65940_8700 n1_M2_67020_8700 0.988200
R1022 n1_M2_67020_8700 n1_M2_68100_8700 0.988200
R1023 n1_M2_68100_8700 n1_M2_69180_8700 0.988200
R1024 n1_M2_69180_8700 n1_M2_70260_8700 0.988200
R1025 n1_M2_70260_8700 n1_M2_71340_8700 0.988200
R1026 n1_M2_71340_8700 n1_M2_72420_8700 0.988200
R1027 n1_M2_72420_8700 n1_M2_73500_8700 0.988200
R1028 n1_M2_73500_8700 n1_M2_74580_8700 0.988200
R1029 n1_M2_74580_8700 n1_M2_75660_8700 0.988200
R1030 n1_M2_75660_8700 n1_M2_76740_8700 0.988200
R1031 n1_M2_76740_8700 n1_M2_77820_8700 0.988200
R1032 n1_M2_77820_8700 n1_M2_78900_8700 0.988200
R1033 n1_M2_78900_8700 n1_M2_79980_8700 0.988200
R1034 n1_M2_79980_8700 n1_M2_81060_8700 0.988200
R1035 n1_M2_81060_8700 n1_M2_82140_8700 0.988200
R1036 n1_M2_82140_8700 n1_M2_83220_8700 0.988200
R1037 n1_M2_83220_8700 n1_M2_84300_8700 0.988200
R1038 n1_M2_84300_8700 n1_M2_85380_8700 0.988200
R1039 n1_M2_85380_8700 n1_M2_86460_8700 0.988200
R1040 n1_M2_86460_8700 n1_M2_87540_8700 0.988200
R1041 n1_M2_87540_8700 n1_M2_88620_8700 0.988200
R1042 n1_M2_88620_8700 n1_M2_89700_8700 0.988200
R1043 n1_M2_89700_8700 n1_M2_90780_8700 0.988200
R1044 n1_M2_90780_8700 n1_M2_91860_8700 0.988200
R1045 n1_M2_91860_8700 n1_M2_92940_8700 0.988200
R1046 n1_M2_92940_8700 n1_M2_94020_8700 0.988200
R1047 n1_M2_94020_8700 n1_M2_95100_8700 0.988200
R1048 n1_M2_95100_8700 n1_M2_96180_8700 0.988200
R1049 n1_M2_96180_8700 n1_M2_97260_8700 0.988200
R1050 n1_M2_97260_8700 n1_M2_98340_8700 0.988200
R1051 n1_M2_98340_8700 n1_M2_99420_8700 0.988200
R1052 n1_M2_99420_8700 n1_M2_100500_8700 0.988200
R1053 n1_M2_100500_8700 n1_M2_101580_8700 0.988200
R1054 n1_M2_101580_8700 n1_M2_102660_8700 0.988200
R1055 n1_M2_102660_8700 n1_M2_103740_8700 0.988200
R1056 n1_M2_103740_8700 n1_M2_104820_8700 0.988200
R1057 n1_M2_104820_8700 n1_M2_105900_8700 0.988200
R1058 n1_M2_105900_8700 n1_M2_106980_8700 0.988200
R1059 n1_M2_106980_8700 n1_M2_108060_8700 0.988200
R1060 n1_M2_108060_8700 n1_M2_109140_8700 0.988200
R1061 n1_M2_109140_8700 n1_M2_110220_8700 0.988200
R1062 n1_M2_110220_8700 n1_M2_111300_8700 0.988200
R1063 n1_M2_111300_8700 n1_M2_112380_8700 0.988200
R1064 n1_M2_112380_8700 n1_M2_113460_8700 0.988200
R1065 n1_M2_113460_8700 n1_M2_114540_8700 0.988200
R1066 n1_M2_114540_8700 n1_M2_115620_8700 0.988200
R1067 n1_M2_115620_8700 n1_M2_116700_8700 0.988200
R1068 n1_M2_116700_8700 n1_M2_117780_8700 0.988200
R1069 n1_M2_117780_8700 n1_M2_118860_8700 0.988200
R1070 n1_M2_118860_8700 n1_M2_119940_8700 0.988200
R1071 n1_M2_119940_8700 n1_M2_121020_8700 0.988200
R1072 n1_M2_121020_8700 n1_M2_122100_8700 0.988200
R1073 n1_M2_122100_8700 n1_M2_123180_8700 0.988200
R1074 n1_M2_123180_8700 n1_M2_124260_8700 0.988200
R1075 n1_M2_124260_8700 n1_M2_125340_8700 0.988200
R1076 n1_M2_125340_8700 n1_M2_126420_8700 0.988200
R1077 n1_M2_126420_8700 n1_M2_127500_8700 0.988200
R1078 n1_M2_127500_8700 n1_M2_128580_8700 0.988200
R1079 n1_M2_128580_8700 n1_M2_129660_8700 0.988200
R1080 n1_M2_60_9780 n1_M2_1140_9780 0.988200
R1081 n1_M2_1140_9780 n1_M2_2220_9780 0.988200
R1082 n1_M2_2220_9780 n1_M2_3300_9780 0.988200
R1083 n1_M2_3300_9780 n1_M2_4380_9780 0.988200
R1084 n1_M2_4380_9780 n1_M2_5460_9780 0.988200
R1085 n1_M2_5460_9780 n1_M2_6540_9780 0.988200
R1086 n1_M2_6540_9780 n1_M2_7620_9780 0.988200
R1087 n1_M2_7620_9780 n1_M2_8700_9780 0.988200
R1088 n1_M2_8700_9780 n1_M2_9780_9780 0.988200
R1089 n1_M2_9780_9780 n1_M2_10860_9780 0.988200
R1090 n1_M2_10860_9780 n1_M2_11940_9780 0.988200
R1091 n1_M2_11940_9780 n1_M2_13020_9780 0.988200
R1092 n1_M2_13020_9780 n1_M2_14100_9780 0.988200
R1093 n1_M2_14100_9780 n1_M2_15180_9780 0.988200
R1094 n1_M2_15180_9780 n1_M2_16260_9780 0.988200
R1095 n1_M2_16260_9780 n1_M2_17340_9780 0.988200
R1096 n1_M2_17340_9780 n1_M2_18420_9780 0.988200
R1097 n1_M2_18420_9780 n1_M2_19500_9780 0.988200
R1098 n1_M2_19500_9780 n1_M2_20580_9780 0.988200
R1099 n1_M2_20580_9780 n1_M2_21660_9780 0.988200
R1100 n1_M2_21660_9780 n1_M2_22740_9780 0.988200
R1101 n1_M2_22740_9780 n1_M2_23820_9780 0.988200
R1102 n1_M2_23820_9780 n1_M2_24900_9780 0.988200
R1103 n1_M2_24900_9780 n1_M2_25980_9780 0.988200
R1104 n1_M2_25980_9780 n1_M2_27060_9780 0.988200
R1105 n1_M2_27060_9780 n1_M2_28140_9780 0.988200
R1106 n1_M2_28140_9780 n1_M2_29220_9780 0.988200
R1107 n1_M2_29220_9780 n1_M2_30300_9780 0.988200
R1108 n1_M2_30300_9780 n1_M2_31380_9780 0.988200
R1109 n1_M2_31380_9780 n1_M2_32460_9780 0.988200
R1110 n1_M2_32460_9780 n1_M2_33540_9780 0.988200
R1111 n1_M2_33540_9780 n1_M2_34620_9780 0.988200
R1112 n1_M2_34620_9780 n1_M2_35700_9780 0.988200
R1113 n1_M2_35700_9780 n1_M2_36780_9780 0.988200
R1114 n1_M2_36780_9780 n1_M2_37860_9780 0.988200
R1115 n1_M2_37860_9780 n1_M2_38940_9780 0.988200
R1116 n1_M2_38940_9780 n1_M2_40020_9780 0.988200
R1117 n1_M2_40020_9780 n1_M2_41100_9780 0.988200
R1118 n1_M2_41100_9780 n1_M2_42180_9780 0.988200
R1119 n1_M2_42180_9780 n1_M2_43260_9780 0.988200
R1120 n1_M2_43260_9780 n1_M2_44340_9780 0.988200
R1121 n1_M2_44340_9780 n1_M2_45420_9780 0.988200
R1122 n1_M2_45420_9780 n1_M2_46500_9780 0.988200
R1123 n1_M2_46500_9780 n1_M2_47580_9780 0.988200
R1124 n1_M2_47580_9780 n1_M2_48660_9780 0.988200
R1125 n1_M2_48660_9780 n1_M2_49740_9780 0.988200
R1126 n1_M2_49740_9780 n1_M2_50820_9780 0.988200
R1127 n1_M2_50820_9780 n1_M2_51900_9780 0.988200
R1128 n1_M2_51900_9780 n1_M2_52980_9780 0.988200
R1129 n1_M2_52980_9780 n1_M2_54060_9780 0.988200
R1130 n1_M2_54060_9780 n1_M2_55140_9780 0.988200
R1131 n1_M2_55140_9780 n1_M2_56220_9780 0.988200
R1132 n1_M2_56220_9780 n1_M2_57300_9780 0.988200
R1133 n1_M2_57300_9780 n1_M2_58380_9780 0.988200
R1134 n1_M2_58380_9780 n1_M2_59460_9780 0.988200
R1135 n1_M2_59460_9780 n1_M2_60540_9780 0.988200
R1136 n1_M2_60540_9780 n1_M2_61620_9780 0.988200
R1137 n1_M2_61620_9780 n1_M2_62700_9780 0.988200
R1138 n1_M2_62700_9780 n1_M2_63780_9780 0.988200
R1139 n1_M2_63780_9780 n1_M2_64860_9780 0.988200
R1140 n1_M2_64860_9780 n1_M2_65940_9780 0.988200
R1141 n1_M2_65940_9780 n1_M2_67020_9780 0.988200
R1142 n1_M2_67020_9780 n1_M2_68100_9780 0.988200
R1143 n1_M2_68100_9780 n1_M2_69180_9780 0.988200
R1144 n1_M2_69180_9780 n1_M2_70260_9780 0.988200
R1145 n1_M2_70260_9780 n1_M2_71340_9780 0.988200
R1146 n1_M2_71340_9780 n1_M2_72420_9780 0.988200
R1147 n1_M2_72420_9780 n1_M2_73500_9780 0.988200
R1148 n1_M2_73500_9780 n1_M2_74580_9780 0.988200
R1149 n1_M2_74580_9780 n1_M2_75660_9780 0.988200
R1150 n1_M2_75660_9780 n1_M2_76740_9780 0.988200
R1151 n1_M2_76740_9780 n1_M2_77820_9780 0.988200
R1152 n1_M2_77820_9780 n1_M2_78900_9780 0.988200
R1153 n1_M2_78900_9780 n1_M2_79980_9780 0.988200
R1154 n1_M2_79980_9780 n1_M2_81060_9780 0.988200
R1155 n1_M2_81060_9780 n1_M2_82140_9780 0.988200
R1156 n1_M2_82140_9780 n1_M2_83220_9780 0.988200
R1157 n1_M2_83220_9780 n1_M2_84300_9780 0.988200
R1158 n1_M2_84300_9780 n1_M2_85380_9780 0.988200
R1159 n1_M2_85380_9780 n1_M2_86460_9780 0.988200
R1160 n1_M2_86460_9780 n1_M2_87540_9780 0.988200
R1161 n1_M2_87540_9780 n1_M2_88620_9780 0.988200
R1162 n1_M2_88620_9780 n1_M2_89700_9780 0.988200
R1163 n1_M2_89700_9780 n1_M2_90780_9780 0.988200
R1164 n1_M2_90780_9780 n1_M2_91860_9780 0.988200
R1165 n1_M2_91860_9780 n1_M2_92940_9780 0.988200
R1166 n1_M2_92940_9780 n1_M2_94020_9780 0.988200
R1167 n1_M2_94020_9780 n1_M2_95100_9780 0.988200
R1168 n1_M2_95100_9780 n1_M2_96180_9780 0.988200
R1169 n1_M2_96180_9780 n1_M2_97260_9780 0.988200
R1170 n1_M2_97260_9780 n1_M2_98340_9780 0.988200
R1171 n1_M2_98340_9780 n1_M2_99420_9780 0.988200
R1172 n1_M2_99420_9780 n1_M2_100500_9780 0.988200
R1173 n1_M2_100500_9780 n1_M2_101580_9780 0.988200
R1174 n1_M2_101580_9780 n1_M2_102660_9780 0.988200
R1175 n1_M2_102660_9780 n1_M2_103740_9780 0.988200
R1176 n1_M2_103740_9780 n1_M2_104820_9780 0.988200
R1177 n1_M2_104820_9780 n1_M2_105900_9780 0.988200
R1178 n1_M2_105900_9780 n1_M2_106980_9780 0.988200
R1179 n1_M2_106980_9780 n1_M2_108060_9780 0.988200
R1180 n1_M2_108060_9780 n1_M2_109140_9780 0.988200
R1181 n1_M2_109140_9780 n1_M2_110220_9780 0.988200
R1182 n1_M2_110220_9780 n1_M2_111300_9780 0.988200
R1183 n1_M2_111300_9780 n1_M2_112380_9780 0.988200
R1184 n1_M2_112380_9780 n1_M2_113460_9780 0.988200
R1185 n1_M2_113460_9780 n1_M2_114540_9780 0.988200
R1186 n1_M2_114540_9780 n1_M2_115620_9780 0.988200
R1187 n1_M2_115620_9780 n1_M2_116700_9780 0.988200
R1188 n1_M2_116700_9780 n1_M2_117780_9780 0.988200
R1189 n1_M2_117780_9780 n1_M2_118860_9780 0.988200
R1190 n1_M2_118860_9780 n1_M2_119940_9780 0.988200
R1191 n1_M2_119940_9780 n1_M2_121020_9780 0.988200
R1192 n1_M2_121020_9780 n1_M2_122100_9780 0.988200
R1193 n1_M2_122100_9780 n1_M2_123180_9780 0.988200
R1194 n1_M2_123180_9780 n1_M2_124260_9780 0.988200
R1195 n1_M2_124260_9780 n1_M2_125340_9780 0.988200
R1196 n1_M2_125340_9780 n1_M2_126420_9780 0.988200
R1197 n1_M2_126420_9780 n1_M2_127500_9780 0.988200
R1198 n1_M2_127500_9780 n1_M2_128580_9780 0.988200
R1199 n1_M2_128580_9780 n1_M2_129660_9780 0.988200
R1200 n1_M2_60_10860 n1_M2_1140_10860 0.988200
R1201 n1_M2_1140_10860 n1_M2_2220_10860 0.988200
R1202 n1_M2_2220_10860 n1_M2_3300_10860 0.988200
R1203 n1_M2_3300_10860 n1_M2_4380_10860 0.988200
R1204 n1_M2_4380_10860 n1_M2_5460_10860 0.988200
R1205 n1_M2_5460_10860 n1_M2_6540_10860 0.988200
R1206 n1_M2_6540_10860 n1_M2_7620_10860 0.988200
R1207 n1_M2_7620_10860 n1_M2_8700_10860 0.988200
R1208 n1_M2_8700_10860 n1_M2_9780_10860 0.988200
R1209 n1_M2_9780_10860 n1_M2_10860_10860 0.988200
R1210 n1_M2_10860_10860 n1_M2_11940_10860 0.988200
R1211 n1_M2_11940_10860 n1_M2_13020_10860 0.988200
R1212 n1_M2_13020_10860 n1_M2_14100_10860 0.988200
R1213 n1_M2_14100_10860 n1_M2_15180_10860 0.988200
R1214 n1_M2_15180_10860 n1_M2_16260_10860 0.988200
R1215 n1_M2_16260_10860 n1_M2_17340_10860 0.988200
R1216 n1_M2_17340_10860 n1_M2_18420_10860 0.988200
R1217 n1_M2_18420_10860 n1_M2_19500_10860 0.988200
R1218 n1_M2_19500_10860 n1_M2_20580_10860 0.988200
R1219 n1_M2_20580_10860 n1_M2_21660_10860 0.988200
R1220 n1_M2_21660_10860 n1_M2_22740_10860 0.988200
R1221 n1_M2_22740_10860 n1_M2_23820_10860 0.988200
R1222 n1_M2_23820_10860 n1_M2_24900_10860 0.988200
R1223 n1_M2_24900_10860 n1_M2_25980_10860 0.988200
R1224 n1_M2_25980_10860 n1_M2_27060_10860 0.988200
R1225 n1_M2_27060_10860 n1_M2_28140_10860 0.988200
R1226 n1_M2_28140_10860 n1_M2_29220_10860 0.988200
R1227 n1_M2_29220_10860 n1_M2_30300_10860 0.988200
R1228 n1_M2_30300_10860 n1_M2_31380_10860 0.988200
R1229 n1_M2_31380_10860 n1_M2_32460_10860 0.988200
R1230 n1_M2_32460_10860 n1_M2_33540_10860 0.988200
R1231 n1_M2_33540_10860 n1_M2_34620_10860 0.988200
R1232 n1_M2_34620_10860 n1_M2_35700_10860 0.988200
R1233 n1_M2_35700_10860 n1_M2_36780_10860 0.988200
R1234 n1_M2_36780_10860 n1_M2_37860_10860 0.988200
R1235 n1_M2_37860_10860 n1_M2_38940_10860 0.988200
R1236 n1_M2_38940_10860 n1_M2_40020_10860 0.988200
R1237 n1_M2_40020_10860 n1_M2_41100_10860 0.988200
R1238 n1_M2_41100_10860 n1_M2_42180_10860 0.988200
R1239 n1_M2_42180_10860 n1_M2_43260_10860 0.988200
R1240 n1_M2_43260_10860 n1_M2_44340_10860 0.988200
R1241 n1_M2_44340_10860 n1_M2_45420_10860 0.988200
R1242 n1_M2_45420_10860 n1_M2_46500_10860 0.988200
R1243 n1_M2_46500_10860 n1_M2_47580_10860 0.988200
R1244 n1_M2_47580_10860 n1_M2_48660_10860 0.988200
R1245 n1_M2_48660_10860 n1_M2_49740_10860 0.988200
R1246 n1_M2_49740_10860 n1_M2_50820_10860 0.988200
R1247 n1_M2_50820_10860 n1_M2_51900_10860 0.988200
R1248 n1_M2_51900_10860 n1_M2_52980_10860 0.988200
R1249 n1_M2_52980_10860 n1_M2_54060_10860 0.988200
R1250 n1_M2_54060_10860 n1_M2_55140_10860 0.988200
R1251 n1_M2_55140_10860 n1_M2_56220_10860 0.988200
R1252 n1_M2_56220_10860 n1_M2_57300_10860 0.988200
R1253 n1_M2_57300_10860 n1_M2_58380_10860 0.988200
R1254 n1_M2_58380_10860 n1_M2_59460_10860 0.988200
R1255 n1_M2_59460_10860 n1_M2_60540_10860 0.988200
R1256 n1_M2_60540_10860 n1_M2_61620_10860 0.988200
R1257 n1_M2_61620_10860 n1_M2_62700_10860 0.988200
R1258 n1_M2_62700_10860 n1_M2_63780_10860 0.988200
R1259 n1_M2_63780_10860 n1_M2_64860_10860 0.988200
R1260 n1_M2_64860_10860 n1_M2_65940_10860 0.988200
R1261 n1_M2_65940_10860 n1_M2_67020_10860 0.988200
R1262 n1_M2_67020_10860 n1_M2_68100_10860 0.988200
R1263 n1_M2_68100_10860 n1_M2_69180_10860 0.988200
R1264 n1_M2_69180_10860 n1_M2_70260_10860 0.988200
R1265 n1_M2_70260_10860 n1_M2_71340_10860 0.988200
R1266 n1_M2_71340_10860 n1_M2_72420_10860 0.988200
R1267 n1_M2_72420_10860 n1_M2_73500_10860 0.988200
R1268 n1_M2_73500_10860 n1_M2_74580_10860 0.988200
R1269 n1_M2_74580_10860 n1_M2_75660_10860 0.988200
R1270 n1_M2_75660_10860 n1_M2_76740_10860 0.988200
R1271 n1_M2_76740_10860 n1_M2_77820_10860 0.988200
R1272 n1_M2_77820_10860 n1_M2_78900_10860 0.988200
R1273 n1_M2_78900_10860 n1_M2_79980_10860 0.988200
R1274 n1_M2_79980_10860 n1_M2_81060_10860 0.988200
R1275 n1_M2_81060_10860 n1_M2_82140_10860 0.988200
R1276 n1_M2_82140_10860 n1_M2_83220_10860 0.988200
R1277 n1_M2_83220_10860 n1_M2_84300_10860 0.988200
R1278 n1_M2_84300_10860 n1_M2_85380_10860 0.988200
R1279 n1_M2_85380_10860 n1_M2_86460_10860 0.988200
R1280 n1_M2_86460_10860 n1_M2_87540_10860 0.988200
R1281 n1_M2_87540_10860 n1_M2_88620_10860 0.988200
R1282 n1_M2_88620_10860 n1_M2_89700_10860 0.988200
R1283 n1_M2_89700_10860 n1_M2_90780_10860 0.988200
R1284 n1_M2_90780_10860 n1_M2_91860_10860 0.988200
R1285 n1_M2_91860_10860 n1_M2_92940_10860 0.988200
R1286 n1_M2_92940_10860 n1_M2_94020_10860 0.988200
R1287 n1_M2_94020_10860 n1_M2_95100_10860 0.988200
R1288 n1_M2_95100_10860 n1_M2_96180_10860 0.988200
R1289 n1_M2_96180_10860 n1_M2_97260_10860 0.988200
R1290 n1_M2_97260_10860 n1_M2_98340_10860 0.988200
R1291 n1_M2_98340_10860 n1_M2_99420_10860 0.988200
R1292 n1_M2_99420_10860 n1_M2_100500_10860 0.988200
R1293 n1_M2_100500_10860 n1_M2_101580_10860 0.988200
R1294 n1_M2_101580_10860 n1_M2_102660_10860 0.988200
R1295 n1_M2_102660_10860 n1_M2_103740_10860 0.988200
R1296 n1_M2_103740_10860 n1_M2_104820_10860 0.988200
R1297 n1_M2_104820_10860 n1_M2_105900_10860 0.988200
R1298 n1_M2_105900_10860 n1_M2_106980_10860 0.988200
R1299 n1_M2_106980_10860 n1_M2_108060_10860 0.988200
R1300 n1_M2_108060_10860 n1_M2_109140_10860 0.988200
R1301 n1_M2_109140_10860 n1_M2_110220_10860 0.988200
R1302 n1_M2_110220_10860 n1_M2_111300_10860 0.988200
R1303 n1_M2_111300_10860 n1_M2_112380_10860 0.988200
R1304 n1_M2_112380_10860 n1_M2_113460_10860 0.988200
R1305 n1_M2_113460_10860 n1_M2_114540_10860 0.988200
R1306 n1_M2_114540_10860 n1_M2_115620_10860 0.988200
R1307 n1_M2_115620_10860 n1_M2_116700_10860 0.988200
R1308 n1_M2_116700_10860 n1_M2_117780_10860 0.988200
R1309 n1_M2_117780_10860 n1_M2_118860_10860 0.988200
R1310 n1_M2_118860_10860 n1_M2_119940_10860 0.988200
R1311 n1_M2_119940_10860 n1_M2_121020_10860 0.988200
R1312 n1_M2_121020_10860 n1_M2_122100_10860 0.988200
R1313 n1_M2_122100_10860 n1_M2_123180_10860 0.988200
R1314 n1_M2_123180_10860 n1_M2_124260_10860 0.988200
R1315 n1_M2_124260_10860 n1_M2_125340_10860 0.988200
R1316 n1_M2_125340_10860 n1_M2_126420_10860 0.988200
R1317 n1_M2_126420_10860 n1_M2_127500_10860 0.988200
R1318 n1_M2_127500_10860 n1_M2_128580_10860 0.988200
R1319 n1_M2_128580_10860 n1_M2_129660_10860 0.988200
R1320 n1_M2_60_11940 n1_M2_1140_11940 0.988200
R1321 n1_M2_1140_11940 n1_M2_2220_11940 0.988200
R1322 n1_M2_2220_11940 n1_M2_3300_11940 0.988200
R1323 n1_M2_3300_11940 n1_M2_4380_11940 0.988200
R1324 n1_M2_4380_11940 n1_M2_5460_11940 0.988200
R1325 n1_M2_5460_11940 n1_M2_6540_11940 0.988200
R1326 n1_M2_6540_11940 n1_M2_7620_11940 0.988200
R1327 n1_M2_7620_11940 n1_M2_8700_11940 0.988200
R1328 n1_M2_8700_11940 n1_M2_9780_11940 0.988200
R1329 n1_M2_9780_11940 n1_M2_10860_11940 0.988200
R1330 n1_M2_10860_11940 n1_M2_11940_11940 0.988200
R1331 n1_M2_11940_11940 n1_M2_13020_11940 0.988200
R1332 n1_M2_13020_11940 n1_M2_14100_11940 0.988200
R1333 n1_M2_14100_11940 n1_M2_15180_11940 0.988200
R1334 n1_M2_15180_11940 n1_M2_16260_11940 0.988200
R1335 n1_M2_16260_11940 n1_M2_17340_11940 0.988200
R1336 n1_M2_17340_11940 n1_M2_18420_11940 0.988200
R1337 n1_M2_18420_11940 n1_M2_19500_11940 0.988200
R1338 n1_M2_19500_11940 n1_M2_20580_11940 0.988200
R1339 n1_M2_20580_11940 n1_M2_21660_11940 0.988200
R1340 n1_M2_21660_11940 n1_M2_22740_11940 0.988200
R1341 n1_M2_22740_11940 n1_M2_23820_11940 0.988200
R1342 n1_M2_23820_11940 n1_M2_24900_11940 0.988200
R1343 n1_M2_24900_11940 n1_M2_25980_11940 0.988200
R1344 n1_M2_25980_11940 n1_M2_27060_11940 0.988200
R1345 n1_M2_27060_11940 n1_M2_28140_11940 0.988200
R1346 n1_M2_28140_11940 n1_M2_29220_11940 0.988200
R1347 n1_M2_29220_11940 n1_M2_30300_11940 0.988200
R1348 n1_M2_30300_11940 n1_M2_31380_11940 0.988200
R1349 n1_M2_31380_11940 n1_M2_32460_11940 0.988200
R1350 n1_M2_32460_11940 n1_M2_33540_11940 0.988200
R1351 n1_M2_33540_11940 n1_M2_34620_11940 0.988200
R1352 n1_M2_34620_11940 n1_M2_35700_11940 0.988200
R1353 n1_M2_35700_11940 n1_M2_36780_11940 0.988200
R1354 n1_M2_36780_11940 n1_M2_37860_11940 0.988200
R1355 n1_M2_37860_11940 n1_M2_38940_11940 0.988200
R1356 n1_M2_38940_11940 n1_M2_40020_11940 0.988200
R1357 n1_M2_40020_11940 n1_M2_41100_11940 0.988200
R1358 n1_M2_41100_11940 n1_M2_42180_11940 0.988200
R1359 n1_M2_42180_11940 n1_M2_43260_11940 0.988200
R1360 n1_M2_43260_11940 n1_M2_44340_11940 0.988200
R1361 n1_M2_44340_11940 n1_M2_45420_11940 0.988200
R1362 n1_M2_45420_11940 n1_M2_46500_11940 0.988200
R1363 n1_M2_46500_11940 n1_M2_47580_11940 0.988200
R1364 n1_M2_47580_11940 n1_M2_48660_11940 0.988200
R1365 n1_M2_48660_11940 n1_M2_49740_11940 0.988200
R1366 n1_M2_49740_11940 n1_M2_50820_11940 0.988200
R1367 n1_M2_50820_11940 n1_M2_51900_11940 0.988200
R1368 n1_M2_51900_11940 n1_M2_52980_11940 0.988200
R1369 n1_M2_52980_11940 n1_M2_54060_11940 0.988200
R1370 n1_M2_54060_11940 n1_M2_55140_11940 0.988200
R1371 n1_M2_55140_11940 n1_M2_56220_11940 0.988200
R1372 n1_M2_56220_11940 n1_M2_57300_11940 0.988200
R1373 n1_M2_57300_11940 n1_M2_58380_11940 0.988200
R1374 n1_M2_58380_11940 n1_M2_59460_11940 0.988200
R1375 n1_M2_59460_11940 n1_M2_60540_11940 0.988200
R1376 n1_M2_60540_11940 n1_M2_61620_11940 0.988200
R1377 n1_M2_61620_11940 n1_M2_62700_11940 0.988200
R1378 n1_M2_62700_11940 n1_M2_63780_11940 0.988200
R1379 n1_M2_63780_11940 n1_M2_64860_11940 0.988200
R1380 n1_M2_64860_11940 n1_M2_65940_11940 0.988200
R1381 n1_M2_65940_11940 n1_M2_67020_11940 0.988200
R1382 n1_M2_67020_11940 n1_M2_68100_11940 0.988200
R1383 n1_M2_68100_11940 n1_M2_69180_11940 0.988200
R1384 n1_M2_69180_11940 n1_M2_70260_11940 0.988200
R1385 n1_M2_70260_11940 n1_M2_71340_11940 0.988200
R1386 n1_M2_71340_11940 n1_M2_72420_11940 0.988200
R1387 n1_M2_72420_11940 n1_M2_73500_11940 0.988200
R1388 n1_M2_73500_11940 n1_M2_74580_11940 0.988200
R1389 n1_M2_74580_11940 n1_M2_75660_11940 0.988200
R1390 n1_M2_75660_11940 n1_M2_76740_11940 0.988200
R1391 n1_M2_76740_11940 n1_M2_77820_11940 0.988200
R1392 n1_M2_77820_11940 n1_M2_78900_11940 0.988200
R1393 n1_M2_78900_11940 n1_M2_79980_11940 0.988200
R1394 n1_M2_79980_11940 n1_M2_81060_11940 0.988200
R1395 n1_M2_81060_11940 n1_M2_82140_11940 0.988200
R1396 n1_M2_82140_11940 n1_M2_83220_11940 0.988200
R1397 n1_M2_83220_11940 n1_M2_84300_11940 0.988200
R1398 n1_M2_84300_11940 n1_M2_85380_11940 0.988200
R1399 n1_M2_85380_11940 n1_M2_86460_11940 0.988200
R1400 n1_M2_86460_11940 n1_M2_87540_11940 0.988200
R1401 n1_M2_87540_11940 n1_M2_88620_11940 0.988200
R1402 n1_M2_88620_11940 n1_M2_89700_11940 0.988200
R1403 n1_M2_89700_11940 n1_M2_90780_11940 0.988200
R1404 n1_M2_90780_11940 n1_M2_91860_11940 0.988200
R1405 n1_M2_91860_11940 n1_M2_92940_11940 0.988200
R1406 n1_M2_92940_11940 n1_M2_94020_11940 0.988200
R1407 n1_M2_94020_11940 n1_M2_95100_11940 0.988200
R1408 n1_M2_95100_11940 n1_M2_96180_11940 0.988200
R1409 n1_M2_96180_11940 n1_M2_97260_11940 0.988200
R1410 n1_M2_97260_11940 n1_M2_98340_11940 0.988200
R1411 n1_M2_98340_11940 n1_M2_99420_11940 0.988200
R1412 n1_M2_99420_11940 n1_M2_100500_11940 0.988200
R1413 n1_M2_100500_11940 n1_M2_101580_11940 0.988200
R1414 n1_M2_101580_11940 n1_M2_102660_11940 0.988200
R1415 n1_M2_102660_11940 n1_M2_103740_11940 0.988200
R1416 n1_M2_103740_11940 n1_M2_104820_11940 0.988200
R1417 n1_M2_104820_11940 n1_M2_105900_11940 0.988200
R1418 n1_M2_105900_11940 n1_M2_106980_11940 0.988200
R1419 n1_M2_106980_11940 n1_M2_108060_11940 0.988200
R1420 n1_M2_108060_11940 n1_M2_109140_11940 0.988200
R1421 n1_M2_109140_11940 n1_M2_110220_11940 0.988200
R1422 n1_M2_110220_11940 n1_M2_111300_11940 0.988200
R1423 n1_M2_111300_11940 n1_M2_112380_11940 0.988200
R1424 n1_M2_112380_11940 n1_M2_113460_11940 0.988200
R1425 n1_M2_113460_11940 n1_M2_114540_11940 0.988200
R1426 n1_M2_114540_11940 n1_M2_115620_11940 0.988200
R1427 n1_M2_115620_11940 n1_M2_116700_11940 0.988200
R1428 n1_M2_116700_11940 n1_M2_117780_11940 0.988200
R1429 n1_M2_117780_11940 n1_M2_118860_11940 0.988200
R1430 n1_M2_118860_11940 n1_M2_119940_11940 0.988200
R1431 n1_M2_119940_11940 n1_M2_121020_11940 0.988200
R1432 n1_M2_121020_11940 n1_M2_122100_11940 0.988200
R1433 n1_M2_122100_11940 n1_M2_123180_11940 0.988200
R1434 n1_M2_123180_11940 n1_M2_124260_11940 0.988200
R1435 n1_M2_124260_11940 n1_M2_125340_11940 0.988200
R1436 n1_M2_125340_11940 n1_M2_126420_11940 0.988200
R1437 n1_M2_126420_11940 n1_M2_127500_11940 0.988200
R1438 n1_M2_127500_11940 n1_M2_128580_11940 0.988200
R1439 n1_M2_128580_11940 n1_M2_129660_11940 0.988200
R1440 n1_M2_60_13020 n1_M2_1140_13020 0.988200
R1441 n1_M2_1140_13020 n1_M2_2220_13020 0.988200
R1442 n1_M2_2220_13020 n1_M2_3300_13020 0.988200
R1443 n1_M2_3300_13020 n1_M2_4380_13020 0.988200
R1444 n1_M2_4380_13020 n1_M2_5460_13020 0.988200
R1445 n1_M2_5460_13020 n1_M2_6540_13020 0.988200
R1446 n1_M2_6540_13020 n1_M2_7620_13020 0.988200
R1447 n1_M2_7620_13020 n1_M2_8700_13020 0.988200
R1448 n1_M2_8700_13020 n1_M2_9780_13020 0.988200
R1449 n1_M2_9780_13020 n1_M2_10860_13020 0.988200
R1450 n1_M2_10860_13020 n1_M2_11940_13020 0.988200
R1451 n1_M2_11940_13020 n1_M2_13020_13020 0.988200
R1452 n1_M2_13020_13020 n1_M2_14100_13020 0.988200
R1453 n1_M2_14100_13020 n1_M2_15180_13020 0.988200
R1454 n1_M2_15180_13020 n1_M2_16260_13020 0.988200
R1455 n1_M2_16260_13020 n1_M2_17340_13020 0.988200
R1456 n1_M2_17340_13020 n1_M2_18420_13020 0.988200
R1457 n1_M2_18420_13020 n1_M2_19500_13020 0.988200
R1458 n1_M2_19500_13020 n1_M2_20580_13020 0.988200
R1459 n1_M2_20580_13020 n1_M2_21660_13020 0.988200
R1460 n1_M2_21660_13020 n1_M2_22740_13020 0.988200
R1461 n1_M2_22740_13020 n1_M2_23820_13020 0.988200
R1462 n1_M2_23820_13020 n1_M2_24900_13020 0.988200
R1463 n1_M2_24900_13020 n1_M2_25980_13020 0.988200
R1464 n1_M2_25980_13020 n1_M2_27060_13020 0.988200
R1465 n1_M2_27060_13020 n1_M2_28140_13020 0.988200
R1466 n1_M2_28140_13020 n1_M2_29220_13020 0.988200
R1467 n1_M2_29220_13020 n1_M2_30300_13020 0.988200
R1468 n1_M2_30300_13020 n1_M2_31380_13020 0.988200
R1469 n1_M2_31380_13020 n1_M2_32460_13020 0.988200
R1470 n1_M2_32460_13020 n1_M2_33540_13020 0.988200
R1471 n1_M2_33540_13020 n1_M2_34620_13020 0.988200
R1472 n1_M2_34620_13020 n1_M2_35700_13020 0.988200
R1473 n1_M2_35700_13020 n1_M2_36780_13020 0.988200
R1474 n1_M2_36780_13020 n1_M2_37860_13020 0.988200
R1475 n1_M2_37860_13020 n1_M2_38940_13020 0.988200
R1476 n1_M2_38940_13020 n1_M2_40020_13020 0.988200
R1477 n1_M2_40020_13020 n1_M2_41100_13020 0.988200
R1478 n1_M2_41100_13020 n1_M2_42180_13020 0.988200
R1479 n1_M2_42180_13020 n1_M2_43260_13020 0.988200
R1480 n1_M2_43260_13020 n1_M2_44340_13020 0.988200
R1481 n1_M2_44340_13020 n1_M2_45420_13020 0.988200
R1482 n1_M2_45420_13020 n1_M2_46500_13020 0.988200
R1483 n1_M2_46500_13020 n1_M2_47580_13020 0.988200
R1484 n1_M2_47580_13020 n1_M2_48660_13020 0.988200
R1485 n1_M2_48660_13020 n1_M2_49740_13020 0.988200
R1486 n1_M2_49740_13020 n1_M2_50820_13020 0.988200
R1487 n1_M2_50820_13020 n1_M2_51900_13020 0.988200
R1488 n1_M2_51900_13020 n1_M2_52980_13020 0.988200
R1489 n1_M2_52980_13020 n1_M2_54060_13020 0.988200
R1490 n1_M2_54060_13020 n1_M2_55140_13020 0.988200
R1491 n1_M2_55140_13020 n1_M2_56220_13020 0.988200
R1492 n1_M2_56220_13020 n1_M2_57300_13020 0.988200
R1493 n1_M2_57300_13020 n1_M2_58380_13020 0.988200
R1494 n1_M2_58380_13020 n1_M2_59460_13020 0.988200
R1495 n1_M2_59460_13020 n1_M2_60540_13020 0.988200
R1496 n1_M2_60540_13020 n1_M2_61620_13020 0.988200
R1497 n1_M2_61620_13020 n1_M2_62700_13020 0.988200
R1498 n1_M2_62700_13020 n1_M2_63780_13020 0.988200
R1499 n1_M2_63780_13020 n1_M2_64860_13020 0.988200
R1500 n1_M2_64860_13020 n1_M2_65940_13020 0.988200
R1501 n1_M2_65940_13020 n1_M2_67020_13020 0.988200
R1502 n1_M2_67020_13020 n1_M2_68100_13020 0.988200
R1503 n1_M2_68100_13020 n1_M2_69180_13020 0.988200
R1504 n1_M2_69180_13020 n1_M2_70260_13020 0.988200
R1505 n1_M2_70260_13020 n1_M2_71340_13020 0.988200
R1506 n1_M2_71340_13020 n1_M2_72420_13020 0.988200
R1507 n1_M2_72420_13020 n1_M2_73500_13020 0.988200
R1508 n1_M2_73500_13020 n1_M2_74580_13020 0.988200
R1509 n1_M2_74580_13020 n1_M2_75660_13020 0.988200
R1510 n1_M2_75660_13020 n1_M2_76740_13020 0.988200
R1511 n1_M2_76740_13020 n1_M2_77820_13020 0.988200
R1512 n1_M2_77820_13020 n1_M2_78900_13020 0.988200
R1513 n1_M2_78900_13020 n1_M2_79980_13020 0.988200
R1514 n1_M2_79980_13020 n1_M2_81060_13020 0.988200
R1515 n1_M2_81060_13020 n1_M2_82140_13020 0.988200
R1516 n1_M2_82140_13020 n1_M2_83220_13020 0.988200
R1517 n1_M2_83220_13020 n1_M2_84300_13020 0.988200
R1518 n1_M2_84300_13020 n1_M2_85380_13020 0.988200
R1519 n1_M2_85380_13020 n1_M2_86460_13020 0.988200
R1520 n1_M2_86460_13020 n1_M2_87540_13020 0.988200
R1521 n1_M2_87540_13020 n1_M2_88620_13020 0.988200
R1522 n1_M2_88620_13020 n1_M2_89700_13020 0.988200
R1523 n1_M2_89700_13020 n1_M2_90780_13020 0.988200
R1524 n1_M2_90780_13020 n1_M2_91860_13020 0.988200
R1525 n1_M2_91860_13020 n1_M2_92940_13020 0.988200
R1526 n1_M2_92940_13020 n1_M2_94020_13020 0.988200
R1527 n1_M2_94020_13020 n1_M2_95100_13020 0.988200
R1528 n1_M2_95100_13020 n1_M2_96180_13020 0.988200
R1529 n1_M2_96180_13020 n1_M2_97260_13020 0.988200
R1530 n1_M2_97260_13020 n1_M2_98340_13020 0.988200
R1531 n1_M2_98340_13020 n1_M2_99420_13020 0.988200
R1532 n1_M2_99420_13020 n1_M2_100500_13020 0.988200
R1533 n1_M2_100500_13020 n1_M2_101580_13020 0.988200
R1534 n1_M2_101580_13020 n1_M2_102660_13020 0.988200
R1535 n1_M2_102660_13020 n1_M2_103740_13020 0.988200
R1536 n1_M2_103740_13020 n1_M2_104820_13020 0.988200
R1537 n1_M2_104820_13020 n1_M2_105900_13020 0.988200
R1538 n1_M2_105900_13020 n1_M2_106980_13020 0.988200
R1539 n1_M2_106980_13020 n1_M2_108060_13020 0.988200
R1540 n1_M2_108060_13020 n1_M2_109140_13020 0.988200
R1541 n1_M2_109140_13020 n1_M2_110220_13020 0.988200
R1542 n1_M2_110220_13020 n1_M2_111300_13020 0.988200
R1543 n1_M2_111300_13020 n1_M2_112380_13020 0.988200
R1544 n1_M2_112380_13020 n1_M2_113460_13020 0.988200
R1545 n1_M2_113460_13020 n1_M2_114540_13020 0.988200
R1546 n1_M2_114540_13020 n1_M2_115620_13020 0.988200
R1547 n1_M2_115620_13020 n1_M2_116700_13020 0.988200
R1548 n1_M2_116700_13020 n1_M2_117780_13020 0.988200
R1549 n1_M2_117780_13020 n1_M2_118860_13020 0.988200
R1550 n1_M2_118860_13020 n1_M2_119940_13020 0.988200
R1551 n1_M2_119940_13020 n1_M2_121020_13020 0.988200
R1552 n1_M2_121020_13020 n1_M2_122100_13020 0.988200
R1553 n1_M2_122100_13020 n1_M2_123180_13020 0.988200
R1554 n1_M2_123180_13020 n1_M2_124260_13020 0.988200
R1555 n1_M2_124260_13020 n1_M2_125340_13020 0.988200
R1556 n1_M2_125340_13020 n1_M2_126420_13020 0.988200
R1557 n1_M2_126420_13020 n1_M2_127500_13020 0.988200
R1558 n1_M2_127500_13020 n1_M2_128580_13020 0.988200
R1559 n1_M2_128580_13020 n1_M2_129660_13020 0.988200
R1560 n1_M2_60_14100 n1_M2_1140_14100 0.988200
R1561 n1_M2_1140_14100 n1_M2_2220_14100 0.988200
R1562 n1_M2_2220_14100 n1_M2_3300_14100 0.988200
R1563 n1_M2_3300_14100 n1_M2_4380_14100 0.988200
R1564 n1_M2_4380_14100 n1_M2_5460_14100 0.988200
R1565 n1_M2_5460_14100 n1_M2_6540_14100 0.988200
R1566 n1_M2_6540_14100 n1_M2_7620_14100 0.988200
R1567 n1_M2_7620_14100 n1_M2_8700_14100 0.988200
R1568 n1_M2_8700_14100 n1_M2_9780_14100 0.988200
R1569 n1_M2_9780_14100 n1_M2_10860_14100 0.988200
R1570 n1_M2_10860_14100 n1_M2_11940_14100 0.988200
R1571 n1_M2_11940_14100 n1_M2_13020_14100 0.988200
R1572 n1_M2_13020_14100 n1_M2_14100_14100 0.988200
R1573 n1_M2_14100_14100 n1_M2_15180_14100 0.988200
R1574 n1_M2_15180_14100 n1_M2_16260_14100 0.988200
R1575 n1_M2_16260_14100 n1_M2_17340_14100 0.988200
R1576 n1_M2_17340_14100 n1_M2_18420_14100 0.988200
R1577 n1_M2_18420_14100 n1_M2_19500_14100 0.988200
R1578 n1_M2_19500_14100 n1_M2_20580_14100 0.988200
R1579 n1_M2_20580_14100 n1_M2_21660_14100 0.988200
R1580 n1_M2_21660_14100 n1_M2_22740_14100 0.988200
R1581 n1_M2_22740_14100 n1_M2_23820_14100 0.988200
R1582 n1_M2_23820_14100 n1_M2_24900_14100 0.988200
R1583 n1_M2_24900_14100 n1_M2_25980_14100 0.988200
R1584 n1_M2_25980_14100 n1_M2_27060_14100 0.988200
R1585 n1_M2_27060_14100 n1_M2_28140_14100 0.988200
R1586 n1_M2_28140_14100 n1_M2_29220_14100 0.988200
R1587 n1_M2_29220_14100 n1_M2_30300_14100 0.988200
R1588 n1_M2_30300_14100 n1_M2_31380_14100 0.988200
R1589 n1_M2_31380_14100 n1_M2_32460_14100 0.988200
R1590 n1_M2_32460_14100 n1_M2_33540_14100 0.988200
R1591 n1_M2_33540_14100 n1_M2_34620_14100 0.988200
R1592 n1_M2_34620_14100 n1_M2_35700_14100 0.988200
R1593 n1_M2_35700_14100 n1_M2_36780_14100 0.988200
R1594 n1_M2_36780_14100 n1_M2_37860_14100 0.988200
R1595 n1_M2_37860_14100 n1_M2_38940_14100 0.988200
R1596 n1_M2_38940_14100 n1_M2_40020_14100 0.988200
R1597 n1_M2_40020_14100 n1_M2_41100_14100 0.988200
R1598 n1_M2_41100_14100 n1_M2_42180_14100 0.988200
R1599 n1_M2_42180_14100 n1_M2_43260_14100 0.988200
R1600 n1_M2_43260_14100 n1_M2_44340_14100 0.988200
R1601 n1_M2_44340_14100 n1_M2_45420_14100 0.988200
R1602 n1_M2_45420_14100 n1_M2_46500_14100 0.988200
R1603 n1_M2_46500_14100 n1_M2_47580_14100 0.988200
R1604 n1_M2_47580_14100 n1_M2_48660_14100 0.988200
R1605 n1_M2_48660_14100 n1_M2_49740_14100 0.988200
R1606 n1_M2_49740_14100 n1_M2_50820_14100 0.988200
R1607 n1_M2_50820_14100 n1_M2_51900_14100 0.988200
R1608 n1_M2_51900_14100 n1_M2_52980_14100 0.988200
R1609 n1_M2_52980_14100 n1_M2_54060_14100 0.988200
R1610 n1_M2_54060_14100 n1_M2_55140_14100 0.988200
R1611 n1_M2_55140_14100 n1_M2_56220_14100 0.988200
R1612 n1_M2_56220_14100 n1_M2_57300_14100 0.988200
R1613 n1_M2_57300_14100 n1_M2_58380_14100 0.988200
R1614 n1_M2_58380_14100 n1_M2_59460_14100 0.988200
R1615 n1_M2_59460_14100 n1_M2_60540_14100 0.988200
R1616 n1_M2_60540_14100 n1_M2_61620_14100 0.988200
R1617 n1_M2_61620_14100 n1_M2_62700_14100 0.988200
R1618 n1_M2_62700_14100 n1_M2_63780_14100 0.988200
R1619 n1_M2_63780_14100 n1_M2_64860_14100 0.988200
R1620 n1_M2_64860_14100 n1_M2_65940_14100 0.988200
R1621 n1_M2_65940_14100 n1_M2_67020_14100 0.988200
R1622 n1_M2_67020_14100 n1_M2_68100_14100 0.988200
R1623 n1_M2_68100_14100 n1_M2_69180_14100 0.988200
R1624 n1_M2_69180_14100 n1_M2_70260_14100 0.988200
R1625 n1_M2_70260_14100 n1_M2_71340_14100 0.988200
R1626 n1_M2_71340_14100 n1_M2_72420_14100 0.988200
R1627 n1_M2_72420_14100 n1_M2_73500_14100 0.988200
R1628 n1_M2_73500_14100 n1_M2_74580_14100 0.988200
R1629 n1_M2_74580_14100 n1_M2_75660_14100 0.988200
R1630 n1_M2_75660_14100 n1_M2_76740_14100 0.988200
R1631 n1_M2_76740_14100 n1_M2_77820_14100 0.988200
R1632 n1_M2_77820_14100 n1_M2_78900_14100 0.988200
R1633 n1_M2_78900_14100 n1_M2_79980_14100 0.988200
R1634 n1_M2_79980_14100 n1_M2_81060_14100 0.988200
R1635 n1_M2_81060_14100 n1_M2_82140_14100 0.988200
R1636 n1_M2_82140_14100 n1_M2_83220_14100 0.988200
R1637 n1_M2_83220_14100 n1_M2_84300_14100 0.988200
R1638 n1_M2_84300_14100 n1_M2_85380_14100 0.988200
R1639 n1_M2_85380_14100 n1_M2_86460_14100 0.988200
R1640 n1_M2_86460_14100 n1_M2_87540_14100 0.988200
R1641 n1_M2_87540_14100 n1_M2_88620_14100 0.988200
R1642 n1_M2_88620_14100 n1_M2_89700_14100 0.988200
R1643 n1_M2_89700_14100 n1_M2_90780_14100 0.988200
R1644 n1_M2_90780_14100 n1_M2_91860_14100 0.988200
R1645 n1_M2_91860_14100 n1_M2_92940_14100 0.988200
R1646 n1_M2_92940_14100 n1_M2_94020_14100 0.988200
R1647 n1_M2_94020_14100 n1_M2_95100_14100 0.988200
R1648 n1_M2_95100_14100 n1_M2_96180_14100 0.988200
R1649 n1_M2_96180_14100 n1_M2_97260_14100 0.988200
R1650 n1_M2_97260_14100 n1_M2_98340_14100 0.988200
R1651 n1_M2_98340_14100 n1_M2_99420_14100 0.988200
R1652 n1_M2_99420_14100 n1_M2_100500_14100 0.988200
R1653 n1_M2_100500_14100 n1_M2_101580_14100 0.988200
R1654 n1_M2_101580_14100 n1_M2_102660_14100 0.988200
R1655 n1_M2_102660_14100 n1_M2_103740_14100 0.988200
R1656 n1_M2_103740_14100 n1_M2_104820_14100 0.988200
R1657 n1_M2_104820_14100 n1_M2_105900_14100 0.988200
R1658 n1_M2_105900_14100 n1_M2_106980_14100 0.988200
R1659 n1_M2_106980_14100 n1_M2_108060_14100 0.988200
R1660 n1_M2_108060_14100 n1_M2_109140_14100 0.988200
R1661 n1_M2_109140_14100 n1_M2_110220_14100 0.988200
R1662 n1_M2_110220_14100 n1_M2_111300_14100 0.988200
R1663 n1_M2_111300_14100 n1_M2_112380_14100 0.988200
R1664 n1_M2_112380_14100 n1_M2_113460_14100 0.988200
R1665 n1_M2_113460_14100 n1_M2_114540_14100 0.988200
R1666 n1_M2_114540_14100 n1_M2_115620_14100 0.988200
R1667 n1_M2_115620_14100 n1_M2_116700_14100 0.988200
R1668 n1_M2_116700_14100 n1_M2_117780_14100 0.988200
R1669 n1_M2_117780_14100 n1_M2_118860_14100 0.988200
R1670 n1_M2_118860_14100 n1_M2_119940_14100 0.988200
R1671 n1_M2_119940_14100 n1_M2_121020_14100 0.988200
R1672 n1_M2_121020_14100 n1_M2_122100_14100 0.988200
R1673 n1_M2_122100_14100 n1_M2_123180_14100 0.988200
R1674 n1_M2_123180_14100 n1_M2_124260_14100 0.988200
R1675 n1_M2_124260_14100 n1_M2_125340_14100 0.988200
R1676 n1_M2_125340_14100 n1_M2_126420_14100 0.988200
R1677 n1_M2_126420_14100 n1_M2_127500_14100 0.988200
R1678 n1_M2_127500_14100 n1_M2_128580_14100 0.988200
R1679 n1_M2_128580_14100 n1_M2_129660_14100 0.988200
R1680 n1_M2_60_15180 n1_M2_1140_15180 0.988200
R1681 n1_M2_1140_15180 n1_M2_2220_15180 0.988200
R1682 n1_M2_2220_15180 n1_M2_3300_15180 0.988200
R1683 n1_M2_3300_15180 n1_M2_4380_15180 0.988200
R1684 n1_M2_4380_15180 n1_M2_5460_15180 0.988200
R1685 n1_M2_5460_15180 n1_M2_6540_15180 0.988200
R1686 n1_M2_6540_15180 n1_M2_7620_15180 0.988200
R1687 n1_M2_7620_15180 n1_M2_8700_15180 0.988200
R1688 n1_M2_8700_15180 n1_M2_9780_15180 0.988200
R1689 n1_M2_9780_15180 n1_M2_10860_15180 0.988200
R1690 n1_M2_10860_15180 n1_M2_11940_15180 0.988200
R1691 n1_M2_11940_15180 n1_M2_13020_15180 0.988200
R1692 n1_M2_13020_15180 n1_M2_14100_15180 0.988200
R1693 n1_M2_14100_15180 n1_M2_15180_15180 0.988200
R1694 n1_M2_15180_15180 n1_M2_16260_15180 0.988200
R1695 n1_M2_16260_15180 n1_M2_17340_15180 0.988200
R1696 n1_M2_17340_15180 n1_M2_18420_15180 0.988200
R1697 n1_M2_18420_15180 n1_M2_19500_15180 0.988200
R1698 n1_M2_19500_15180 n1_M2_20580_15180 0.988200
R1699 n1_M2_20580_15180 n1_M2_21660_15180 0.988200
R1700 n1_M2_21660_15180 n1_M2_22740_15180 0.988200
R1701 n1_M2_22740_15180 n1_M2_23820_15180 0.988200
R1702 n1_M2_23820_15180 n1_M2_24900_15180 0.988200
R1703 n1_M2_24900_15180 n1_M2_25980_15180 0.988200
R1704 n1_M2_25980_15180 n1_M2_27060_15180 0.988200
R1705 n1_M2_27060_15180 n1_M2_28140_15180 0.988200
R1706 n1_M2_28140_15180 n1_M2_29220_15180 0.988200
R1707 n1_M2_29220_15180 n1_M2_30300_15180 0.988200
R1708 n1_M2_30300_15180 n1_M2_31380_15180 0.988200
R1709 n1_M2_31380_15180 n1_M2_32460_15180 0.988200
R1710 n1_M2_32460_15180 n1_M2_33540_15180 0.988200
R1711 n1_M2_33540_15180 n1_M2_34620_15180 0.988200
R1712 n1_M2_34620_15180 n1_M2_35700_15180 0.988200
R1713 n1_M2_35700_15180 n1_M2_36780_15180 0.988200
R1714 n1_M2_36780_15180 n1_M2_37860_15180 0.988200
R1715 n1_M2_37860_15180 n1_M2_38940_15180 0.988200
R1716 n1_M2_38940_15180 n1_M2_40020_15180 0.988200
R1717 n1_M2_40020_15180 n1_M2_41100_15180 0.988200
R1718 n1_M2_41100_15180 n1_M2_42180_15180 0.988200
R1719 n1_M2_42180_15180 n1_M2_43260_15180 0.988200
R1720 n1_M2_43260_15180 n1_M2_44340_15180 0.988200
R1721 n1_M2_44340_15180 n1_M2_45420_15180 0.988200
R1722 n1_M2_45420_15180 n1_M2_46500_15180 0.988200
R1723 n1_M2_46500_15180 n1_M2_47580_15180 0.988200
R1724 n1_M2_47580_15180 n1_M2_48660_15180 0.988200
R1725 n1_M2_48660_15180 n1_M2_49740_15180 0.988200
R1726 n1_M2_49740_15180 n1_M2_50820_15180 0.988200
R1727 n1_M2_50820_15180 n1_M2_51900_15180 0.988200
R1728 n1_M2_51900_15180 n1_M2_52980_15180 0.988200
R1729 n1_M2_52980_15180 n1_M2_54060_15180 0.988200
R1730 n1_M2_54060_15180 n1_M2_55140_15180 0.988200
R1731 n1_M2_55140_15180 n1_M2_56220_15180 0.988200
R1732 n1_M2_56220_15180 n1_M2_57300_15180 0.988200
R1733 n1_M2_57300_15180 n1_M2_58380_15180 0.988200
R1734 n1_M2_58380_15180 n1_M2_59460_15180 0.988200
R1735 n1_M2_59460_15180 n1_M2_60540_15180 0.988200
R1736 n1_M2_60540_15180 n1_M2_61620_15180 0.988200
R1737 n1_M2_61620_15180 n1_M2_62700_15180 0.988200
R1738 n1_M2_62700_15180 n1_M2_63780_15180 0.988200
R1739 n1_M2_63780_15180 n1_M2_64860_15180 0.988200
R1740 n1_M2_64860_15180 n1_M2_65940_15180 0.988200
R1741 n1_M2_65940_15180 n1_M2_67020_15180 0.988200
R1742 n1_M2_67020_15180 n1_M2_68100_15180 0.988200
R1743 n1_M2_68100_15180 n1_M2_69180_15180 0.988200
R1744 n1_M2_69180_15180 n1_M2_70260_15180 0.988200
R1745 n1_M2_70260_15180 n1_M2_71340_15180 0.988200
R1746 n1_M2_71340_15180 n1_M2_72420_15180 0.988200
R1747 n1_M2_72420_15180 n1_M2_73500_15180 0.988200
R1748 n1_M2_73500_15180 n1_M2_74580_15180 0.988200
R1749 n1_M2_74580_15180 n1_M2_75660_15180 0.988200
R1750 n1_M2_75660_15180 n1_M2_76740_15180 0.988200
R1751 n1_M2_76740_15180 n1_M2_77820_15180 0.988200
R1752 n1_M2_77820_15180 n1_M2_78900_15180 0.988200
R1753 n1_M2_78900_15180 n1_M2_79980_15180 0.988200
R1754 n1_M2_79980_15180 n1_M2_81060_15180 0.988200
R1755 n1_M2_81060_15180 n1_M2_82140_15180 0.988200
R1756 n1_M2_82140_15180 n1_M2_83220_15180 0.988200
R1757 n1_M2_83220_15180 n1_M2_84300_15180 0.988200
R1758 n1_M2_84300_15180 n1_M2_85380_15180 0.988200
R1759 n1_M2_85380_15180 n1_M2_86460_15180 0.988200
R1760 n1_M2_86460_15180 n1_M2_87540_15180 0.988200
R1761 n1_M2_87540_15180 n1_M2_88620_15180 0.988200
R1762 n1_M2_88620_15180 n1_M2_89700_15180 0.988200
R1763 n1_M2_89700_15180 n1_M2_90780_15180 0.988200
R1764 n1_M2_90780_15180 n1_M2_91860_15180 0.988200
R1765 n1_M2_91860_15180 n1_M2_92940_15180 0.988200
R1766 n1_M2_92940_15180 n1_M2_94020_15180 0.988200
R1767 n1_M2_94020_15180 n1_M2_95100_15180 0.988200
R1768 n1_M2_95100_15180 n1_M2_96180_15180 0.988200
R1769 n1_M2_96180_15180 n1_M2_97260_15180 0.988200
R1770 n1_M2_97260_15180 n1_M2_98340_15180 0.988200
R1771 n1_M2_98340_15180 n1_M2_99420_15180 0.988200
R1772 n1_M2_99420_15180 n1_M2_100500_15180 0.988200
R1773 n1_M2_100500_15180 n1_M2_101580_15180 0.988200
R1774 n1_M2_101580_15180 n1_M2_102660_15180 0.988200
R1775 n1_M2_102660_15180 n1_M2_103740_15180 0.988200
R1776 n1_M2_103740_15180 n1_M2_104820_15180 0.988200
R1777 n1_M2_104820_15180 n1_M2_105900_15180 0.988200
R1778 n1_M2_105900_15180 n1_M2_106980_15180 0.988200
R1779 n1_M2_106980_15180 n1_M2_108060_15180 0.988200
R1780 n1_M2_108060_15180 n1_M2_109140_15180 0.988200
R1781 n1_M2_109140_15180 n1_M2_110220_15180 0.988200
R1782 n1_M2_110220_15180 n1_M2_111300_15180 0.988200
R1783 n1_M2_111300_15180 n1_M2_112380_15180 0.988200
R1784 n1_M2_112380_15180 n1_M2_113460_15180 0.988200
R1785 n1_M2_113460_15180 n1_M2_114540_15180 0.988200
R1786 n1_M2_114540_15180 n1_M2_115620_15180 0.988200
R1787 n1_M2_115620_15180 n1_M2_116700_15180 0.988200
R1788 n1_M2_116700_15180 n1_M2_117780_15180 0.988200
R1789 n1_M2_117780_15180 n1_M2_118860_15180 0.988200
R1790 n1_M2_118860_15180 n1_M2_119940_15180 0.988200
R1791 n1_M2_119940_15180 n1_M2_121020_15180 0.988200
R1792 n1_M2_121020_15180 n1_M2_122100_15180 0.988200
R1793 n1_M2_122100_15180 n1_M2_123180_15180 0.988200
R1794 n1_M2_123180_15180 n1_M2_124260_15180 0.988200
R1795 n1_M2_124260_15180 n1_M2_125340_15180 0.988200
R1796 n1_M2_125340_15180 n1_M2_126420_15180 0.988200
R1797 n1_M2_126420_15180 n1_M2_127500_15180 0.988200
R1798 n1_M2_127500_15180 n1_M2_128580_15180 0.988200
R1799 n1_M2_128580_15180 n1_M2_129660_15180 0.988200
R1800 n1_M2_60_16260 n1_M2_1140_16260 0.988200
R1801 n1_M2_1140_16260 n1_M2_2220_16260 0.988200
R1802 n1_M2_2220_16260 n1_M2_3300_16260 0.988200
R1803 n1_M2_3300_16260 n1_M2_4380_16260 0.988200
R1804 n1_M2_4380_16260 n1_M2_5460_16260 0.988200
R1805 n1_M2_5460_16260 n1_M2_6540_16260 0.988200
R1806 n1_M2_6540_16260 n1_M2_7620_16260 0.988200
R1807 n1_M2_7620_16260 n1_M2_8700_16260 0.988200
R1808 n1_M2_8700_16260 n1_M2_9780_16260 0.988200
R1809 n1_M2_9780_16260 n1_M2_10860_16260 0.988200
R1810 n1_M2_10860_16260 n1_M2_11940_16260 0.988200
R1811 n1_M2_11940_16260 n1_M2_13020_16260 0.988200
R1812 n1_M2_13020_16260 n1_M2_14100_16260 0.988200
R1813 n1_M2_14100_16260 n1_M2_15180_16260 0.988200
R1814 n1_M2_15180_16260 n1_M2_16260_16260 0.988200
R1815 n1_M2_16260_16260 n1_M2_17340_16260 0.988200
R1816 n1_M2_17340_16260 n1_M2_18420_16260 0.988200
R1817 n1_M2_18420_16260 n1_M2_19500_16260 0.988200
R1818 n1_M2_19500_16260 n1_M2_20580_16260 0.988200
R1819 n1_M2_20580_16260 n1_M2_21660_16260 0.988200
R1820 n1_M2_21660_16260 n1_M2_22740_16260 0.988200
R1821 n1_M2_22740_16260 n1_M2_23820_16260 0.988200
R1822 n1_M2_23820_16260 n1_M2_24900_16260 0.988200
R1823 n1_M2_24900_16260 n1_M2_25980_16260 0.988200
R1824 n1_M2_25980_16260 n1_M2_27060_16260 0.988200
R1825 n1_M2_27060_16260 n1_M2_28140_16260 0.988200
R1826 n1_M2_28140_16260 n1_M2_29220_16260 0.988200
R1827 n1_M2_29220_16260 n1_M2_30300_16260 0.988200
R1828 n1_M2_30300_16260 n1_M2_31380_16260 0.988200
R1829 n1_M2_31380_16260 n1_M2_32460_16260 0.988200
R1830 n1_M2_32460_16260 n1_M2_33540_16260 0.988200
R1831 n1_M2_33540_16260 n1_M2_34620_16260 0.988200
R1832 n1_M2_34620_16260 n1_M2_35700_16260 0.988200
R1833 n1_M2_35700_16260 n1_M2_36780_16260 0.988200
R1834 n1_M2_36780_16260 n1_M2_37860_16260 0.988200
R1835 n1_M2_37860_16260 n1_M2_38940_16260 0.988200
R1836 n1_M2_38940_16260 n1_M2_40020_16260 0.988200
R1837 n1_M2_40020_16260 n1_M2_41100_16260 0.988200
R1838 n1_M2_41100_16260 n1_M2_42180_16260 0.988200
R1839 n1_M2_42180_16260 n1_M2_43260_16260 0.988200
R1840 n1_M2_43260_16260 n1_M2_44340_16260 0.988200
R1841 n1_M2_44340_16260 n1_M2_45420_16260 0.988200
R1842 n1_M2_45420_16260 n1_M2_46500_16260 0.988200
R1843 n1_M2_46500_16260 n1_M2_47580_16260 0.988200
R1844 n1_M2_47580_16260 n1_M2_48660_16260 0.988200
R1845 n1_M2_48660_16260 n1_M2_49740_16260 0.988200
R1846 n1_M2_49740_16260 n1_M2_50820_16260 0.988200
R1847 n1_M2_50820_16260 n1_M2_51900_16260 0.988200
R1848 n1_M2_51900_16260 n1_M2_52980_16260 0.988200
R1849 n1_M2_52980_16260 n1_M2_54060_16260 0.988200
R1850 n1_M2_54060_16260 n1_M2_55140_16260 0.988200
R1851 n1_M2_55140_16260 n1_M2_56220_16260 0.988200
R1852 n1_M2_56220_16260 n1_M2_57300_16260 0.988200
R1853 n1_M2_57300_16260 n1_M2_58380_16260 0.988200
R1854 n1_M2_58380_16260 n1_M2_59460_16260 0.988200
R1855 n1_M2_59460_16260 n1_M2_60540_16260 0.988200
R1856 n1_M2_60540_16260 n1_M2_61620_16260 0.988200
R1857 n1_M2_61620_16260 n1_M2_62700_16260 0.988200
R1858 n1_M2_62700_16260 n1_M2_63780_16260 0.988200
R1859 n1_M2_63780_16260 n1_M2_64860_16260 0.988200
R1860 n1_M2_64860_16260 n1_M2_65940_16260 0.988200
R1861 n1_M2_65940_16260 n1_M2_67020_16260 0.988200
R1862 n1_M2_67020_16260 n1_M2_68100_16260 0.988200
R1863 n1_M2_68100_16260 n1_M2_69180_16260 0.988200
R1864 n1_M2_69180_16260 n1_M2_70260_16260 0.988200
R1865 n1_M2_70260_16260 n1_M2_71340_16260 0.988200
R1866 n1_M2_71340_16260 n1_M2_72420_16260 0.988200
R1867 n1_M2_72420_16260 n1_M2_73500_16260 0.988200
R1868 n1_M2_73500_16260 n1_M2_74580_16260 0.988200
R1869 n1_M2_74580_16260 n1_M2_75660_16260 0.988200
R1870 n1_M2_75660_16260 n1_M2_76740_16260 0.988200
R1871 n1_M2_76740_16260 n1_M2_77820_16260 0.988200
R1872 n1_M2_77820_16260 n1_M2_78900_16260 0.988200
R1873 n1_M2_78900_16260 n1_M2_79980_16260 0.988200
R1874 n1_M2_79980_16260 n1_M2_81060_16260 0.988200
R1875 n1_M2_81060_16260 n1_M2_82140_16260 0.988200
R1876 n1_M2_82140_16260 n1_M2_83220_16260 0.988200
R1877 n1_M2_83220_16260 n1_M2_84300_16260 0.988200
R1878 n1_M2_84300_16260 n1_M2_85380_16260 0.988200
R1879 n1_M2_85380_16260 n1_M2_86460_16260 0.988200
R1880 n1_M2_86460_16260 n1_M2_87540_16260 0.988200
R1881 n1_M2_87540_16260 n1_M2_88620_16260 0.988200
R1882 n1_M2_88620_16260 n1_M2_89700_16260 0.988200
R1883 n1_M2_89700_16260 n1_M2_90780_16260 0.988200
R1884 n1_M2_90780_16260 n1_M2_91860_16260 0.988200
R1885 n1_M2_91860_16260 n1_M2_92940_16260 0.988200
R1886 n1_M2_92940_16260 n1_M2_94020_16260 0.988200
R1887 n1_M2_94020_16260 n1_M2_95100_16260 0.988200
R1888 n1_M2_95100_16260 n1_M2_96180_16260 0.988200
R1889 n1_M2_96180_16260 n1_M2_97260_16260 0.988200
R1890 n1_M2_97260_16260 n1_M2_98340_16260 0.988200
R1891 n1_M2_98340_16260 n1_M2_99420_16260 0.988200
R1892 n1_M2_99420_16260 n1_M2_100500_16260 0.988200
R1893 n1_M2_100500_16260 n1_M2_101580_16260 0.988200
R1894 n1_M2_101580_16260 n1_M2_102660_16260 0.988200
R1895 n1_M2_102660_16260 n1_M2_103740_16260 0.988200
R1896 n1_M2_103740_16260 n1_M2_104820_16260 0.988200
R1897 n1_M2_104820_16260 n1_M2_105900_16260 0.988200
R1898 n1_M2_105900_16260 n1_M2_106980_16260 0.988200
R1899 n1_M2_106980_16260 n1_M2_108060_16260 0.988200
R1900 n1_M2_108060_16260 n1_M2_109140_16260 0.988200
R1901 n1_M2_109140_16260 n1_M2_110220_16260 0.988200
R1902 n1_M2_110220_16260 n1_M2_111300_16260 0.988200
R1903 n1_M2_111300_16260 n1_M2_112380_16260 0.988200
R1904 n1_M2_112380_16260 n1_M2_113460_16260 0.988200
R1905 n1_M2_113460_16260 n1_M2_114540_16260 0.988200
R1906 n1_M2_114540_16260 n1_M2_115620_16260 0.988200
R1907 n1_M2_115620_16260 n1_M2_116700_16260 0.988200
R1908 n1_M2_116700_16260 n1_M2_117780_16260 0.988200
R1909 n1_M2_117780_16260 n1_M2_118860_16260 0.988200
R1910 n1_M2_118860_16260 n1_M2_119940_16260 0.988200
R1911 n1_M2_119940_16260 n1_M2_121020_16260 0.988200
R1912 n1_M2_121020_16260 n1_M2_122100_16260 0.988200
R1913 n1_M2_122100_16260 n1_M2_123180_16260 0.988200
R1914 n1_M2_123180_16260 n1_M2_124260_16260 0.988200
R1915 n1_M2_124260_16260 n1_M2_125340_16260 0.988200
R1916 n1_M2_125340_16260 n1_M2_126420_16260 0.988200
R1917 n1_M2_126420_16260 n1_M2_127500_16260 0.988200
R1918 n1_M2_127500_16260 n1_M2_128580_16260 0.988200
R1919 n1_M2_128580_16260 n1_M2_129660_16260 0.988200
R1920 n1_M2_60_17340 n1_M2_1140_17340 0.988200
R1921 n1_M2_1140_17340 n1_M2_2220_17340 0.988200
R1922 n1_M2_2220_17340 n1_M2_3300_17340 0.988200
R1923 n1_M2_3300_17340 n1_M2_4380_17340 0.988200
R1924 n1_M2_4380_17340 n1_M2_5460_17340 0.988200
R1925 n1_M2_5460_17340 n1_M2_6540_17340 0.988200
R1926 n1_M2_6540_17340 n1_M2_7620_17340 0.988200
R1927 n1_M2_7620_17340 n1_M2_8700_17340 0.988200
R1928 n1_M2_8700_17340 n1_M2_9780_17340 0.988200
R1929 n1_M2_9780_17340 n1_M2_10860_17340 0.988200
R1930 n1_M2_10860_17340 n1_M2_11940_17340 0.988200
R1931 n1_M2_11940_17340 n1_M2_13020_17340 0.988200
R1932 n1_M2_13020_17340 n1_M2_14100_17340 0.988200
R1933 n1_M2_14100_17340 n1_M2_15180_17340 0.988200
R1934 n1_M2_15180_17340 n1_M2_16260_17340 0.988200
R1935 n1_M2_16260_17340 n1_M2_17340_17340 0.988200
R1936 n1_M2_17340_17340 n1_M2_18420_17340 0.988200
R1937 n1_M2_18420_17340 n1_M2_19500_17340 0.988200
R1938 n1_M2_19500_17340 n1_M2_20580_17340 0.988200
R1939 n1_M2_20580_17340 n1_M2_21660_17340 0.988200
R1940 n1_M2_21660_17340 n1_M2_22740_17340 0.988200
R1941 n1_M2_22740_17340 n1_M2_23820_17340 0.988200
R1942 n1_M2_23820_17340 n1_M2_24900_17340 0.988200
R1943 n1_M2_24900_17340 n1_M2_25980_17340 0.988200
R1944 n1_M2_25980_17340 n1_M2_27060_17340 0.988200
R1945 n1_M2_27060_17340 n1_M2_28140_17340 0.988200
R1946 n1_M2_28140_17340 n1_M2_29220_17340 0.988200
R1947 n1_M2_29220_17340 n1_M2_30300_17340 0.988200
R1948 n1_M2_30300_17340 n1_M2_31380_17340 0.988200
R1949 n1_M2_31380_17340 n1_M2_32460_17340 0.988200
R1950 n1_M2_32460_17340 n1_M2_33540_17340 0.988200
R1951 n1_M2_33540_17340 n1_M2_34620_17340 0.988200
R1952 n1_M2_34620_17340 n1_M2_35700_17340 0.988200
R1953 n1_M2_35700_17340 n1_M2_36780_17340 0.988200
R1954 n1_M2_36780_17340 n1_M2_37860_17340 0.988200
R1955 n1_M2_37860_17340 n1_M2_38940_17340 0.988200
R1956 n1_M2_38940_17340 n1_M2_40020_17340 0.988200
R1957 n1_M2_40020_17340 n1_M2_41100_17340 0.988200
R1958 n1_M2_41100_17340 n1_M2_42180_17340 0.988200
R1959 n1_M2_42180_17340 n1_M2_43260_17340 0.988200
R1960 n1_M2_43260_17340 n1_M2_44340_17340 0.988200
R1961 n1_M2_44340_17340 n1_M2_45420_17340 0.988200
R1962 n1_M2_45420_17340 n1_M2_46500_17340 0.988200
R1963 n1_M2_46500_17340 n1_M2_47580_17340 0.988200
R1964 n1_M2_47580_17340 n1_M2_48660_17340 0.988200
R1965 n1_M2_48660_17340 n1_M2_49740_17340 0.988200
R1966 n1_M2_49740_17340 n1_M2_50820_17340 0.988200
R1967 n1_M2_50820_17340 n1_M2_51900_17340 0.988200
R1968 n1_M2_51900_17340 n1_M2_52980_17340 0.988200
R1969 n1_M2_52980_17340 n1_M2_54060_17340 0.988200
R1970 n1_M2_54060_17340 n1_M2_55140_17340 0.988200
R1971 n1_M2_55140_17340 n1_M2_56220_17340 0.988200
R1972 n1_M2_56220_17340 n1_M2_57300_17340 0.988200
R1973 n1_M2_57300_17340 n1_M2_58380_17340 0.988200
R1974 n1_M2_58380_17340 n1_M2_59460_17340 0.988200
R1975 n1_M2_59460_17340 n1_M2_60540_17340 0.988200
R1976 n1_M2_60540_17340 n1_M2_61620_17340 0.988200
R1977 n1_M2_61620_17340 n1_M2_62700_17340 0.988200
R1978 n1_M2_62700_17340 n1_M2_63780_17340 0.988200
R1979 n1_M2_63780_17340 n1_M2_64860_17340 0.988200
R1980 n1_M2_64860_17340 n1_M2_65940_17340 0.988200
R1981 n1_M2_65940_17340 n1_M2_67020_17340 0.988200
R1982 n1_M2_67020_17340 n1_M2_68100_17340 0.988200
R1983 n1_M2_68100_17340 n1_M2_69180_17340 0.988200
R1984 n1_M2_69180_17340 n1_M2_70260_17340 0.988200
R1985 n1_M2_70260_17340 n1_M2_71340_17340 0.988200
R1986 n1_M2_71340_17340 n1_M2_72420_17340 0.988200
R1987 n1_M2_72420_17340 n1_M2_73500_17340 0.988200
R1988 n1_M2_73500_17340 n1_M2_74580_17340 0.988200
R1989 n1_M2_74580_17340 n1_M2_75660_17340 0.988200
R1990 n1_M2_75660_17340 n1_M2_76740_17340 0.988200
R1991 n1_M2_76740_17340 n1_M2_77820_17340 0.988200
R1992 n1_M2_77820_17340 n1_M2_78900_17340 0.988200
R1993 n1_M2_78900_17340 n1_M2_79980_17340 0.988200
R1994 n1_M2_79980_17340 n1_M2_81060_17340 0.988200
R1995 n1_M2_81060_17340 n1_M2_82140_17340 0.988200
R1996 n1_M2_82140_17340 n1_M2_83220_17340 0.988200
R1997 n1_M2_83220_17340 n1_M2_84300_17340 0.988200
R1998 n1_M2_84300_17340 n1_M2_85380_17340 0.988200
R1999 n1_M2_85380_17340 n1_M2_86460_17340 0.988200
R2000 n1_M2_86460_17340 n1_M2_87540_17340 0.988200
R2001 n1_M2_87540_17340 n1_M2_88620_17340 0.988200
R2002 n1_M2_88620_17340 n1_M2_89700_17340 0.988200
R2003 n1_M2_89700_17340 n1_M2_90780_17340 0.988200
R2004 n1_M2_90780_17340 n1_M2_91860_17340 0.988200
R2005 n1_M2_91860_17340 n1_M2_92940_17340 0.988200
R2006 n1_M2_92940_17340 n1_M2_94020_17340 0.988200
R2007 n1_M2_94020_17340 n1_M2_95100_17340 0.988200
R2008 n1_M2_95100_17340 n1_M2_96180_17340 0.988200
R2009 n1_M2_96180_17340 n1_M2_97260_17340 0.988200
R2010 n1_M2_97260_17340 n1_M2_98340_17340 0.988200
R2011 n1_M2_98340_17340 n1_M2_99420_17340 0.988200
R2012 n1_M2_99420_17340 n1_M2_100500_17340 0.988200
R2013 n1_M2_100500_17340 n1_M2_101580_17340 0.988200
R2014 n1_M2_101580_17340 n1_M2_102660_17340 0.988200
R2015 n1_M2_102660_17340 n1_M2_103740_17340 0.988200
R2016 n1_M2_103740_17340 n1_M2_104820_17340 0.988200
R2017 n1_M2_104820_17340 n1_M2_105900_17340 0.988200
R2018 n1_M2_105900_17340 n1_M2_106980_17340 0.988200
R2019 n1_M2_106980_17340 n1_M2_108060_17340 0.988200
R2020 n1_M2_108060_17340 n1_M2_109140_17340 0.988200
R2021 n1_M2_109140_17340 n1_M2_110220_17340 0.988200
R2022 n1_M2_110220_17340 n1_M2_111300_17340 0.988200
R2023 n1_M2_111300_17340 n1_M2_112380_17340 0.988200
R2024 n1_M2_112380_17340 n1_M2_113460_17340 0.988200
R2025 n1_M2_113460_17340 n1_M2_114540_17340 0.988200
R2026 n1_M2_114540_17340 n1_M2_115620_17340 0.988200
R2027 n1_M2_115620_17340 n1_M2_116700_17340 0.988200
R2028 n1_M2_116700_17340 n1_M2_117780_17340 0.988200
R2029 n1_M2_117780_17340 n1_M2_118860_17340 0.988200
R2030 n1_M2_118860_17340 n1_M2_119940_17340 0.988200
R2031 n1_M2_119940_17340 n1_M2_121020_17340 0.988200
R2032 n1_M2_121020_17340 n1_M2_122100_17340 0.988200
R2033 n1_M2_122100_17340 n1_M2_123180_17340 0.988200
R2034 n1_M2_123180_17340 n1_M2_124260_17340 0.988200
R2035 n1_M2_124260_17340 n1_M2_125340_17340 0.988200
R2036 n1_M2_125340_17340 n1_M2_126420_17340 0.988200
R2037 n1_M2_126420_17340 n1_M2_127500_17340 0.988200
R2038 n1_M2_127500_17340 n1_M2_128580_17340 0.988200
R2039 n1_M2_128580_17340 n1_M2_129660_17340 0.988200
R2040 n1_M2_60_18420 n1_M2_1140_18420 0.988200
R2041 n1_M2_1140_18420 n1_M2_2220_18420 0.988200
R2042 n1_M2_2220_18420 n1_M2_3300_18420 0.988200
R2043 n1_M2_3300_18420 n1_M2_4380_18420 0.988200
R2044 n1_M2_4380_18420 n1_M2_5460_18420 0.988200
R2045 n1_M2_5460_18420 n1_M2_6540_18420 0.988200
R2046 n1_M2_6540_18420 n1_M2_7620_18420 0.988200
R2047 n1_M2_7620_18420 n1_M2_8700_18420 0.988200
R2048 n1_M2_8700_18420 n1_M2_9780_18420 0.988200
R2049 n1_M2_9780_18420 n1_M2_10860_18420 0.988200
R2050 n1_M2_10860_18420 n1_M2_11940_18420 0.988200
R2051 n1_M2_11940_18420 n1_M2_13020_18420 0.988200
R2052 n1_M2_13020_18420 n1_M2_14100_18420 0.988200
R2053 n1_M2_14100_18420 n1_M2_15180_18420 0.988200
R2054 n1_M2_15180_18420 n1_M2_16260_18420 0.988200
R2055 n1_M2_16260_18420 n1_M2_17340_18420 0.988200
R2056 n1_M2_17340_18420 n1_M2_18420_18420 0.988200
R2057 n1_M2_18420_18420 n1_M2_19500_18420 0.988200
R2058 n1_M2_19500_18420 n1_M2_20580_18420 0.988200
R2059 n1_M2_20580_18420 n1_M2_21660_18420 0.988200
R2060 n1_M2_21660_18420 n1_M2_22740_18420 0.988200
R2061 n1_M2_22740_18420 n1_M2_23820_18420 0.988200
R2062 n1_M2_23820_18420 n1_M2_24900_18420 0.988200
R2063 n1_M2_24900_18420 n1_M2_25980_18420 0.988200
R2064 n1_M2_25980_18420 n1_M2_27060_18420 0.988200
R2065 n1_M2_27060_18420 n1_M2_28140_18420 0.988200
R2066 n1_M2_28140_18420 n1_M2_29220_18420 0.988200
R2067 n1_M2_29220_18420 n1_M2_30300_18420 0.988200
R2068 n1_M2_30300_18420 n1_M2_31380_18420 0.988200
R2069 n1_M2_31380_18420 n1_M2_32460_18420 0.988200
R2070 n1_M2_32460_18420 n1_M2_33540_18420 0.988200
R2071 n1_M2_33540_18420 n1_M2_34620_18420 0.988200
R2072 n1_M2_34620_18420 n1_M2_35700_18420 0.988200
R2073 n1_M2_35700_18420 n1_M2_36780_18420 0.988200
R2074 n1_M2_36780_18420 n1_M2_37860_18420 0.988200
R2075 n1_M2_37860_18420 n1_M2_38940_18420 0.988200
R2076 n1_M2_38940_18420 n1_M2_40020_18420 0.988200
R2077 n1_M2_40020_18420 n1_M2_41100_18420 0.988200
R2078 n1_M2_41100_18420 n1_M2_42180_18420 0.988200
R2079 n1_M2_42180_18420 n1_M2_43260_18420 0.988200
R2080 n1_M2_43260_18420 n1_M2_44340_18420 0.988200
R2081 n1_M2_44340_18420 n1_M2_45420_18420 0.988200
R2082 n1_M2_45420_18420 n1_M2_46500_18420 0.988200
R2083 n1_M2_46500_18420 n1_M2_47580_18420 0.988200
R2084 n1_M2_47580_18420 n1_M2_48660_18420 0.988200
R2085 n1_M2_48660_18420 n1_M2_49740_18420 0.988200
R2086 n1_M2_49740_18420 n1_M2_50820_18420 0.988200
R2087 n1_M2_50820_18420 n1_M2_51900_18420 0.988200
R2088 n1_M2_51900_18420 n1_M2_52980_18420 0.988200
R2089 n1_M2_52980_18420 n1_M2_54060_18420 0.988200
R2090 n1_M2_54060_18420 n1_M2_55140_18420 0.988200
R2091 n1_M2_55140_18420 n1_M2_56220_18420 0.988200
R2092 n1_M2_56220_18420 n1_M2_57300_18420 0.988200
R2093 n1_M2_57300_18420 n1_M2_58380_18420 0.988200
R2094 n1_M2_58380_18420 n1_M2_59460_18420 0.988200
R2095 n1_M2_59460_18420 n1_M2_60540_18420 0.988200
R2096 n1_M2_60540_18420 n1_M2_61620_18420 0.988200
R2097 n1_M2_61620_18420 n1_M2_62700_18420 0.988200
R2098 n1_M2_62700_18420 n1_M2_63780_18420 0.988200
R2099 n1_M2_63780_18420 n1_M2_64860_18420 0.988200
R2100 n1_M2_64860_18420 n1_M2_65940_18420 0.988200
R2101 n1_M2_65940_18420 n1_M2_67020_18420 0.988200
R2102 n1_M2_67020_18420 n1_M2_68100_18420 0.988200
R2103 n1_M2_68100_18420 n1_M2_69180_18420 0.988200
R2104 n1_M2_69180_18420 n1_M2_70260_18420 0.988200
R2105 n1_M2_70260_18420 n1_M2_71340_18420 0.988200
R2106 n1_M2_71340_18420 n1_M2_72420_18420 0.988200
R2107 n1_M2_72420_18420 n1_M2_73500_18420 0.988200
R2108 n1_M2_73500_18420 n1_M2_74580_18420 0.988200
R2109 n1_M2_74580_18420 n1_M2_75660_18420 0.988200
R2110 n1_M2_75660_18420 n1_M2_76740_18420 0.988200
R2111 n1_M2_76740_18420 n1_M2_77820_18420 0.988200
R2112 n1_M2_77820_18420 n1_M2_78900_18420 0.988200
R2113 n1_M2_78900_18420 n1_M2_79980_18420 0.988200
R2114 n1_M2_79980_18420 n1_M2_81060_18420 0.988200
R2115 n1_M2_81060_18420 n1_M2_82140_18420 0.988200
R2116 n1_M2_82140_18420 n1_M2_83220_18420 0.988200
R2117 n1_M2_83220_18420 n1_M2_84300_18420 0.988200
R2118 n1_M2_84300_18420 n1_M2_85380_18420 0.988200
R2119 n1_M2_85380_18420 n1_M2_86460_18420 0.988200
R2120 n1_M2_86460_18420 n1_M2_87540_18420 0.988200
R2121 n1_M2_87540_18420 n1_M2_88620_18420 0.988200
R2122 n1_M2_88620_18420 n1_M2_89700_18420 0.988200
R2123 n1_M2_89700_18420 n1_M2_90780_18420 0.988200
R2124 n1_M2_90780_18420 n1_M2_91860_18420 0.988200
R2125 n1_M2_91860_18420 n1_M2_92940_18420 0.988200
R2126 n1_M2_92940_18420 n1_M2_94020_18420 0.988200
R2127 n1_M2_94020_18420 n1_M2_95100_18420 0.988200
R2128 n1_M2_95100_18420 n1_M2_96180_18420 0.988200
R2129 n1_M2_96180_18420 n1_M2_97260_18420 0.988200
R2130 n1_M2_97260_18420 n1_M2_98340_18420 0.988200
R2131 n1_M2_98340_18420 n1_M2_99420_18420 0.988200
R2132 n1_M2_99420_18420 n1_M2_100500_18420 0.988200
R2133 n1_M2_100500_18420 n1_M2_101580_18420 0.988200
R2134 n1_M2_101580_18420 n1_M2_102660_18420 0.988200
R2135 n1_M2_102660_18420 n1_M2_103740_18420 0.988200
R2136 n1_M2_103740_18420 n1_M2_104820_18420 0.988200
R2137 n1_M2_104820_18420 n1_M2_105900_18420 0.988200
R2138 n1_M2_105900_18420 n1_M2_106980_18420 0.988200
R2139 n1_M2_106980_18420 n1_M2_108060_18420 0.988200
R2140 n1_M2_108060_18420 n1_M2_109140_18420 0.988200
R2141 n1_M2_109140_18420 n1_M2_110220_18420 0.988200
R2142 n1_M2_110220_18420 n1_M2_111300_18420 0.988200
R2143 n1_M2_111300_18420 n1_M2_112380_18420 0.988200
R2144 n1_M2_112380_18420 n1_M2_113460_18420 0.988200
R2145 n1_M2_113460_18420 n1_M2_114540_18420 0.988200
R2146 n1_M2_114540_18420 n1_M2_115620_18420 0.988200
R2147 n1_M2_115620_18420 n1_M2_116700_18420 0.988200
R2148 n1_M2_116700_18420 n1_M2_117780_18420 0.988200
R2149 n1_M2_117780_18420 n1_M2_118860_18420 0.988200
R2150 n1_M2_118860_18420 n1_M2_119940_18420 0.988200
R2151 n1_M2_119940_18420 n1_M2_121020_18420 0.988200
R2152 n1_M2_121020_18420 n1_M2_122100_18420 0.988200
R2153 n1_M2_122100_18420 n1_M2_123180_18420 0.988200
R2154 n1_M2_123180_18420 n1_M2_124260_18420 0.988200
R2155 n1_M2_124260_18420 n1_M2_125340_18420 0.988200
R2156 n1_M2_125340_18420 n1_M2_126420_18420 0.988200
R2157 n1_M2_126420_18420 n1_M2_127500_18420 0.988200
R2158 n1_M2_127500_18420 n1_M2_128580_18420 0.988200
R2159 n1_M2_128580_18420 n1_M2_129660_18420 0.988200
R2160 n1_M2_60_19500 n1_M2_1140_19500 0.988200
R2161 n1_M2_1140_19500 n1_M2_2220_19500 0.988200
R2162 n1_M2_2220_19500 n1_M2_3300_19500 0.988200
R2163 n1_M2_3300_19500 n1_M2_4380_19500 0.988200
R2164 n1_M2_4380_19500 n1_M2_5460_19500 0.988200
R2165 n1_M2_5460_19500 n1_M2_6540_19500 0.988200
R2166 n1_M2_6540_19500 n1_M2_7620_19500 0.988200
R2167 n1_M2_7620_19500 n1_M2_8700_19500 0.988200
R2168 n1_M2_8700_19500 n1_M2_9780_19500 0.988200
R2169 n1_M2_9780_19500 n1_M2_10860_19500 0.988200
R2170 n1_M2_10860_19500 n1_M2_11940_19500 0.988200
R2171 n1_M2_11940_19500 n1_M2_13020_19500 0.988200
R2172 n1_M2_13020_19500 n1_M2_14100_19500 0.988200
R2173 n1_M2_14100_19500 n1_M2_15180_19500 0.988200
R2174 n1_M2_15180_19500 n1_M2_16260_19500 0.988200
R2175 n1_M2_16260_19500 n1_M2_17340_19500 0.988200
R2176 n1_M2_17340_19500 n1_M2_18420_19500 0.988200
R2177 n1_M2_18420_19500 n1_M2_19500_19500 0.988200
R2178 n1_M2_19500_19500 n1_M2_20580_19500 0.988200
R2179 n1_M2_20580_19500 n1_M2_21660_19500 0.988200
R2180 n1_M2_21660_19500 n1_M2_22740_19500 0.988200
R2181 n1_M2_22740_19500 n1_M2_23820_19500 0.988200
R2182 n1_M2_23820_19500 n1_M2_24900_19500 0.988200
R2183 n1_M2_24900_19500 n1_M2_25980_19500 0.988200
R2184 n1_M2_25980_19500 n1_M2_27060_19500 0.988200
R2185 n1_M2_27060_19500 n1_M2_28140_19500 0.988200
R2186 n1_M2_28140_19500 n1_M2_29220_19500 0.988200
R2187 n1_M2_29220_19500 n1_M2_30300_19500 0.988200
R2188 n1_M2_30300_19500 n1_M2_31380_19500 0.988200
R2189 n1_M2_31380_19500 n1_M2_32460_19500 0.988200
R2190 n1_M2_32460_19500 n1_M2_33540_19500 0.988200
R2191 n1_M2_33540_19500 n1_M2_34620_19500 0.988200
R2192 n1_M2_34620_19500 n1_M2_35700_19500 0.988200
R2193 n1_M2_35700_19500 n1_M2_36780_19500 0.988200
R2194 n1_M2_36780_19500 n1_M2_37860_19500 0.988200
R2195 n1_M2_37860_19500 n1_M2_38940_19500 0.988200
R2196 n1_M2_38940_19500 n1_M2_40020_19500 0.988200
R2197 n1_M2_40020_19500 n1_M2_41100_19500 0.988200
R2198 n1_M2_41100_19500 n1_M2_42180_19500 0.988200
R2199 n1_M2_42180_19500 n1_M2_43260_19500 0.988200
R2200 n1_M2_43260_19500 n1_M2_44340_19500 0.988200
R2201 n1_M2_44340_19500 n1_M2_45420_19500 0.988200
R2202 n1_M2_45420_19500 n1_M2_46500_19500 0.988200
R2203 n1_M2_46500_19500 n1_M2_47580_19500 0.988200
R2204 n1_M2_47580_19500 n1_M2_48660_19500 0.988200
R2205 n1_M2_48660_19500 n1_M2_49740_19500 0.988200
R2206 n1_M2_49740_19500 n1_M2_50820_19500 0.988200
R2207 n1_M2_50820_19500 n1_M2_51900_19500 0.988200
R2208 n1_M2_51900_19500 n1_M2_52980_19500 0.988200
R2209 n1_M2_52980_19500 n1_M2_54060_19500 0.988200
R2210 n1_M2_54060_19500 n1_M2_55140_19500 0.988200
R2211 n1_M2_55140_19500 n1_M2_56220_19500 0.988200
R2212 n1_M2_56220_19500 n1_M2_57300_19500 0.988200
R2213 n1_M2_57300_19500 n1_M2_58380_19500 0.988200
R2214 n1_M2_58380_19500 n1_M2_59460_19500 0.988200
R2215 n1_M2_59460_19500 n1_M2_60540_19500 0.988200
R2216 n1_M2_60540_19500 n1_M2_61620_19500 0.988200
R2217 n1_M2_61620_19500 n1_M2_62700_19500 0.988200
R2218 n1_M2_62700_19500 n1_M2_63780_19500 0.988200
R2219 n1_M2_63780_19500 n1_M2_64860_19500 0.988200
R2220 n1_M2_64860_19500 n1_M2_65940_19500 0.988200
R2221 n1_M2_65940_19500 n1_M2_67020_19500 0.988200
R2222 n1_M2_67020_19500 n1_M2_68100_19500 0.988200
R2223 n1_M2_68100_19500 n1_M2_69180_19500 0.988200
R2224 n1_M2_69180_19500 n1_M2_70260_19500 0.988200
R2225 n1_M2_70260_19500 n1_M2_71340_19500 0.988200
R2226 n1_M2_71340_19500 n1_M2_72420_19500 0.988200
R2227 n1_M2_72420_19500 n1_M2_73500_19500 0.988200
R2228 n1_M2_73500_19500 n1_M2_74580_19500 0.988200
R2229 n1_M2_74580_19500 n1_M2_75660_19500 0.988200
R2230 n1_M2_75660_19500 n1_M2_76740_19500 0.988200
R2231 n1_M2_76740_19500 n1_M2_77820_19500 0.988200
R2232 n1_M2_77820_19500 n1_M2_78900_19500 0.988200
R2233 n1_M2_78900_19500 n1_M2_79980_19500 0.988200
R2234 n1_M2_79980_19500 n1_M2_81060_19500 0.988200
R2235 n1_M2_81060_19500 n1_M2_82140_19500 0.988200
R2236 n1_M2_82140_19500 n1_M2_83220_19500 0.988200
R2237 n1_M2_83220_19500 n1_M2_84300_19500 0.988200
R2238 n1_M2_84300_19500 n1_M2_85380_19500 0.988200
R2239 n1_M2_85380_19500 n1_M2_86460_19500 0.988200
R2240 n1_M2_86460_19500 n1_M2_87540_19500 0.988200
R2241 n1_M2_87540_19500 n1_M2_88620_19500 0.988200
R2242 n1_M2_88620_19500 n1_M2_89700_19500 0.988200
R2243 n1_M2_89700_19500 n1_M2_90780_19500 0.988200
R2244 n1_M2_90780_19500 n1_M2_91860_19500 0.988200
R2245 n1_M2_91860_19500 n1_M2_92940_19500 0.988200
R2246 n1_M2_92940_19500 n1_M2_94020_19500 0.988200
R2247 n1_M2_94020_19500 n1_M2_95100_19500 0.988200
R2248 n1_M2_95100_19500 n1_M2_96180_19500 0.988200
R2249 n1_M2_96180_19500 n1_M2_97260_19500 0.988200
R2250 n1_M2_97260_19500 n1_M2_98340_19500 0.988200
R2251 n1_M2_98340_19500 n1_M2_99420_19500 0.988200
R2252 n1_M2_99420_19500 n1_M2_100500_19500 0.988200
R2253 n1_M2_100500_19500 n1_M2_101580_19500 0.988200
R2254 n1_M2_101580_19500 n1_M2_102660_19500 0.988200
R2255 n1_M2_102660_19500 n1_M2_103740_19500 0.988200
R2256 n1_M2_103740_19500 n1_M2_104820_19500 0.988200
R2257 n1_M2_104820_19500 n1_M2_105900_19500 0.988200
R2258 n1_M2_105900_19500 n1_M2_106980_19500 0.988200
R2259 n1_M2_106980_19500 n1_M2_108060_19500 0.988200
R2260 n1_M2_108060_19500 n1_M2_109140_19500 0.988200
R2261 n1_M2_109140_19500 n1_M2_110220_19500 0.988200
R2262 n1_M2_110220_19500 n1_M2_111300_19500 0.988200
R2263 n1_M2_111300_19500 n1_M2_112380_19500 0.988200
R2264 n1_M2_112380_19500 n1_M2_113460_19500 0.988200
R2265 n1_M2_113460_19500 n1_M2_114540_19500 0.988200
R2266 n1_M2_114540_19500 n1_M2_115620_19500 0.988200
R2267 n1_M2_115620_19500 n1_M2_116700_19500 0.988200
R2268 n1_M2_116700_19500 n1_M2_117780_19500 0.988200
R2269 n1_M2_117780_19500 n1_M2_118860_19500 0.988200
R2270 n1_M2_118860_19500 n1_M2_119940_19500 0.988200
R2271 n1_M2_119940_19500 n1_M2_121020_19500 0.988200
R2272 n1_M2_121020_19500 n1_M2_122100_19500 0.988200
R2273 n1_M2_122100_19500 n1_M2_123180_19500 0.988200
R2274 n1_M2_123180_19500 n1_M2_124260_19500 0.988200
R2275 n1_M2_124260_19500 n1_M2_125340_19500 0.988200
R2276 n1_M2_125340_19500 n1_M2_126420_19500 0.988200
R2277 n1_M2_126420_19500 n1_M2_127500_19500 0.988200
R2278 n1_M2_127500_19500 n1_M2_128580_19500 0.988200
R2279 n1_M2_128580_19500 n1_M2_129660_19500 0.988200
R2280 n1_M2_60_20580 n1_M2_1140_20580 0.988200
R2281 n1_M2_1140_20580 n1_M2_2220_20580 0.988200
R2282 n1_M2_2220_20580 n1_M2_3300_20580 0.988200
R2283 n1_M2_3300_20580 n1_M2_4380_20580 0.988200
R2284 n1_M2_4380_20580 n1_M2_5460_20580 0.988200
R2285 n1_M2_5460_20580 n1_M2_6540_20580 0.988200
R2286 n1_M2_6540_20580 n1_M2_7620_20580 0.988200
R2287 n1_M2_7620_20580 n1_M2_8700_20580 0.988200
R2288 n1_M2_8700_20580 n1_M2_9780_20580 0.988200
R2289 n1_M2_9780_20580 n1_M2_10860_20580 0.988200
R2290 n1_M2_10860_20580 n1_M2_11940_20580 0.988200
R2291 n1_M2_11940_20580 n1_M2_13020_20580 0.988200
R2292 n1_M2_13020_20580 n1_M2_14100_20580 0.988200
R2293 n1_M2_14100_20580 n1_M2_15180_20580 0.988200
R2294 n1_M2_15180_20580 n1_M2_16260_20580 0.988200
R2295 n1_M2_16260_20580 n1_M2_17340_20580 0.988200
R2296 n1_M2_17340_20580 n1_M2_18420_20580 0.988200
R2297 n1_M2_18420_20580 n1_M2_19500_20580 0.988200
R2298 n1_M2_19500_20580 n1_M2_20580_20580 0.988200
R2299 n1_M2_20580_20580 n1_M2_21660_20580 0.988200
R2300 n1_M2_21660_20580 n1_M2_22740_20580 0.988200
R2301 n1_M2_22740_20580 n1_M2_23820_20580 0.988200
R2302 n1_M2_23820_20580 n1_M2_24900_20580 0.988200
R2303 n1_M2_24900_20580 n1_M2_25980_20580 0.988200
R2304 n1_M2_25980_20580 n1_M2_27060_20580 0.988200
R2305 n1_M2_27060_20580 n1_M2_28140_20580 0.988200
R2306 n1_M2_28140_20580 n1_M2_29220_20580 0.988200
R2307 n1_M2_29220_20580 n1_M2_30300_20580 0.988200
R2308 n1_M2_30300_20580 n1_M2_31380_20580 0.988200
R2309 n1_M2_31380_20580 n1_M2_32460_20580 0.988200
R2310 n1_M2_32460_20580 n1_M2_33540_20580 0.988200
R2311 n1_M2_33540_20580 n1_M2_34620_20580 0.988200
R2312 n1_M2_34620_20580 n1_M2_35700_20580 0.988200
R2313 n1_M2_35700_20580 n1_M2_36780_20580 0.988200
R2314 n1_M2_36780_20580 n1_M2_37860_20580 0.988200
R2315 n1_M2_37860_20580 n1_M2_38940_20580 0.988200
R2316 n1_M2_38940_20580 n1_M2_40020_20580 0.988200
R2317 n1_M2_40020_20580 n1_M2_41100_20580 0.988200
R2318 n1_M2_41100_20580 n1_M2_42180_20580 0.988200
R2319 n1_M2_42180_20580 n1_M2_43260_20580 0.988200
R2320 n1_M2_43260_20580 n1_M2_44340_20580 0.988200
R2321 n1_M2_44340_20580 n1_M2_45420_20580 0.988200
R2322 n1_M2_45420_20580 n1_M2_46500_20580 0.988200
R2323 n1_M2_46500_20580 n1_M2_47580_20580 0.988200
R2324 n1_M2_47580_20580 n1_M2_48660_20580 0.988200
R2325 n1_M2_48660_20580 n1_M2_49740_20580 0.988200
R2326 n1_M2_49740_20580 n1_M2_50820_20580 0.988200
R2327 n1_M2_50820_20580 n1_M2_51900_20580 0.988200
R2328 n1_M2_51900_20580 n1_M2_52980_20580 0.988200
R2329 n1_M2_52980_20580 n1_M2_54060_20580 0.988200
R2330 n1_M2_54060_20580 n1_M2_55140_20580 0.988200
R2331 n1_M2_55140_20580 n1_M2_56220_20580 0.988200
R2332 n1_M2_56220_20580 n1_M2_57300_20580 0.988200
R2333 n1_M2_57300_20580 n1_M2_58380_20580 0.988200
R2334 n1_M2_58380_20580 n1_M2_59460_20580 0.988200
R2335 n1_M2_59460_20580 n1_M2_60540_20580 0.988200
R2336 n1_M2_60540_20580 n1_M2_61620_20580 0.988200
R2337 n1_M2_61620_20580 n1_M2_62700_20580 0.988200
R2338 n1_M2_62700_20580 n1_M2_63780_20580 0.988200
R2339 n1_M2_63780_20580 n1_M2_64860_20580 0.988200
R2340 n1_M2_64860_20580 n1_M2_65940_20580 0.988200
R2341 n1_M2_65940_20580 n1_M2_67020_20580 0.988200
R2342 n1_M2_67020_20580 n1_M2_68100_20580 0.988200
R2343 n1_M2_68100_20580 n1_M2_69180_20580 0.988200
R2344 n1_M2_69180_20580 n1_M2_70260_20580 0.988200
R2345 n1_M2_70260_20580 n1_M2_71340_20580 0.988200
R2346 n1_M2_71340_20580 n1_M2_72420_20580 0.988200
R2347 n1_M2_72420_20580 n1_M2_73500_20580 0.988200
R2348 n1_M2_73500_20580 n1_M2_74580_20580 0.988200
R2349 n1_M2_74580_20580 n1_M2_75660_20580 0.988200
R2350 n1_M2_75660_20580 n1_M2_76740_20580 0.988200
R2351 n1_M2_76740_20580 n1_M2_77820_20580 0.988200
R2352 n1_M2_77820_20580 n1_M2_78900_20580 0.988200
R2353 n1_M2_78900_20580 n1_M2_79980_20580 0.988200
R2354 n1_M2_79980_20580 n1_M2_81060_20580 0.988200
R2355 n1_M2_81060_20580 n1_M2_82140_20580 0.988200
R2356 n1_M2_82140_20580 n1_M2_83220_20580 0.988200
R2357 n1_M2_83220_20580 n1_M2_84300_20580 0.988200
R2358 n1_M2_84300_20580 n1_M2_85380_20580 0.988200
R2359 n1_M2_85380_20580 n1_M2_86460_20580 0.988200
R2360 n1_M2_86460_20580 n1_M2_87540_20580 0.988200
R2361 n1_M2_87540_20580 n1_M2_88620_20580 0.988200
R2362 n1_M2_88620_20580 n1_M2_89700_20580 0.988200
R2363 n1_M2_89700_20580 n1_M2_90780_20580 0.988200
R2364 n1_M2_90780_20580 n1_M2_91860_20580 0.988200
R2365 n1_M2_91860_20580 n1_M2_92940_20580 0.988200
R2366 n1_M2_92940_20580 n1_M2_94020_20580 0.988200
R2367 n1_M2_94020_20580 n1_M2_95100_20580 0.988200
R2368 n1_M2_95100_20580 n1_M2_96180_20580 0.988200
R2369 n1_M2_96180_20580 n1_M2_97260_20580 0.988200
R2370 n1_M2_97260_20580 n1_M2_98340_20580 0.988200
R2371 n1_M2_98340_20580 n1_M2_99420_20580 0.988200
R2372 n1_M2_99420_20580 n1_M2_100500_20580 0.988200
R2373 n1_M2_100500_20580 n1_M2_101580_20580 0.988200
R2374 n1_M2_101580_20580 n1_M2_102660_20580 0.988200
R2375 n1_M2_102660_20580 n1_M2_103740_20580 0.988200
R2376 n1_M2_103740_20580 n1_M2_104820_20580 0.988200
R2377 n1_M2_104820_20580 n1_M2_105900_20580 0.988200
R2378 n1_M2_105900_20580 n1_M2_106980_20580 0.988200
R2379 n1_M2_106980_20580 n1_M2_108060_20580 0.988200
R2380 n1_M2_108060_20580 n1_M2_109140_20580 0.988200
R2381 n1_M2_109140_20580 n1_M2_110220_20580 0.988200
R2382 n1_M2_110220_20580 n1_M2_111300_20580 0.988200
R2383 n1_M2_111300_20580 n1_M2_112380_20580 0.988200
R2384 n1_M2_112380_20580 n1_M2_113460_20580 0.988200
R2385 n1_M2_113460_20580 n1_M2_114540_20580 0.988200
R2386 n1_M2_114540_20580 n1_M2_115620_20580 0.988200
R2387 n1_M2_115620_20580 n1_M2_116700_20580 0.988200
R2388 n1_M2_116700_20580 n1_M2_117780_20580 0.988200
R2389 n1_M2_117780_20580 n1_M2_118860_20580 0.988200
R2390 n1_M2_118860_20580 n1_M2_119940_20580 0.988200
R2391 n1_M2_119940_20580 n1_M2_121020_20580 0.988200
R2392 n1_M2_121020_20580 n1_M2_122100_20580 0.988200
R2393 n1_M2_122100_20580 n1_M2_123180_20580 0.988200
R2394 n1_M2_123180_20580 n1_M2_124260_20580 0.988200
R2395 n1_M2_124260_20580 n1_M2_125340_20580 0.988200
R2396 n1_M2_125340_20580 n1_M2_126420_20580 0.988200
R2397 n1_M2_126420_20580 n1_M2_127500_20580 0.988200
R2398 n1_M2_127500_20580 n1_M2_128580_20580 0.988200
R2399 n1_M2_128580_20580 n1_M2_129660_20580 0.988200
R2400 n1_M2_60_21660 n1_M2_1140_21660 0.988200
R2401 n1_M2_1140_21660 n1_M2_2220_21660 0.988200
R2402 n1_M2_2220_21660 n1_M2_3300_21660 0.988200
R2403 n1_M2_3300_21660 n1_M2_4380_21660 0.988200
R2404 n1_M2_4380_21660 n1_M2_5460_21660 0.988200
R2405 n1_M2_5460_21660 n1_M2_6540_21660 0.988200
R2406 n1_M2_6540_21660 n1_M2_7620_21660 0.988200
R2407 n1_M2_7620_21660 n1_M2_8700_21660 0.988200
R2408 n1_M2_8700_21660 n1_M2_9780_21660 0.988200
R2409 n1_M2_9780_21660 n1_M2_10860_21660 0.988200
R2410 n1_M2_10860_21660 n1_M2_11940_21660 0.988200
R2411 n1_M2_11940_21660 n1_M2_13020_21660 0.988200
R2412 n1_M2_13020_21660 n1_M2_14100_21660 0.988200
R2413 n1_M2_14100_21660 n1_M2_15180_21660 0.988200
R2414 n1_M2_15180_21660 n1_M2_16260_21660 0.988200
R2415 n1_M2_16260_21660 n1_M2_17340_21660 0.988200
R2416 n1_M2_17340_21660 n1_M2_18420_21660 0.988200
R2417 n1_M2_18420_21660 n1_M2_19500_21660 0.988200
R2418 n1_M2_19500_21660 n1_M2_20580_21660 0.988200
R2419 n1_M2_20580_21660 n1_M2_21660_21660 0.988200
R2420 n1_M2_21660_21660 n1_M2_22740_21660 0.988200
R2421 n1_M2_22740_21660 n1_M2_23820_21660 0.988200
R2422 n1_M2_23820_21660 n1_M2_24900_21660 0.988200
R2423 n1_M2_24900_21660 n1_M2_25980_21660 0.988200
R2424 n1_M2_25980_21660 n1_M2_27060_21660 0.988200
R2425 n1_M2_27060_21660 n1_M2_28140_21660 0.988200
R2426 n1_M2_28140_21660 n1_M2_29220_21660 0.988200
R2427 n1_M2_29220_21660 n1_M2_30300_21660 0.988200
R2428 n1_M2_30300_21660 n1_M2_31380_21660 0.988200
R2429 n1_M2_31380_21660 n1_M2_32460_21660 0.988200
R2430 n1_M2_32460_21660 n1_M2_33540_21660 0.988200
R2431 n1_M2_33540_21660 n1_M2_34620_21660 0.988200
R2432 n1_M2_34620_21660 n1_M2_35700_21660 0.988200
R2433 n1_M2_35700_21660 n1_M2_36780_21660 0.988200
R2434 n1_M2_36780_21660 n1_M2_37860_21660 0.988200
R2435 n1_M2_37860_21660 n1_M2_38940_21660 0.988200
R2436 n1_M2_38940_21660 n1_M2_40020_21660 0.988200
R2437 n1_M2_40020_21660 n1_M2_41100_21660 0.988200
R2438 n1_M2_41100_21660 n1_M2_42180_21660 0.988200
R2439 n1_M2_42180_21660 n1_M2_43260_21660 0.988200
R2440 n1_M2_43260_21660 n1_M2_44340_21660 0.988200
R2441 n1_M2_44340_21660 n1_M2_45420_21660 0.988200
R2442 n1_M2_45420_21660 n1_M2_46500_21660 0.988200
R2443 n1_M2_46500_21660 n1_M2_47580_21660 0.988200
R2444 n1_M2_47580_21660 n1_M2_48660_21660 0.988200
R2445 n1_M2_48660_21660 n1_M2_49740_21660 0.988200
R2446 n1_M2_49740_21660 n1_M2_50820_21660 0.988200
R2447 n1_M2_50820_21660 n1_M2_51900_21660 0.988200
R2448 n1_M2_51900_21660 n1_M2_52980_21660 0.988200
R2449 n1_M2_52980_21660 n1_M2_54060_21660 0.988200
R2450 n1_M2_54060_21660 n1_M2_55140_21660 0.988200
R2451 n1_M2_55140_21660 n1_M2_56220_21660 0.988200
R2452 n1_M2_56220_21660 n1_M2_57300_21660 0.988200
R2453 n1_M2_57300_21660 n1_M2_58380_21660 0.988200
R2454 n1_M2_58380_21660 n1_M2_59460_21660 0.988200
R2455 n1_M2_59460_21660 n1_M2_60540_21660 0.988200
R2456 n1_M2_60540_21660 n1_M2_61620_21660 0.988200
R2457 n1_M2_61620_21660 n1_M2_62700_21660 0.988200
R2458 n1_M2_62700_21660 n1_M2_63780_21660 0.988200
R2459 n1_M2_63780_21660 n1_M2_64860_21660 0.988200
R2460 n1_M2_64860_21660 n1_M2_65940_21660 0.988200
R2461 n1_M2_65940_21660 n1_M2_67020_21660 0.988200
R2462 n1_M2_67020_21660 n1_M2_68100_21660 0.988200
R2463 n1_M2_68100_21660 n1_M2_69180_21660 0.988200
R2464 n1_M2_69180_21660 n1_M2_70260_21660 0.988200
R2465 n1_M2_70260_21660 n1_M2_71340_21660 0.988200
R2466 n1_M2_71340_21660 n1_M2_72420_21660 0.988200
R2467 n1_M2_72420_21660 n1_M2_73500_21660 0.988200
R2468 n1_M2_73500_21660 n1_M2_74580_21660 0.988200
R2469 n1_M2_74580_21660 n1_M2_75660_21660 0.988200
R2470 n1_M2_75660_21660 n1_M2_76740_21660 0.988200
R2471 n1_M2_76740_21660 n1_M2_77820_21660 0.988200
R2472 n1_M2_77820_21660 n1_M2_78900_21660 0.988200
R2473 n1_M2_78900_21660 n1_M2_79980_21660 0.988200
R2474 n1_M2_79980_21660 n1_M2_81060_21660 0.988200
R2475 n1_M2_81060_21660 n1_M2_82140_21660 0.988200
R2476 n1_M2_82140_21660 n1_M2_83220_21660 0.988200
R2477 n1_M2_83220_21660 n1_M2_84300_21660 0.988200
R2478 n1_M2_84300_21660 n1_M2_85380_21660 0.988200
R2479 n1_M2_85380_21660 n1_M2_86460_21660 0.988200
R2480 n1_M2_86460_21660 n1_M2_87540_21660 0.988200
R2481 n1_M2_87540_21660 n1_M2_88620_21660 0.988200
R2482 n1_M2_88620_21660 n1_M2_89700_21660 0.988200
R2483 n1_M2_89700_21660 n1_M2_90780_21660 0.988200
R2484 n1_M2_90780_21660 n1_M2_91860_21660 0.988200
R2485 n1_M2_91860_21660 n1_M2_92940_21660 0.988200
R2486 n1_M2_92940_21660 n1_M2_94020_21660 0.988200
R2487 n1_M2_94020_21660 n1_M2_95100_21660 0.988200
R2488 n1_M2_95100_21660 n1_M2_96180_21660 0.988200
R2489 n1_M2_96180_21660 n1_M2_97260_21660 0.988200
R2490 n1_M2_97260_21660 n1_M2_98340_21660 0.988200
R2491 n1_M2_98340_21660 n1_M2_99420_21660 0.988200
R2492 n1_M2_99420_21660 n1_M2_100500_21660 0.988200
R2493 n1_M2_100500_21660 n1_M2_101580_21660 0.988200
R2494 n1_M2_101580_21660 n1_M2_102660_21660 0.988200
R2495 n1_M2_102660_21660 n1_M2_103740_21660 0.988200
R2496 n1_M2_103740_21660 n1_M2_104820_21660 0.988200
R2497 n1_M2_104820_21660 n1_M2_105900_21660 0.988200
R2498 n1_M2_105900_21660 n1_M2_106980_21660 0.988200
R2499 n1_M2_106980_21660 n1_M2_108060_21660 0.988200
R2500 n1_M2_108060_21660 n1_M2_109140_21660 0.988200
R2501 n1_M2_109140_21660 n1_M2_110220_21660 0.988200
R2502 n1_M2_110220_21660 n1_M2_111300_21660 0.988200
R2503 n1_M2_111300_21660 n1_M2_112380_21660 0.988200
R2504 n1_M2_112380_21660 n1_M2_113460_21660 0.988200
R2505 n1_M2_113460_21660 n1_M2_114540_21660 0.988200
R2506 n1_M2_114540_21660 n1_M2_115620_21660 0.988200
R2507 n1_M2_115620_21660 n1_M2_116700_21660 0.988200
R2508 n1_M2_116700_21660 n1_M2_117780_21660 0.988200
R2509 n1_M2_117780_21660 n1_M2_118860_21660 0.988200
R2510 n1_M2_118860_21660 n1_M2_119940_21660 0.988200
R2511 n1_M2_119940_21660 n1_M2_121020_21660 0.988200
R2512 n1_M2_121020_21660 n1_M2_122100_21660 0.988200
R2513 n1_M2_122100_21660 n1_M2_123180_21660 0.988200
R2514 n1_M2_123180_21660 n1_M2_124260_21660 0.988200
R2515 n1_M2_124260_21660 n1_M2_125340_21660 0.988200
R2516 n1_M2_125340_21660 n1_M2_126420_21660 0.988200
R2517 n1_M2_126420_21660 n1_M2_127500_21660 0.988200
R2518 n1_M2_127500_21660 n1_M2_128580_21660 0.988200
R2519 n1_M2_128580_21660 n1_M2_129660_21660 0.988200
R2520 n1_M2_60_22740 n1_M2_1140_22740 0.988200
R2521 n1_M2_1140_22740 n1_M2_2220_22740 0.988200
R2522 n1_M2_2220_22740 n1_M2_3300_22740 0.988200
R2523 n1_M2_3300_22740 n1_M2_4380_22740 0.988200
R2524 n1_M2_4380_22740 n1_M2_5460_22740 0.988200
R2525 n1_M2_5460_22740 n1_M2_6540_22740 0.988200
R2526 n1_M2_6540_22740 n1_M2_7620_22740 0.988200
R2527 n1_M2_7620_22740 n1_M2_8700_22740 0.988200
R2528 n1_M2_8700_22740 n1_M2_9780_22740 0.988200
R2529 n1_M2_9780_22740 n1_M2_10860_22740 0.988200
R2530 n1_M2_10860_22740 n1_M2_11940_22740 0.988200
R2531 n1_M2_11940_22740 n1_M2_13020_22740 0.988200
R2532 n1_M2_13020_22740 n1_M2_14100_22740 0.988200
R2533 n1_M2_14100_22740 n1_M2_15180_22740 0.988200
R2534 n1_M2_15180_22740 n1_M2_16260_22740 0.988200
R2535 n1_M2_16260_22740 n1_M2_17340_22740 0.988200
R2536 n1_M2_17340_22740 n1_M2_18420_22740 0.988200
R2537 n1_M2_18420_22740 n1_M2_19500_22740 0.988200
R2538 n1_M2_19500_22740 n1_M2_20580_22740 0.988200
R2539 n1_M2_20580_22740 n1_M2_21660_22740 0.988200
R2540 n1_M2_21660_22740 n1_M2_22740_22740 0.988200
R2541 n1_M2_22740_22740 n1_M2_23820_22740 0.988200
R2542 n1_M2_23820_22740 n1_M2_24900_22740 0.988200
R2543 n1_M2_24900_22740 n1_M2_25980_22740 0.988200
R2544 n1_M2_25980_22740 n1_M2_27060_22740 0.988200
R2545 n1_M2_27060_22740 n1_M2_28140_22740 0.988200
R2546 n1_M2_28140_22740 n1_M2_29220_22740 0.988200
R2547 n1_M2_29220_22740 n1_M2_30300_22740 0.988200
R2548 n1_M2_30300_22740 n1_M2_31380_22740 0.988200
R2549 n1_M2_31380_22740 n1_M2_32460_22740 0.988200
R2550 n1_M2_32460_22740 n1_M2_33540_22740 0.988200
R2551 n1_M2_33540_22740 n1_M2_34620_22740 0.988200
R2552 n1_M2_34620_22740 n1_M2_35700_22740 0.988200
R2553 n1_M2_35700_22740 n1_M2_36780_22740 0.988200
R2554 n1_M2_36780_22740 n1_M2_37860_22740 0.988200
R2555 n1_M2_37860_22740 n1_M2_38940_22740 0.988200
R2556 n1_M2_38940_22740 n1_M2_40020_22740 0.988200
R2557 n1_M2_40020_22740 n1_M2_41100_22740 0.988200
R2558 n1_M2_41100_22740 n1_M2_42180_22740 0.988200
R2559 n1_M2_42180_22740 n1_M2_43260_22740 0.988200
R2560 n1_M2_43260_22740 n1_M2_44340_22740 0.988200
R2561 n1_M2_44340_22740 n1_M2_45420_22740 0.988200
R2562 n1_M2_45420_22740 n1_M2_46500_22740 0.988200
R2563 n1_M2_46500_22740 n1_M2_47580_22740 0.988200
R2564 n1_M2_47580_22740 n1_M2_48660_22740 0.988200
R2565 n1_M2_48660_22740 n1_M2_49740_22740 0.988200
R2566 n1_M2_49740_22740 n1_M2_50820_22740 0.988200
R2567 n1_M2_50820_22740 n1_M2_51900_22740 0.988200
R2568 n1_M2_51900_22740 n1_M2_52980_22740 0.988200
R2569 n1_M2_52980_22740 n1_M2_54060_22740 0.988200
R2570 n1_M2_54060_22740 n1_M2_55140_22740 0.988200
R2571 n1_M2_55140_22740 n1_M2_56220_22740 0.988200
R2572 n1_M2_56220_22740 n1_M2_57300_22740 0.988200
R2573 n1_M2_57300_22740 n1_M2_58380_22740 0.988200
R2574 n1_M2_58380_22740 n1_M2_59460_22740 0.988200
R2575 n1_M2_59460_22740 n1_M2_60540_22740 0.988200
R2576 n1_M2_60540_22740 n1_M2_61620_22740 0.988200
R2577 n1_M2_61620_22740 n1_M2_62700_22740 0.988200
R2578 n1_M2_62700_22740 n1_M2_63780_22740 0.988200
R2579 n1_M2_63780_22740 n1_M2_64860_22740 0.988200
R2580 n1_M2_64860_22740 n1_M2_65940_22740 0.988200
R2581 n1_M2_65940_22740 n1_M2_67020_22740 0.988200
R2582 n1_M2_67020_22740 n1_M2_68100_22740 0.988200
R2583 n1_M2_68100_22740 n1_M2_69180_22740 0.988200
R2584 n1_M2_69180_22740 n1_M2_70260_22740 0.988200
R2585 n1_M2_70260_22740 n1_M2_71340_22740 0.988200
R2586 n1_M2_71340_22740 n1_M2_72420_22740 0.988200
R2587 n1_M2_72420_22740 n1_M2_73500_22740 0.988200
R2588 n1_M2_73500_22740 n1_M2_74580_22740 0.988200
R2589 n1_M2_74580_22740 n1_M2_75660_22740 0.988200
R2590 n1_M2_75660_22740 n1_M2_76740_22740 0.988200
R2591 n1_M2_76740_22740 n1_M2_77820_22740 0.988200
R2592 n1_M2_77820_22740 n1_M2_78900_22740 0.988200
R2593 n1_M2_78900_22740 n1_M2_79980_22740 0.988200
R2594 n1_M2_79980_22740 n1_M2_81060_22740 0.988200
R2595 n1_M2_81060_22740 n1_M2_82140_22740 0.988200
R2596 n1_M2_82140_22740 n1_M2_83220_22740 0.988200
R2597 n1_M2_83220_22740 n1_M2_84300_22740 0.988200
R2598 n1_M2_84300_22740 n1_M2_85380_22740 0.988200
R2599 n1_M2_85380_22740 n1_M2_86460_22740 0.988200
R2600 n1_M2_86460_22740 n1_M2_87540_22740 0.988200
R2601 n1_M2_87540_22740 n1_M2_88620_22740 0.988200
R2602 n1_M2_88620_22740 n1_M2_89700_22740 0.988200
R2603 n1_M2_89700_22740 n1_M2_90780_22740 0.988200
R2604 n1_M2_90780_22740 n1_M2_91860_22740 0.988200
R2605 n1_M2_91860_22740 n1_M2_92940_22740 0.988200
R2606 n1_M2_92940_22740 n1_M2_94020_22740 0.988200
R2607 n1_M2_94020_22740 n1_M2_95100_22740 0.988200
R2608 n1_M2_95100_22740 n1_M2_96180_22740 0.988200
R2609 n1_M2_96180_22740 n1_M2_97260_22740 0.988200
R2610 n1_M2_97260_22740 n1_M2_98340_22740 0.988200
R2611 n1_M2_98340_22740 n1_M2_99420_22740 0.988200
R2612 n1_M2_99420_22740 n1_M2_100500_22740 0.988200
R2613 n1_M2_100500_22740 n1_M2_101580_22740 0.988200
R2614 n1_M2_101580_22740 n1_M2_102660_22740 0.988200
R2615 n1_M2_102660_22740 n1_M2_103740_22740 0.988200
R2616 n1_M2_103740_22740 n1_M2_104820_22740 0.988200
R2617 n1_M2_104820_22740 n1_M2_105900_22740 0.988200
R2618 n1_M2_105900_22740 n1_M2_106980_22740 0.988200
R2619 n1_M2_106980_22740 n1_M2_108060_22740 0.988200
R2620 n1_M2_108060_22740 n1_M2_109140_22740 0.988200
R2621 n1_M2_109140_22740 n1_M2_110220_22740 0.988200
R2622 n1_M2_110220_22740 n1_M2_111300_22740 0.988200
R2623 n1_M2_111300_22740 n1_M2_112380_22740 0.988200
R2624 n1_M2_112380_22740 n1_M2_113460_22740 0.988200
R2625 n1_M2_113460_22740 n1_M2_114540_22740 0.988200
R2626 n1_M2_114540_22740 n1_M2_115620_22740 0.988200
R2627 n1_M2_115620_22740 n1_M2_116700_22740 0.988200
R2628 n1_M2_116700_22740 n1_M2_117780_22740 0.988200
R2629 n1_M2_117780_22740 n1_M2_118860_22740 0.988200
R2630 n1_M2_118860_22740 n1_M2_119940_22740 0.988200
R2631 n1_M2_119940_22740 n1_M2_121020_22740 0.988200
R2632 n1_M2_121020_22740 n1_M2_122100_22740 0.988200
R2633 n1_M2_122100_22740 n1_M2_123180_22740 0.988200
R2634 n1_M2_123180_22740 n1_M2_124260_22740 0.988200
R2635 n1_M2_124260_22740 n1_M2_125340_22740 0.988200
R2636 n1_M2_125340_22740 n1_M2_126420_22740 0.988200
R2637 n1_M2_126420_22740 n1_M2_127500_22740 0.988200
R2638 n1_M2_127500_22740 n1_M2_128580_22740 0.988200
R2639 n1_M2_128580_22740 n1_M2_129660_22740 0.988200
R2640 n1_M2_60_23820 n1_M2_1140_23820 0.988200
R2641 n1_M2_1140_23820 n1_M2_2220_23820 0.988200
R2642 n1_M2_2220_23820 n1_M2_3300_23820 0.988200
R2643 n1_M2_3300_23820 n1_M2_4380_23820 0.988200
R2644 n1_M2_4380_23820 n1_M2_5460_23820 0.988200
R2645 n1_M2_5460_23820 n1_M2_6540_23820 0.988200
R2646 n1_M2_6540_23820 n1_M2_7620_23820 0.988200
R2647 n1_M2_7620_23820 n1_M2_8700_23820 0.988200
R2648 n1_M2_8700_23820 n1_M2_9780_23820 0.988200
R2649 n1_M2_9780_23820 n1_M2_10860_23820 0.988200
R2650 n1_M2_10860_23820 n1_M2_11940_23820 0.988200
R2651 n1_M2_11940_23820 n1_M2_13020_23820 0.988200
R2652 n1_M2_13020_23820 n1_M2_14100_23820 0.988200
R2653 n1_M2_14100_23820 n1_M2_15180_23820 0.988200
R2654 n1_M2_15180_23820 n1_M2_16260_23820 0.988200
R2655 n1_M2_16260_23820 n1_M2_17340_23820 0.988200
R2656 n1_M2_17340_23820 n1_M2_18420_23820 0.988200
R2657 n1_M2_18420_23820 n1_M2_19500_23820 0.988200
R2658 n1_M2_19500_23820 n1_M2_20580_23820 0.988200
R2659 n1_M2_20580_23820 n1_M2_21660_23820 0.988200
R2660 n1_M2_21660_23820 n1_M2_22740_23820 0.988200
R2661 n1_M2_22740_23820 n1_M2_23820_23820 0.988200
R2662 n1_M2_23820_23820 n1_M2_24900_23820 0.988200
R2663 n1_M2_24900_23820 n1_M2_25980_23820 0.988200
R2664 n1_M2_25980_23820 n1_M2_27060_23820 0.988200
R2665 n1_M2_27060_23820 n1_M2_28140_23820 0.988200
R2666 n1_M2_28140_23820 n1_M2_29220_23820 0.988200
R2667 n1_M2_29220_23820 n1_M2_30300_23820 0.988200
R2668 n1_M2_30300_23820 n1_M2_31380_23820 0.988200
R2669 n1_M2_31380_23820 n1_M2_32460_23820 0.988200
R2670 n1_M2_32460_23820 n1_M2_33540_23820 0.988200
R2671 n1_M2_33540_23820 n1_M2_34620_23820 0.988200
R2672 n1_M2_34620_23820 n1_M2_35700_23820 0.988200
R2673 n1_M2_35700_23820 n1_M2_36780_23820 0.988200
R2674 n1_M2_36780_23820 n1_M2_37860_23820 0.988200
R2675 n1_M2_37860_23820 n1_M2_38940_23820 0.988200
R2676 n1_M2_38940_23820 n1_M2_40020_23820 0.988200
R2677 n1_M2_40020_23820 n1_M2_41100_23820 0.988200
R2678 n1_M2_41100_23820 n1_M2_42180_23820 0.988200
R2679 n1_M2_42180_23820 n1_M2_43260_23820 0.988200
R2680 n1_M2_43260_23820 n1_M2_44340_23820 0.988200
R2681 n1_M2_44340_23820 n1_M2_45420_23820 0.988200
R2682 n1_M2_45420_23820 n1_M2_46500_23820 0.988200
R2683 n1_M2_46500_23820 n1_M2_47580_23820 0.988200
R2684 n1_M2_47580_23820 n1_M2_48660_23820 0.988200
R2685 n1_M2_48660_23820 n1_M2_49740_23820 0.988200
R2686 n1_M2_49740_23820 n1_M2_50820_23820 0.988200
R2687 n1_M2_50820_23820 n1_M2_51900_23820 0.988200
R2688 n1_M2_51900_23820 n1_M2_52980_23820 0.988200
R2689 n1_M2_52980_23820 n1_M2_54060_23820 0.988200
R2690 n1_M2_54060_23820 n1_M2_55140_23820 0.988200
R2691 n1_M2_55140_23820 n1_M2_56220_23820 0.988200
R2692 n1_M2_56220_23820 n1_M2_57300_23820 0.988200
R2693 n1_M2_57300_23820 n1_M2_58380_23820 0.988200
R2694 n1_M2_58380_23820 n1_M2_59460_23820 0.988200
R2695 n1_M2_59460_23820 n1_M2_60540_23820 0.988200
R2696 n1_M2_60540_23820 n1_M2_61620_23820 0.988200
R2697 n1_M2_61620_23820 n1_M2_62700_23820 0.988200
R2698 n1_M2_62700_23820 n1_M2_63780_23820 0.988200
R2699 n1_M2_63780_23820 n1_M2_64860_23820 0.988200
R2700 n1_M2_64860_23820 n1_M2_65940_23820 0.988200
R2701 n1_M2_65940_23820 n1_M2_67020_23820 0.988200
R2702 n1_M2_67020_23820 n1_M2_68100_23820 0.988200
R2703 n1_M2_68100_23820 n1_M2_69180_23820 0.988200
R2704 n1_M2_69180_23820 n1_M2_70260_23820 0.988200
R2705 n1_M2_70260_23820 n1_M2_71340_23820 0.988200
R2706 n1_M2_71340_23820 n1_M2_72420_23820 0.988200
R2707 n1_M2_72420_23820 n1_M2_73500_23820 0.988200
R2708 n1_M2_73500_23820 n1_M2_74580_23820 0.988200
R2709 n1_M2_74580_23820 n1_M2_75660_23820 0.988200
R2710 n1_M2_75660_23820 n1_M2_76740_23820 0.988200
R2711 n1_M2_76740_23820 n1_M2_77820_23820 0.988200
R2712 n1_M2_77820_23820 n1_M2_78900_23820 0.988200
R2713 n1_M2_78900_23820 n1_M2_79980_23820 0.988200
R2714 n1_M2_79980_23820 n1_M2_81060_23820 0.988200
R2715 n1_M2_81060_23820 n1_M2_82140_23820 0.988200
R2716 n1_M2_82140_23820 n1_M2_83220_23820 0.988200
R2717 n1_M2_83220_23820 n1_M2_84300_23820 0.988200
R2718 n1_M2_84300_23820 n1_M2_85380_23820 0.988200
R2719 n1_M2_85380_23820 n1_M2_86460_23820 0.988200
R2720 n1_M2_86460_23820 n1_M2_87540_23820 0.988200
R2721 n1_M2_87540_23820 n1_M2_88620_23820 0.988200
R2722 n1_M2_88620_23820 n1_M2_89700_23820 0.988200
R2723 n1_M2_89700_23820 n1_M2_90780_23820 0.988200
R2724 n1_M2_90780_23820 n1_M2_91860_23820 0.988200
R2725 n1_M2_91860_23820 n1_M2_92940_23820 0.988200
R2726 n1_M2_92940_23820 n1_M2_94020_23820 0.988200
R2727 n1_M2_94020_23820 n1_M2_95100_23820 0.988200
R2728 n1_M2_95100_23820 n1_M2_96180_23820 0.988200
R2729 n1_M2_96180_23820 n1_M2_97260_23820 0.988200
R2730 n1_M2_97260_23820 n1_M2_98340_23820 0.988200
R2731 n1_M2_98340_23820 n1_M2_99420_23820 0.988200
R2732 n1_M2_99420_23820 n1_M2_100500_23820 0.988200
R2733 n1_M2_100500_23820 n1_M2_101580_23820 0.988200
R2734 n1_M2_101580_23820 n1_M2_102660_23820 0.988200
R2735 n1_M2_102660_23820 n1_M2_103740_23820 0.988200
R2736 n1_M2_103740_23820 n1_M2_104820_23820 0.988200
R2737 n1_M2_104820_23820 n1_M2_105900_23820 0.988200
R2738 n1_M2_105900_23820 n1_M2_106980_23820 0.988200
R2739 n1_M2_106980_23820 n1_M2_108060_23820 0.988200
R2740 n1_M2_108060_23820 n1_M2_109140_23820 0.988200
R2741 n1_M2_109140_23820 n1_M2_110220_23820 0.988200
R2742 n1_M2_110220_23820 n1_M2_111300_23820 0.988200
R2743 n1_M2_111300_23820 n1_M2_112380_23820 0.988200
R2744 n1_M2_112380_23820 n1_M2_113460_23820 0.988200
R2745 n1_M2_113460_23820 n1_M2_114540_23820 0.988200
R2746 n1_M2_114540_23820 n1_M2_115620_23820 0.988200
R2747 n1_M2_115620_23820 n1_M2_116700_23820 0.988200
R2748 n1_M2_116700_23820 n1_M2_117780_23820 0.988200
R2749 n1_M2_117780_23820 n1_M2_118860_23820 0.988200
R2750 n1_M2_118860_23820 n1_M2_119940_23820 0.988200
R2751 n1_M2_119940_23820 n1_M2_121020_23820 0.988200
R2752 n1_M2_121020_23820 n1_M2_122100_23820 0.988200
R2753 n1_M2_122100_23820 n1_M2_123180_23820 0.988200
R2754 n1_M2_123180_23820 n1_M2_124260_23820 0.988200
R2755 n1_M2_124260_23820 n1_M2_125340_23820 0.988200
R2756 n1_M2_125340_23820 n1_M2_126420_23820 0.988200
R2757 n1_M2_126420_23820 n1_M2_127500_23820 0.988200
R2758 n1_M2_127500_23820 n1_M2_128580_23820 0.988200
R2759 n1_M2_128580_23820 n1_M2_129660_23820 0.988200
R2760 n1_M2_60_24900 n1_M2_1140_24900 0.988200
R2761 n1_M2_1140_24900 n1_M2_2220_24900 0.988200
R2762 n1_M2_2220_24900 n1_M2_3300_24900 0.988200
R2763 n1_M2_3300_24900 n1_M2_4380_24900 0.988200
R2764 n1_M2_4380_24900 n1_M2_5460_24900 0.988200
R2765 n1_M2_5460_24900 n1_M2_6540_24900 0.988200
R2766 n1_M2_6540_24900 n1_M2_7620_24900 0.988200
R2767 n1_M2_7620_24900 n1_M2_8700_24900 0.988200
R2768 n1_M2_8700_24900 n1_M2_9780_24900 0.988200
R2769 n1_M2_9780_24900 n1_M2_10860_24900 0.988200
R2770 n1_M2_10860_24900 n1_M2_11940_24900 0.988200
R2771 n1_M2_11940_24900 n1_M2_13020_24900 0.988200
R2772 n1_M2_13020_24900 n1_M2_14100_24900 0.988200
R2773 n1_M2_14100_24900 n1_M2_15180_24900 0.988200
R2774 n1_M2_15180_24900 n1_M2_16260_24900 0.988200
R2775 n1_M2_16260_24900 n1_M2_17340_24900 0.988200
R2776 n1_M2_17340_24900 n1_M2_18420_24900 0.988200
R2777 n1_M2_18420_24900 n1_M2_19500_24900 0.988200
R2778 n1_M2_19500_24900 n1_M2_20580_24900 0.988200
R2779 n1_M2_20580_24900 n1_M2_21660_24900 0.988200
R2780 n1_M2_21660_24900 n1_M2_22740_24900 0.988200
R2781 n1_M2_22740_24900 n1_M2_23820_24900 0.988200
R2782 n1_M2_23820_24900 n1_M2_24900_24900 0.988200
R2783 n1_M2_24900_24900 n1_M2_25980_24900 0.988200
R2784 n1_M2_25980_24900 n1_M2_27060_24900 0.988200
R2785 n1_M2_27060_24900 n1_M2_28140_24900 0.988200
R2786 n1_M2_28140_24900 n1_M2_29220_24900 0.988200
R2787 n1_M2_29220_24900 n1_M2_30300_24900 0.988200
R2788 n1_M2_30300_24900 n1_M2_31380_24900 0.988200
R2789 n1_M2_31380_24900 n1_M2_32460_24900 0.988200
R2790 n1_M2_32460_24900 n1_M2_33540_24900 0.988200
R2791 n1_M2_33540_24900 n1_M2_34620_24900 0.988200
R2792 n1_M2_34620_24900 n1_M2_35700_24900 0.988200
R2793 n1_M2_35700_24900 n1_M2_36780_24900 0.988200
R2794 n1_M2_36780_24900 n1_M2_37860_24900 0.988200
R2795 n1_M2_37860_24900 n1_M2_38940_24900 0.988200
R2796 n1_M2_38940_24900 n1_M2_40020_24900 0.988200
R2797 n1_M2_40020_24900 n1_M2_41100_24900 0.988200
R2798 n1_M2_41100_24900 n1_M2_42180_24900 0.988200
R2799 n1_M2_42180_24900 n1_M2_43260_24900 0.988200
R2800 n1_M2_43260_24900 n1_M2_44340_24900 0.988200
R2801 n1_M2_44340_24900 n1_M2_45420_24900 0.988200
R2802 n1_M2_45420_24900 n1_M2_46500_24900 0.988200
R2803 n1_M2_46500_24900 n1_M2_47580_24900 0.988200
R2804 n1_M2_47580_24900 n1_M2_48660_24900 0.988200
R2805 n1_M2_48660_24900 n1_M2_49740_24900 0.988200
R2806 n1_M2_49740_24900 n1_M2_50820_24900 0.988200
R2807 n1_M2_50820_24900 n1_M2_51900_24900 0.988200
R2808 n1_M2_51900_24900 n1_M2_52980_24900 0.988200
R2809 n1_M2_52980_24900 n1_M2_54060_24900 0.988200
R2810 n1_M2_54060_24900 n1_M2_55140_24900 0.988200
R2811 n1_M2_55140_24900 n1_M2_56220_24900 0.988200
R2812 n1_M2_56220_24900 n1_M2_57300_24900 0.988200
R2813 n1_M2_57300_24900 n1_M2_58380_24900 0.988200
R2814 n1_M2_58380_24900 n1_M2_59460_24900 0.988200
R2815 n1_M2_59460_24900 n1_M2_60540_24900 0.988200
R2816 n1_M2_60540_24900 n1_M2_61620_24900 0.988200
R2817 n1_M2_61620_24900 n1_M2_62700_24900 0.988200
R2818 n1_M2_62700_24900 n1_M2_63780_24900 0.988200
R2819 n1_M2_63780_24900 n1_M2_64860_24900 0.988200
R2820 n1_M2_64860_24900 n1_M2_65940_24900 0.988200
R2821 n1_M2_65940_24900 n1_M2_67020_24900 0.988200
R2822 n1_M2_67020_24900 n1_M2_68100_24900 0.988200
R2823 n1_M2_68100_24900 n1_M2_69180_24900 0.988200
R2824 n1_M2_69180_24900 n1_M2_70260_24900 0.988200
R2825 n1_M2_70260_24900 n1_M2_71340_24900 0.988200
R2826 n1_M2_71340_24900 n1_M2_72420_24900 0.988200
R2827 n1_M2_72420_24900 n1_M2_73500_24900 0.988200
R2828 n1_M2_73500_24900 n1_M2_74580_24900 0.988200
R2829 n1_M2_74580_24900 n1_M2_75660_24900 0.988200
R2830 n1_M2_75660_24900 n1_M2_76740_24900 0.988200
R2831 n1_M2_76740_24900 n1_M2_77820_24900 0.988200
R2832 n1_M2_77820_24900 n1_M2_78900_24900 0.988200
R2833 n1_M2_78900_24900 n1_M2_79980_24900 0.988200
R2834 n1_M2_79980_24900 n1_M2_81060_24900 0.988200
R2835 n1_M2_81060_24900 n1_M2_82140_24900 0.988200
R2836 n1_M2_82140_24900 n1_M2_83220_24900 0.988200
R2837 n1_M2_83220_24900 n1_M2_84300_24900 0.988200
R2838 n1_M2_84300_24900 n1_M2_85380_24900 0.988200
R2839 n1_M2_85380_24900 n1_M2_86460_24900 0.988200
R2840 n1_M2_86460_24900 n1_M2_87540_24900 0.988200
R2841 n1_M2_87540_24900 n1_M2_88620_24900 0.988200
R2842 n1_M2_88620_24900 n1_M2_89700_24900 0.988200
R2843 n1_M2_89700_24900 n1_M2_90780_24900 0.988200
R2844 n1_M2_90780_24900 n1_M2_91860_24900 0.988200
R2845 n1_M2_91860_24900 n1_M2_92940_24900 0.988200
R2846 n1_M2_92940_24900 n1_M2_94020_24900 0.988200
R2847 n1_M2_94020_24900 n1_M2_95100_24900 0.988200
R2848 n1_M2_95100_24900 n1_M2_96180_24900 0.988200
R2849 n1_M2_96180_24900 n1_M2_97260_24900 0.988200
R2850 n1_M2_97260_24900 n1_M2_98340_24900 0.988200
R2851 n1_M2_98340_24900 n1_M2_99420_24900 0.988200
R2852 n1_M2_99420_24900 n1_M2_100500_24900 0.988200
R2853 n1_M2_100500_24900 n1_M2_101580_24900 0.988200
R2854 n1_M2_101580_24900 n1_M2_102660_24900 0.988200
R2855 n1_M2_102660_24900 n1_M2_103740_24900 0.988200
R2856 n1_M2_103740_24900 n1_M2_104820_24900 0.988200
R2857 n1_M2_104820_24900 n1_M2_105900_24900 0.988200
R2858 n1_M2_105900_24900 n1_M2_106980_24900 0.988200
R2859 n1_M2_106980_24900 n1_M2_108060_24900 0.988200
R2860 n1_M2_108060_24900 n1_M2_109140_24900 0.988200
R2861 n1_M2_109140_24900 n1_M2_110220_24900 0.988200
R2862 n1_M2_110220_24900 n1_M2_111300_24900 0.988200
R2863 n1_M2_111300_24900 n1_M2_112380_24900 0.988200
R2864 n1_M2_112380_24900 n1_M2_113460_24900 0.988200
R2865 n1_M2_113460_24900 n1_M2_114540_24900 0.988200
R2866 n1_M2_114540_24900 n1_M2_115620_24900 0.988200
R2867 n1_M2_115620_24900 n1_M2_116700_24900 0.988200
R2868 n1_M2_116700_24900 n1_M2_117780_24900 0.988200
R2869 n1_M2_117780_24900 n1_M2_118860_24900 0.988200
R2870 n1_M2_118860_24900 n1_M2_119940_24900 0.988200
R2871 n1_M2_119940_24900 n1_M2_121020_24900 0.988200
R2872 n1_M2_121020_24900 n1_M2_122100_24900 0.988200
R2873 n1_M2_122100_24900 n1_M2_123180_24900 0.988200
R2874 n1_M2_123180_24900 n1_M2_124260_24900 0.988200
R2875 n1_M2_124260_24900 n1_M2_125340_24900 0.988200
R2876 n1_M2_125340_24900 n1_M2_126420_24900 0.988200
R2877 n1_M2_126420_24900 n1_M2_127500_24900 0.988200
R2878 n1_M2_127500_24900 n1_M2_128580_24900 0.988200
R2879 n1_M2_128580_24900 n1_M2_129660_24900 0.988200
R2880 n1_M2_60_25980 n1_M2_1140_25980 0.988200
R2881 n1_M2_1140_25980 n1_M2_2220_25980 0.988200
R2882 n1_M2_2220_25980 n1_M2_3300_25980 0.988200
R2883 n1_M2_3300_25980 n1_M2_4380_25980 0.988200
R2884 n1_M2_4380_25980 n1_M2_5460_25980 0.988200
R2885 n1_M2_5460_25980 n1_M2_6540_25980 0.988200
R2886 n1_M2_6540_25980 n1_M2_7620_25980 0.988200
R2887 n1_M2_7620_25980 n1_M2_8700_25980 0.988200
R2888 n1_M2_8700_25980 n1_M2_9780_25980 0.988200
R2889 n1_M2_9780_25980 n1_M2_10860_25980 0.988200
R2890 n1_M2_10860_25980 n1_M2_11940_25980 0.988200
R2891 n1_M2_11940_25980 n1_M2_13020_25980 0.988200
R2892 n1_M2_13020_25980 n1_M2_14100_25980 0.988200
R2893 n1_M2_14100_25980 n1_M2_15180_25980 0.988200
R2894 n1_M2_15180_25980 n1_M2_16260_25980 0.988200
R2895 n1_M2_16260_25980 n1_M2_17340_25980 0.988200
R2896 n1_M2_17340_25980 n1_M2_18420_25980 0.988200
R2897 n1_M2_18420_25980 n1_M2_19500_25980 0.988200
R2898 n1_M2_19500_25980 n1_M2_20580_25980 0.988200
R2899 n1_M2_20580_25980 n1_M2_21660_25980 0.988200
R2900 n1_M2_21660_25980 n1_M2_22740_25980 0.988200
R2901 n1_M2_22740_25980 n1_M2_23820_25980 0.988200
R2902 n1_M2_23820_25980 n1_M2_24900_25980 0.988200
R2903 n1_M2_24900_25980 n1_M2_25980_25980 0.988200
R2904 n1_M2_25980_25980 n1_M2_27060_25980 0.988200
R2905 n1_M2_27060_25980 n1_M2_28140_25980 0.988200
R2906 n1_M2_28140_25980 n1_M2_29220_25980 0.988200
R2907 n1_M2_29220_25980 n1_M2_30300_25980 0.988200
R2908 n1_M2_30300_25980 n1_M2_31380_25980 0.988200
R2909 n1_M2_31380_25980 n1_M2_32460_25980 0.988200
R2910 n1_M2_32460_25980 n1_M2_33540_25980 0.988200
R2911 n1_M2_33540_25980 n1_M2_34620_25980 0.988200
R2912 n1_M2_34620_25980 n1_M2_35700_25980 0.988200
R2913 n1_M2_35700_25980 n1_M2_36780_25980 0.988200
R2914 n1_M2_36780_25980 n1_M2_37860_25980 0.988200
R2915 n1_M2_37860_25980 n1_M2_38940_25980 0.988200
R2916 n1_M2_38940_25980 n1_M2_40020_25980 0.988200
R2917 n1_M2_40020_25980 n1_M2_41100_25980 0.988200
R2918 n1_M2_41100_25980 n1_M2_42180_25980 0.988200
R2919 n1_M2_42180_25980 n1_M2_43260_25980 0.988200
R2920 n1_M2_43260_25980 n1_M2_44340_25980 0.988200
R2921 n1_M2_44340_25980 n1_M2_45420_25980 0.988200
R2922 n1_M2_45420_25980 n1_M2_46500_25980 0.988200
R2923 n1_M2_46500_25980 n1_M2_47580_25980 0.988200
R2924 n1_M2_47580_25980 n1_M2_48660_25980 0.988200
R2925 n1_M2_48660_25980 n1_M2_49740_25980 0.988200
R2926 n1_M2_49740_25980 n1_M2_50820_25980 0.988200
R2927 n1_M2_50820_25980 n1_M2_51900_25980 0.988200
R2928 n1_M2_51900_25980 n1_M2_52980_25980 0.988200
R2929 n1_M2_52980_25980 n1_M2_54060_25980 0.988200
R2930 n1_M2_54060_25980 n1_M2_55140_25980 0.988200
R2931 n1_M2_55140_25980 n1_M2_56220_25980 0.988200
R2932 n1_M2_56220_25980 n1_M2_57300_25980 0.988200
R2933 n1_M2_57300_25980 n1_M2_58380_25980 0.988200
R2934 n1_M2_58380_25980 n1_M2_59460_25980 0.988200
R2935 n1_M2_59460_25980 n1_M2_60540_25980 0.988200
R2936 n1_M2_60540_25980 n1_M2_61620_25980 0.988200
R2937 n1_M2_61620_25980 n1_M2_62700_25980 0.988200
R2938 n1_M2_62700_25980 n1_M2_63780_25980 0.988200
R2939 n1_M2_63780_25980 n1_M2_64860_25980 0.988200
R2940 n1_M2_64860_25980 n1_M2_65940_25980 0.988200
R2941 n1_M2_65940_25980 n1_M2_67020_25980 0.988200
R2942 n1_M2_67020_25980 n1_M2_68100_25980 0.988200
R2943 n1_M2_68100_25980 n1_M2_69180_25980 0.988200
R2944 n1_M2_69180_25980 n1_M2_70260_25980 0.988200
R2945 n1_M2_70260_25980 n1_M2_71340_25980 0.988200
R2946 n1_M2_71340_25980 n1_M2_72420_25980 0.988200
R2947 n1_M2_72420_25980 n1_M2_73500_25980 0.988200
R2948 n1_M2_73500_25980 n1_M2_74580_25980 0.988200
R2949 n1_M2_74580_25980 n1_M2_75660_25980 0.988200
R2950 n1_M2_75660_25980 n1_M2_76740_25980 0.988200
R2951 n1_M2_76740_25980 n1_M2_77820_25980 0.988200
R2952 n1_M2_77820_25980 n1_M2_78900_25980 0.988200
R2953 n1_M2_78900_25980 n1_M2_79980_25980 0.988200
R2954 n1_M2_79980_25980 n1_M2_81060_25980 0.988200
R2955 n1_M2_81060_25980 n1_M2_82140_25980 0.988200
R2956 n1_M2_82140_25980 n1_M2_83220_25980 0.988200
R2957 n1_M2_83220_25980 n1_M2_84300_25980 0.988200
R2958 n1_M2_84300_25980 n1_M2_85380_25980 0.988200
R2959 n1_M2_85380_25980 n1_M2_86460_25980 0.988200
R2960 n1_M2_86460_25980 n1_M2_87540_25980 0.988200
R2961 n1_M2_87540_25980 n1_M2_88620_25980 0.988200
R2962 n1_M2_88620_25980 n1_M2_89700_25980 0.988200
R2963 n1_M2_89700_25980 n1_M2_90780_25980 0.988200
R2964 n1_M2_90780_25980 n1_M2_91860_25980 0.988200
R2965 n1_M2_91860_25980 n1_M2_92940_25980 0.988200
R2966 n1_M2_92940_25980 n1_M2_94020_25980 0.988200
R2967 n1_M2_94020_25980 n1_M2_95100_25980 0.988200
R2968 n1_M2_95100_25980 n1_M2_96180_25980 0.988200
R2969 n1_M2_96180_25980 n1_M2_97260_25980 0.988200
R2970 n1_M2_97260_25980 n1_M2_98340_25980 0.988200
R2971 n1_M2_98340_25980 n1_M2_99420_25980 0.988200
R2972 n1_M2_99420_25980 n1_M2_100500_25980 0.988200
R2973 n1_M2_100500_25980 n1_M2_101580_25980 0.988200
R2974 n1_M2_101580_25980 n1_M2_102660_25980 0.988200
R2975 n1_M2_102660_25980 n1_M2_103740_25980 0.988200
R2976 n1_M2_103740_25980 n1_M2_104820_25980 0.988200
R2977 n1_M2_104820_25980 n1_M2_105900_25980 0.988200
R2978 n1_M2_105900_25980 n1_M2_106980_25980 0.988200
R2979 n1_M2_106980_25980 n1_M2_108060_25980 0.988200
R2980 n1_M2_108060_25980 n1_M2_109140_25980 0.988200
R2981 n1_M2_109140_25980 n1_M2_110220_25980 0.988200
R2982 n1_M2_110220_25980 n1_M2_111300_25980 0.988200
R2983 n1_M2_111300_25980 n1_M2_112380_25980 0.988200
R2984 n1_M2_112380_25980 n1_M2_113460_25980 0.988200
R2985 n1_M2_113460_25980 n1_M2_114540_25980 0.988200
R2986 n1_M2_114540_25980 n1_M2_115620_25980 0.988200
R2987 n1_M2_115620_25980 n1_M2_116700_25980 0.988200
R2988 n1_M2_116700_25980 n1_M2_117780_25980 0.988200
R2989 n1_M2_117780_25980 n1_M2_118860_25980 0.988200
R2990 n1_M2_118860_25980 n1_M2_119940_25980 0.988200
R2991 n1_M2_119940_25980 n1_M2_121020_25980 0.988200
R2992 n1_M2_121020_25980 n1_M2_122100_25980 0.988200
R2993 n1_M2_122100_25980 n1_M2_123180_25980 0.988200
R2994 n1_M2_123180_25980 n1_M2_124260_25980 0.988200
R2995 n1_M2_124260_25980 n1_M2_125340_25980 0.988200
R2996 n1_M2_125340_25980 n1_M2_126420_25980 0.988200
R2997 n1_M2_126420_25980 n1_M2_127500_25980 0.988200
R2998 n1_M2_127500_25980 n1_M2_128580_25980 0.988200
R2999 n1_M2_128580_25980 n1_M2_129660_25980 0.988200
R3000 n1_M2_60_27060 n1_M2_1140_27060 0.988200
R3001 n1_M2_1140_27060 n1_M2_2220_27060 0.988200
R3002 n1_M2_2220_27060 n1_M2_3300_27060 0.988200
R3003 n1_M2_3300_27060 n1_M2_4380_27060 0.988200
R3004 n1_M2_4380_27060 n1_M2_5460_27060 0.988200
R3005 n1_M2_5460_27060 n1_M2_6540_27060 0.988200
R3006 n1_M2_6540_27060 n1_M2_7620_27060 0.988200
R3007 n1_M2_7620_27060 n1_M2_8700_27060 0.988200
R3008 n1_M2_8700_27060 n1_M2_9780_27060 0.988200
R3009 n1_M2_9780_27060 n1_M2_10860_27060 0.988200
R3010 n1_M2_10860_27060 n1_M2_11940_27060 0.988200
R3011 n1_M2_11940_27060 n1_M2_13020_27060 0.988200
R3012 n1_M2_13020_27060 n1_M2_14100_27060 0.988200
R3013 n1_M2_14100_27060 n1_M2_15180_27060 0.988200
R3014 n1_M2_15180_27060 n1_M2_16260_27060 0.988200
R3015 n1_M2_16260_27060 n1_M2_17340_27060 0.988200
R3016 n1_M2_17340_27060 n1_M2_18420_27060 0.988200
R3017 n1_M2_18420_27060 n1_M2_19500_27060 0.988200
R3018 n1_M2_19500_27060 n1_M2_20580_27060 0.988200
R3019 n1_M2_20580_27060 n1_M2_21660_27060 0.988200
R3020 n1_M2_21660_27060 n1_M2_22740_27060 0.988200
R3021 n1_M2_22740_27060 n1_M2_23820_27060 0.988200
R3022 n1_M2_23820_27060 n1_M2_24900_27060 0.988200
R3023 n1_M2_24900_27060 n1_M2_25980_27060 0.988200
R3024 n1_M2_25980_27060 n1_M2_27060_27060 0.988200
R3025 n1_M2_27060_27060 n1_M2_28140_27060 0.988200
R3026 n1_M2_28140_27060 n1_M2_29220_27060 0.988200
R3027 n1_M2_29220_27060 n1_M2_30300_27060 0.988200
R3028 n1_M2_30300_27060 n1_M2_31380_27060 0.988200
R3029 n1_M2_31380_27060 n1_M2_32460_27060 0.988200
R3030 n1_M2_32460_27060 n1_M2_33540_27060 0.988200
R3031 n1_M2_33540_27060 n1_M2_34620_27060 0.988200
R3032 n1_M2_34620_27060 n1_M2_35700_27060 0.988200
R3033 n1_M2_35700_27060 n1_M2_36780_27060 0.988200
R3034 n1_M2_36780_27060 n1_M2_37860_27060 0.988200
R3035 n1_M2_37860_27060 n1_M2_38940_27060 0.988200
R3036 n1_M2_38940_27060 n1_M2_40020_27060 0.988200
R3037 n1_M2_40020_27060 n1_M2_41100_27060 0.988200
R3038 n1_M2_41100_27060 n1_M2_42180_27060 0.988200
R3039 n1_M2_42180_27060 n1_M2_43260_27060 0.988200
R3040 n1_M2_43260_27060 n1_M2_44340_27060 0.988200
R3041 n1_M2_44340_27060 n1_M2_45420_27060 0.988200
R3042 n1_M2_45420_27060 n1_M2_46500_27060 0.988200
R3043 n1_M2_46500_27060 n1_M2_47580_27060 0.988200
R3044 n1_M2_47580_27060 n1_M2_48660_27060 0.988200
R3045 n1_M2_48660_27060 n1_M2_49740_27060 0.988200
R3046 n1_M2_49740_27060 n1_M2_50820_27060 0.988200
R3047 n1_M2_50820_27060 n1_M2_51900_27060 0.988200
R3048 n1_M2_51900_27060 n1_M2_52980_27060 0.988200
R3049 n1_M2_52980_27060 n1_M2_54060_27060 0.988200
R3050 n1_M2_54060_27060 n1_M2_55140_27060 0.988200
R3051 n1_M2_55140_27060 n1_M2_56220_27060 0.988200
R3052 n1_M2_56220_27060 n1_M2_57300_27060 0.988200
R3053 n1_M2_57300_27060 n1_M2_58380_27060 0.988200
R3054 n1_M2_58380_27060 n1_M2_59460_27060 0.988200
R3055 n1_M2_59460_27060 n1_M2_60540_27060 0.988200
R3056 n1_M2_60540_27060 n1_M2_61620_27060 0.988200
R3057 n1_M2_61620_27060 n1_M2_62700_27060 0.988200
R3058 n1_M2_62700_27060 n1_M2_63780_27060 0.988200
R3059 n1_M2_63780_27060 n1_M2_64860_27060 0.988200
R3060 n1_M2_64860_27060 n1_M2_65940_27060 0.988200
R3061 n1_M2_65940_27060 n1_M2_67020_27060 0.988200
R3062 n1_M2_67020_27060 n1_M2_68100_27060 0.988200
R3063 n1_M2_68100_27060 n1_M2_69180_27060 0.988200
R3064 n1_M2_69180_27060 n1_M2_70260_27060 0.988200
R3065 n1_M2_70260_27060 n1_M2_71340_27060 0.988200
R3066 n1_M2_71340_27060 n1_M2_72420_27060 0.988200
R3067 n1_M2_72420_27060 n1_M2_73500_27060 0.988200
R3068 n1_M2_73500_27060 n1_M2_74580_27060 0.988200
R3069 n1_M2_74580_27060 n1_M2_75660_27060 0.988200
R3070 n1_M2_75660_27060 n1_M2_76740_27060 0.988200
R3071 n1_M2_76740_27060 n1_M2_77820_27060 0.988200
R3072 n1_M2_77820_27060 n1_M2_78900_27060 0.988200
R3073 n1_M2_78900_27060 n1_M2_79980_27060 0.988200
R3074 n1_M2_79980_27060 n1_M2_81060_27060 0.988200
R3075 n1_M2_81060_27060 n1_M2_82140_27060 0.988200
R3076 n1_M2_82140_27060 n1_M2_83220_27060 0.988200
R3077 n1_M2_83220_27060 n1_M2_84300_27060 0.988200
R3078 n1_M2_84300_27060 n1_M2_85380_27060 0.988200
R3079 n1_M2_85380_27060 n1_M2_86460_27060 0.988200
R3080 n1_M2_86460_27060 n1_M2_87540_27060 0.988200
R3081 n1_M2_87540_27060 n1_M2_88620_27060 0.988200
R3082 n1_M2_88620_27060 n1_M2_89700_27060 0.988200
R3083 n1_M2_89700_27060 n1_M2_90780_27060 0.988200
R3084 n1_M2_90780_27060 n1_M2_91860_27060 0.988200
R3085 n1_M2_91860_27060 n1_M2_92940_27060 0.988200
R3086 n1_M2_92940_27060 n1_M2_94020_27060 0.988200
R3087 n1_M2_94020_27060 n1_M2_95100_27060 0.988200
R3088 n1_M2_95100_27060 n1_M2_96180_27060 0.988200
R3089 n1_M2_96180_27060 n1_M2_97260_27060 0.988200
R3090 n1_M2_97260_27060 n1_M2_98340_27060 0.988200
R3091 n1_M2_98340_27060 n1_M2_99420_27060 0.988200
R3092 n1_M2_99420_27060 n1_M2_100500_27060 0.988200
R3093 n1_M2_100500_27060 n1_M2_101580_27060 0.988200
R3094 n1_M2_101580_27060 n1_M2_102660_27060 0.988200
R3095 n1_M2_102660_27060 n1_M2_103740_27060 0.988200
R3096 n1_M2_103740_27060 n1_M2_104820_27060 0.988200
R3097 n1_M2_104820_27060 n1_M2_105900_27060 0.988200
R3098 n1_M2_105900_27060 n1_M2_106980_27060 0.988200
R3099 n1_M2_106980_27060 n1_M2_108060_27060 0.988200
R3100 n1_M2_108060_27060 n1_M2_109140_27060 0.988200
R3101 n1_M2_109140_27060 n1_M2_110220_27060 0.988200
R3102 n1_M2_110220_27060 n1_M2_111300_27060 0.988200
R3103 n1_M2_111300_27060 n1_M2_112380_27060 0.988200
R3104 n1_M2_112380_27060 n1_M2_113460_27060 0.988200
R3105 n1_M2_113460_27060 n1_M2_114540_27060 0.988200
R3106 n1_M2_114540_27060 n1_M2_115620_27060 0.988200
R3107 n1_M2_115620_27060 n1_M2_116700_27060 0.988200
R3108 n1_M2_116700_27060 n1_M2_117780_27060 0.988200
R3109 n1_M2_117780_27060 n1_M2_118860_27060 0.988200
R3110 n1_M2_118860_27060 n1_M2_119940_27060 0.988200
R3111 n1_M2_119940_27060 n1_M2_121020_27060 0.988200
R3112 n1_M2_121020_27060 n1_M2_122100_27060 0.988200
R3113 n1_M2_122100_27060 n1_M2_123180_27060 0.988200
R3114 n1_M2_123180_27060 n1_M2_124260_27060 0.988200
R3115 n1_M2_124260_27060 n1_M2_125340_27060 0.988200
R3116 n1_M2_125340_27060 n1_M2_126420_27060 0.988200
R3117 n1_M2_126420_27060 n1_M2_127500_27060 0.988200
R3118 n1_M2_127500_27060 n1_M2_128580_27060 0.988200
R3119 n1_M2_128580_27060 n1_M2_129660_27060 0.988200
R3120 n1_M2_60_28140 n1_M2_1140_28140 0.988200
R3121 n1_M2_1140_28140 n1_M2_2220_28140 0.988200
R3122 n1_M2_2220_28140 n1_M2_3300_28140 0.988200
R3123 n1_M2_3300_28140 n1_M2_4380_28140 0.988200
R3124 n1_M2_4380_28140 n1_M2_5460_28140 0.988200
R3125 n1_M2_5460_28140 n1_M2_6540_28140 0.988200
R3126 n1_M2_6540_28140 n1_M2_7620_28140 0.988200
R3127 n1_M2_7620_28140 n1_M2_8700_28140 0.988200
R3128 n1_M2_8700_28140 n1_M2_9780_28140 0.988200
R3129 n1_M2_9780_28140 n1_M2_10860_28140 0.988200
R3130 n1_M2_10860_28140 n1_M2_11940_28140 0.988200
R3131 n1_M2_11940_28140 n1_M2_13020_28140 0.988200
R3132 n1_M2_13020_28140 n1_M2_14100_28140 0.988200
R3133 n1_M2_14100_28140 n1_M2_15180_28140 0.988200
R3134 n1_M2_15180_28140 n1_M2_16260_28140 0.988200
R3135 n1_M2_16260_28140 n1_M2_17340_28140 0.988200
R3136 n1_M2_17340_28140 n1_M2_18420_28140 0.988200
R3137 n1_M2_18420_28140 n1_M2_19500_28140 0.988200
R3138 n1_M2_19500_28140 n1_M2_20580_28140 0.988200
R3139 n1_M2_20580_28140 n1_M2_21660_28140 0.988200
R3140 n1_M2_21660_28140 n1_M2_22740_28140 0.988200
R3141 n1_M2_22740_28140 n1_M2_23820_28140 0.988200
R3142 n1_M2_23820_28140 n1_M2_24900_28140 0.988200
R3143 n1_M2_24900_28140 n1_M2_25980_28140 0.988200
R3144 n1_M2_25980_28140 n1_M2_27060_28140 0.988200
R3145 n1_M2_27060_28140 n1_M2_28140_28140 0.988200
R3146 n1_M2_28140_28140 n1_M2_29220_28140 0.988200
R3147 n1_M2_29220_28140 n1_M2_30300_28140 0.988200
R3148 n1_M2_30300_28140 n1_M2_31380_28140 0.988200
R3149 n1_M2_31380_28140 n1_M2_32460_28140 0.988200
R3150 n1_M2_32460_28140 n1_M2_33540_28140 0.988200
R3151 n1_M2_33540_28140 n1_M2_34620_28140 0.988200
R3152 n1_M2_34620_28140 n1_M2_35700_28140 0.988200
R3153 n1_M2_35700_28140 n1_M2_36780_28140 0.988200
R3154 n1_M2_36780_28140 n1_M2_37860_28140 0.988200
R3155 n1_M2_37860_28140 n1_M2_38940_28140 0.988200
R3156 n1_M2_38940_28140 n1_M2_40020_28140 0.988200
R3157 n1_M2_40020_28140 n1_M2_41100_28140 0.988200
R3158 n1_M2_41100_28140 n1_M2_42180_28140 0.988200
R3159 n1_M2_42180_28140 n1_M2_43260_28140 0.988200
R3160 n1_M2_43260_28140 n1_M2_44340_28140 0.988200
R3161 n1_M2_44340_28140 n1_M2_45420_28140 0.988200
R3162 n1_M2_45420_28140 n1_M2_46500_28140 0.988200
R3163 n1_M2_46500_28140 n1_M2_47580_28140 0.988200
R3164 n1_M2_47580_28140 n1_M2_48660_28140 0.988200
R3165 n1_M2_48660_28140 n1_M2_49740_28140 0.988200
R3166 n1_M2_49740_28140 n1_M2_50820_28140 0.988200
R3167 n1_M2_50820_28140 n1_M2_51900_28140 0.988200
R3168 n1_M2_51900_28140 n1_M2_52980_28140 0.988200
R3169 n1_M2_52980_28140 n1_M2_54060_28140 0.988200
R3170 n1_M2_54060_28140 n1_M2_55140_28140 0.988200
R3171 n1_M2_55140_28140 n1_M2_56220_28140 0.988200
R3172 n1_M2_56220_28140 n1_M2_57300_28140 0.988200
R3173 n1_M2_57300_28140 n1_M2_58380_28140 0.988200
R3174 n1_M2_58380_28140 n1_M2_59460_28140 0.988200
R3175 n1_M2_59460_28140 n1_M2_60540_28140 0.988200
R3176 n1_M2_60540_28140 n1_M2_61620_28140 0.988200
R3177 n1_M2_61620_28140 n1_M2_62700_28140 0.988200
R3178 n1_M2_62700_28140 n1_M2_63780_28140 0.988200
R3179 n1_M2_63780_28140 n1_M2_64860_28140 0.988200
R3180 n1_M2_64860_28140 n1_M2_65940_28140 0.988200
R3181 n1_M2_65940_28140 n1_M2_67020_28140 0.988200
R3182 n1_M2_67020_28140 n1_M2_68100_28140 0.988200
R3183 n1_M2_68100_28140 n1_M2_69180_28140 0.988200
R3184 n1_M2_69180_28140 n1_M2_70260_28140 0.988200
R3185 n1_M2_70260_28140 n1_M2_71340_28140 0.988200
R3186 n1_M2_71340_28140 n1_M2_72420_28140 0.988200
R3187 n1_M2_72420_28140 n1_M2_73500_28140 0.988200
R3188 n1_M2_73500_28140 n1_M2_74580_28140 0.988200
R3189 n1_M2_74580_28140 n1_M2_75660_28140 0.988200
R3190 n1_M2_75660_28140 n1_M2_76740_28140 0.988200
R3191 n1_M2_76740_28140 n1_M2_77820_28140 0.988200
R3192 n1_M2_77820_28140 n1_M2_78900_28140 0.988200
R3193 n1_M2_78900_28140 n1_M2_79980_28140 0.988200
R3194 n1_M2_79980_28140 n1_M2_81060_28140 0.988200
R3195 n1_M2_81060_28140 n1_M2_82140_28140 0.988200
R3196 n1_M2_82140_28140 n1_M2_83220_28140 0.988200
R3197 n1_M2_83220_28140 n1_M2_84300_28140 0.988200
R3198 n1_M2_84300_28140 n1_M2_85380_28140 0.988200
R3199 n1_M2_85380_28140 n1_M2_86460_28140 0.988200
R3200 n1_M2_86460_28140 n1_M2_87540_28140 0.988200
R3201 n1_M2_87540_28140 n1_M2_88620_28140 0.988200
R3202 n1_M2_88620_28140 n1_M2_89700_28140 0.988200
R3203 n1_M2_89700_28140 n1_M2_90780_28140 0.988200
R3204 n1_M2_90780_28140 n1_M2_91860_28140 0.988200
R3205 n1_M2_91860_28140 n1_M2_92940_28140 0.988200
R3206 n1_M2_92940_28140 n1_M2_94020_28140 0.988200
R3207 n1_M2_94020_28140 n1_M2_95100_28140 0.988200
R3208 n1_M2_95100_28140 n1_M2_96180_28140 0.988200
R3209 n1_M2_96180_28140 n1_M2_97260_28140 0.988200
R3210 n1_M2_97260_28140 n1_M2_98340_28140 0.988200
R3211 n1_M2_98340_28140 n1_M2_99420_28140 0.988200
R3212 n1_M2_99420_28140 n1_M2_100500_28140 0.988200
R3213 n1_M2_100500_28140 n1_M2_101580_28140 0.988200
R3214 n1_M2_101580_28140 n1_M2_102660_28140 0.988200
R3215 n1_M2_102660_28140 n1_M2_103740_28140 0.988200
R3216 n1_M2_103740_28140 n1_M2_104820_28140 0.988200
R3217 n1_M2_104820_28140 n1_M2_105900_28140 0.988200
R3218 n1_M2_105900_28140 n1_M2_106980_28140 0.988200
R3219 n1_M2_106980_28140 n1_M2_108060_28140 0.988200
R3220 n1_M2_108060_28140 n1_M2_109140_28140 0.988200
R3221 n1_M2_109140_28140 n1_M2_110220_28140 0.988200
R3222 n1_M2_110220_28140 n1_M2_111300_28140 0.988200
R3223 n1_M2_111300_28140 n1_M2_112380_28140 0.988200
R3224 n1_M2_112380_28140 n1_M2_113460_28140 0.988200
R3225 n1_M2_113460_28140 n1_M2_114540_28140 0.988200
R3226 n1_M2_114540_28140 n1_M2_115620_28140 0.988200
R3227 n1_M2_115620_28140 n1_M2_116700_28140 0.988200
R3228 n1_M2_116700_28140 n1_M2_117780_28140 0.988200
R3229 n1_M2_117780_28140 n1_M2_118860_28140 0.988200
R3230 n1_M2_118860_28140 n1_M2_119940_28140 0.988200
R3231 n1_M2_119940_28140 n1_M2_121020_28140 0.988200
R3232 n1_M2_121020_28140 n1_M2_122100_28140 0.988200
R3233 n1_M2_122100_28140 n1_M2_123180_28140 0.988200
R3234 n1_M2_123180_28140 n1_M2_124260_28140 0.988200
R3235 n1_M2_124260_28140 n1_M2_125340_28140 0.988200
R3236 n1_M2_125340_28140 n1_M2_126420_28140 0.988200
R3237 n1_M2_126420_28140 n1_M2_127500_28140 0.988200
R3238 n1_M2_127500_28140 n1_M2_128580_28140 0.988200
R3239 n1_M2_128580_28140 n1_M2_129660_28140 0.988200
R3240 n1_M2_60_29220 n1_M2_1140_29220 0.988200
R3241 n1_M2_1140_29220 n1_M2_2220_29220 0.988200
R3242 n1_M2_2220_29220 n1_M2_3300_29220 0.988200
R3243 n1_M2_3300_29220 n1_M2_4380_29220 0.988200
R3244 n1_M2_4380_29220 n1_M2_5460_29220 0.988200
R3245 n1_M2_5460_29220 n1_M2_6540_29220 0.988200
R3246 n1_M2_6540_29220 n1_M2_7620_29220 0.988200
R3247 n1_M2_7620_29220 n1_M2_8700_29220 0.988200
R3248 n1_M2_8700_29220 n1_M2_9780_29220 0.988200
R3249 n1_M2_9780_29220 n1_M2_10860_29220 0.988200
R3250 n1_M2_10860_29220 n1_M2_11940_29220 0.988200
R3251 n1_M2_11940_29220 n1_M2_13020_29220 0.988200
R3252 n1_M2_13020_29220 n1_M2_14100_29220 0.988200
R3253 n1_M2_14100_29220 n1_M2_15180_29220 0.988200
R3254 n1_M2_15180_29220 n1_M2_16260_29220 0.988200
R3255 n1_M2_16260_29220 n1_M2_17340_29220 0.988200
R3256 n1_M2_17340_29220 n1_M2_18420_29220 0.988200
R3257 n1_M2_18420_29220 n1_M2_19500_29220 0.988200
R3258 n1_M2_19500_29220 n1_M2_20580_29220 0.988200
R3259 n1_M2_20580_29220 n1_M2_21660_29220 0.988200
R3260 n1_M2_21660_29220 n1_M2_22740_29220 0.988200
R3261 n1_M2_22740_29220 n1_M2_23820_29220 0.988200
R3262 n1_M2_23820_29220 n1_M2_24900_29220 0.988200
R3263 n1_M2_24900_29220 n1_M2_25980_29220 0.988200
R3264 n1_M2_25980_29220 n1_M2_27060_29220 0.988200
R3265 n1_M2_27060_29220 n1_M2_28140_29220 0.988200
R3266 n1_M2_28140_29220 n1_M2_29220_29220 0.988200
R3267 n1_M2_29220_29220 n1_M2_30300_29220 0.988200
R3268 n1_M2_30300_29220 n1_M2_31380_29220 0.988200
R3269 n1_M2_31380_29220 n1_M2_32460_29220 0.988200
R3270 n1_M2_32460_29220 n1_M2_33540_29220 0.988200
R3271 n1_M2_33540_29220 n1_M2_34620_29220 0.988200
R3272 n1_M2_34620_29220 n1_M2_35700_29220 0.988200
R3273 n1_M2_35700_29220 n1_M2_36780_29220 0.988200
R3274 n1_M2_36780_29220 n1_M2_37860_29220 0.988200
R3275 n1_M2_37860_29220 n1_M2_38940_29220 0.988200
R3276 n1_M2_38940_29220 n1_M2_40020_29220 0.988200
R3277 n1_M2_40020_29220 n1_M2_41100_29220 0.988200
R3278 n1_M2_41100_29220 n1_M2_42180_29220 0.988200
R3279 n1_M2_42180_29220 n1_M2_43260_29220 0.988200
R3280 n1_M2_43260_29220 n1_M2_44340_29220 0.988200
R3281 n1_M2_44340_29220 n1_M2_45420_29220 0.988200
R3282 n1_M2_45420_29220 n1_M2_46500_29220 0.988200
R3283 n1_M2_46500_29220 n1_M2_47580_29220 0.988200
R3284 n1_M2_47580_29220 n1_M2_48660_29220 0.988200
R3285 n1_M2_48660_29220 n1_M2_49740_29220 0.988200
R3286 n1_M2_49740_29220 n1_M2_50820_29220 0.988200
R3287 n1_M2_50820_29220 n1_M2_51900_29220 0.988200
R3288 n1_M2_51900_29220 n1_M2_52980_29220 0.988200
R3289 n1_M2_52980_29220 n1_M2_54060_29220 0.988200
R3290 n1_M2_54060_29220 n1_M2_55140_29220 0.988200
R3291 n1_M2_55140_29220 n1_M2_56220_29220 0.988200
R3292 n1_M2_56220_29220 n1_M2_57300_29220 0.988200
R3293 n1_M2_57300_29220 n1_M2_58380_29220 0.988200
R3294 n1_M2_58380_29220 n1_M2_59460_29220 0.988200
R3295 n1_M2_59460_29220 n1_M2_60540_29220 0.988200
R3296 n1_M2_60540_29220 n1_M2_61620_29220 0.988200
R3297 n1_M2_61620_29220 n1_M2_62700_29220 0.988200
R3298 n1_M2_62700_29220 n1_M2_63780_29220 0.988200
R3299 n1_M2_63780_29220 n1_M2_64860_29220 0.988200
R3300 n1_M2_64860_29220 n1_M2_65940_29220 0.988200
R3301 n1_M2_65940_29220 n1_M2_67020_29220 0.988200
R3302 n1_M2_67020_29220 n1_M2_68100_29220 0.988200
R3303 n1_M2_68100_29220 n1_M2_69180_29220 0.988200
R3304 n1_M2_69180_29220 n1_M2_70260_29220 0.988200
R3305 n1_M2_70260_29220 n1_M2_71340_29220 0.988200
R3306 n1_M2_71340_29220 n1_M2_72420_29220 0.988200
R3307 n1_M2_72420_29220 n1_M2_73500_29220 0.988200
R3308 n1_M2_73500_29220 n1_M2_74580_29220 0.988200
R3309 n1_M2_74580_29220 n1_M2_75660_29220 0.988200
R3310 n1_M2_75660_29220 n1_M2_76740_29220 0.988200
R3311 n1_M2_76740_29220 n1_M2_77820_29220 0.988200
R3312 n1_M2_77820_29220 n1_M2_78900_29220 0.988200
R3313 n1_M2_78900_29220 n1_M2_79980_29220 0.988200
R3314 n1_M2_79980_29220 n1_M2_81060_29220 0.988200
R3315 n1_M2_81060_29220 n1_M2_82140_29220 0.988200
R3316 n1_M2_82140_29220 n1_M2_83220_29220 0.988200
R3317 n1_M2_83220_29220 n1_M2_84300_29220 0.988200
R3318 n1_M2_84300_29220 n1_M2_85380_29220 0.988200
R3319 n1_M2_85380_29220 n1_M2_86460_29220 0.988200
R3320 n1_M2_86460_29220 n1_M2_87540_29220 0.988200
R3321 n1_M2_87540_29220 n1_M2_88620_29220 0.988200
R3322 n1_M2_88620_29220 n1_M2_89700_29220 0.988200
R3323 n1_M2_89700_29220 n1_M2_90780_29220 0.988200
R3324 n1_M2_90780_29220 n1_M2_91860_29220 0.988200
R3325 n1_M2_91860_29220 n1_M2_92940_29220 0.988200
R3326 n1_M2_92940_29220 n1_M2_94020_29220 0.988200
R3327 n1_M2_94020_29220 n1_M2_95100_29220 0.988200
R3328 n1_M2_95100_29220 n1_M2_96180_29220 0.988200
R3329 n1_M2_96180_29220 n1_M2_97260_29220 0.988200
R3330 n1_M2_97260_29220 n1_M2_98340_29220 0.988200
R3331 n1_M2_98340_29220 n1_M2_99420_29220 0.988200
R3332 n1_M2_99420_29220 n1_M2_100500_29220 0.988200
R3333 n1_M2_100500_29220 n1_M2_101580_29220 0.988200
R3334 n1_M2_101580_29220 n1_M2_102660_29220 0.988200
R3335 n1_M2_102660_29220 n1_M2_103740_29220 0.988200
R3336 n1_M2_103740_29220 n1_M2_104820_29220 0.988200
R3337 n1_M2_104820_29220 n1_M2_105900_29220 0.988200
R3338 n1_M2_105900_29220 n1_M2_106980_29220 0.988200
R3339 n1_M2_106980_29220 n1_M2_108060_29220 0.988200
R3340 n1_M2_108060_29220 n1_M2_109140_29220 0.988200
R3341 n1_M2_109140_29220 n1_M2_110220_29220 0.988200
R3342 n1_M2_110220_29220 n1_M2_111300_29220 0.988200
R3343 n1_M2_111300_29220 n1_M2_112380_29220 0.988200
R3344 n1_M2_112380_29220 n1_M2_113460_29220 0.988200
R3345 n1_M2_113460_29220 n1_M2_114540_29220 0.988200
R3346 n1_M2_114540_29220 n1_M2_115620_29220 0.988200
R3347 n1_M2_115620_29220 n1_M2_116700_29220 0.988200
R3348 n1_M2_116700_29220 n1_M2_117780_29220 0.988200
R3349 n1_M2_117780_29220 n1_M2_118860_29220 0.988200
R3350 n1_M2_118860_29220 n1_M2_119940_29220 0.988200
R3351 n1_M2_119940_29220 n1_M2_121020_29220 0.988200
R3352 n1_M2_121020_29220 n1_M2_122100_29220 0.988200
R3353 n1_M2_122100_29220 n1_M2_123180_29220 0.988200
R3354 n1_M2_123180_29220 n1_M2_124260_29220 0.988200
R3355 n1_M2_124260_29220 n1_M2_125340_29220 0.988200
R3356 n1_M2_125340_29220 n1_M2_126420_29220 0.988200
R3357 n1_M2_126420_29220 n1_M2_127500_29220 0.988200
R3358 n1_M2_127500_29220 n1_M2_128580_29220 0.988200
R3359 n1_M2_128580_29220 n1_M2_129660_29220 0.988200
R3360 n1_M2_60_30300 n1_M2_1140_30300 0.988200
R3361 n1_M2_1140_30300 n1_M2_2220_30300 0.988200
R3362 n1_M2_2220_30300 n1_M2_3300_30300 0.988200
R3363 n1_M2_3300_30300 n1_M2_4380_30300 0.988200
R3364 n1_M2_4380_30300 n1_M2_5460_30300 0.988200
R3365 n1_M2_5460_30300 n1_M2_6540_30300 0.988200
R3366 n1_M2_6540_30300 n1_M2_7620_30300 0.988200
R3367 n1_M2_7620_30300 n1_M2_8700_30300 0.988200
R3368 n1_M2_8700_30300 n1_M2_9780_30300 0.988200
R3369 n1_M2_9780_30300 n1_M2_10860_30300 0.988200
R3370 n1_M2_10860_30300 n1_M2_11940_30300 0.988200
R3371 n1_M2_11940_30300 n1_M2_13020_30300 0.988200
R3372 n1_M2_13020_30300 n1_M2_14100_30300 0.988200
R3373 n1_M2_14100_30300 n1_M2_15180_30300 0.988200
R3374 n1_M2_15180_30300 n1_M2_16260_30300 0.988200
R3375 n1_M2_16260_30300 n1_M2_17340_30300 0.988200
R3376 n1_M2_17340_30300 n1_M2_18420_30300 0.988200
R3377 n1_M2_18420_30300 n1_M2_19500_30300 0.988200
R3378 n1_M2_19500_30300 n1_M2_20580_30300 0.988200
R3379 n1_M2_20580_30300 n1_M2_21660_30300 0.988200
R3380 n1_M2_21660_30300 n1_M2_22740_30300 0.988200
R3381 n1_M2_22740_30300 n1_M2_23820_30300 0.988200
R3382 n1_M2_23820_30300 n1_M2_24900_30300 0.988200
R3383 n1_M2_24900_30300 n1_M2_25980_30300 0.988200
R3384 n1_M2_25980_30300 n1_M2_27060_30300 0.988200
R3385 n1_M2_27060_30300 n1_M2_28140_30300 0.988200
R3386 n1_M2_28140_30300 n1_M2_29220_30300 0.988200
R3387 n1_M2_29220_30300 n1_M2_30300_30300 0.988200
R3388 n1_M2_30300_30300 n1_M2_31380_30300 0.988200
R3389 n1_M2_31380_30300 n1_M2_32460_30300 0.988200
R3390 n1_M2_32460_30300 n1_M2_33540_30300 0.988200
R3391 n1_M2_33540_30300 n1_M2_34620_30300 0.988200
R3392 n1_M2_34620_30300 n1_M2_35700_30300 0.988200
R3393 n1_M2_35700_30300 n1_M2_36780_30300 0.988200
R3394 n1_M2_36780_30300 n1_M2_37860_30300 0.988200
R3395 n1_M2_37860_30300 n1_M2_38940_30300 0.988200
R3396 n1_M2_38940_30300 n1_M2_40020_30300 0.988200
R3397 n1_M2_40020_30300 n1_M2_41100_30300 0.988200
R3398 n1_M2_41100_30300 n1_M2_42180_30300 0.988200
R3399 n1_M2_42180_30300 n1_M2_43260_30300 0.988200
R3400 n1_M2_43260_30300 n1_M2_44340_30300 0.988200
R3401 n1_M2_44340_30300 n1_M2_45420_30300 0.988200
R3402 n1_M2_45420_30300 n1_M2_46500_30300 0.988200
R3403 n1_M2_46500_30300 n1_M2_47580_30300 0.988200
R3404 n1_M2_47580_30300 n1_M2_48660_30300 0.988200
R3405 n1_M2_48660_30300 n1_M2_49740_30300 0.988200
R3406 n1_M2_49740_30300 n1_M2_50820_30300 0.988200
R3407 n1_M2_50820_30300 n1_M2_51900_30300 0.988200
R3408 n1_M2_51900_30300 n1_M2_52980_30300 0.988200
R3409 n1_M2_52980_30300 n1_M2_54060_30300 0.988200
R3410 n1_M2_54060_30300 n1_M2_55140_30300 0.988200
R3411 n1_M2_55140_30300 n1_M2_56220_30300 0.988200
R3412 n1_M2_56220_30300 n1_M2_57300_30300 0.988200
R3413 n1_M2_57300_30300 n1_M2_58380_30300 0.988200
R3414 n1_M2_58380_30300 n1_M2_59460_30300 0.988200
R3415 n1_M2_59460_30300 n1_M2_60540_30300 0.988200
R3416 n1_M2_60540_30300 n1_M2_61620_30300 0.988200
R3417 n1_M2_61620_30300 n1_M2_62700_30300 0.988200
R3418 n1_M2_62700_30300 n1_M2_63780_30300 0.988200
R3419 n1_M2_63780_30300 n1_M2_64860_30300 0.988200
R3420 n1_M2_64860_30300 n1_M2_65940_30300 0.988200
R3421 n1_M2_65940_30300 n1_M2_67020_30300 0.988200
R3422 n1_M2_67020_30300 n1_M2_68100_30300 0.988200
R3423 n1_M2_68100_30300 n1_M2_69180_30300 0.988200
R3424 n1_M2_69180_30300 n1_M2_70260_30300 0.988200
R3425 n1_M2_70260_30300 n1_M2_71340_30300 0.988200
R3426 n1_M2_71340_30300 n1_M2_72420_30300 0.988200
R3427 n1_M2_72420_30300 n1_M2_73500_30300 0.988200
R3428 n1_M2_73500_30300 n1_M2_74580_30300 0.988200
R3429 n1_M2_74580_30300 n1_M2_75660_30300 0.988200
R3430 n1_M2_75660_30300 n1_M2_76740_30300 0.988200
R3431 n1_M2_76740_30300 n1_M2_77820_30300 0.988200
R3432 n1_M2_77820_30300 n1_M2_78900_30300 0.988200
R3433 n1_M2_78900_30300 n1_M2_79980_30300 0.988200
R3434 n1_M2_79980_30300 n1_M2_81060_30300 0.988200
R3435 n1_M2_81060_30300 n1_M2_82140_30300 0.988200
R3436 n1_M2_82140_30300 n1_M2_83220_30300 0.988200
R3437 n1_M2_83220_30300 n1_M2_84300_30300 0.988200
R3438 n1_M2_84300_30300 n1_M2_85380_30300 0.988200
R3439 n1_M2_85380_30300 n1_M2_86460_30300 0.988200
R3440 n1_M2_86460_30300 n1_M2_87540_30300 0.988200
R3441 n1_M2_87540_30300 n1_M2_88620_30300 0.988200
R3442 n1_M2_88620_30300 n1_M2_89700_30300 0.988200
R3443 n1_M2_89700_30300 n1_M2_90780_30300 0.988200
R3444 n1_M2_90780_30300 n1_M2_91860_30300 0.988200
R3445 n1_M2_91860_30300 n1_M2_92940_30300 0.988200
R3446 n1_M2_92940_30300 n1_M2_94020_30300 0.988200
R3447 n1_M2_94020_30300 n1_M2_95100_30300 0.988200
R3448 n1_M2_95100_30300 n1_M2_96180_30300 0.988200
R3449 n1_M2_96180_30300 n1_M2_97260_30300 0.988200
R3450 n1_M2_97260_30300 n1_M2_98340_30300 0.988200
R3451 n1_M2_98340_30300 n1_M2_99420_30300 0.988200
R3452 n1_M2_99420_30300 n1_M2_100500_30300 0.988200
R3453 n1_M2_100500_30300 n1_M2_101580_30300 0.988200
R3454 n1_M2_101580_30300 n1_M2_102660_30300 0.988200
R3455 n1_M2_102660_30300 n1_M2_103740_30300 0.988200
R3456 n1_M2_103740_30300 n1_M2_104820_30300 0.988200
R3457 n1_M2_104820_30300 n1_M2_105900_30300 0.988200
R3458 n1_M2_105900_30300 n1_M2_106980_30300 0.988200
R3459 n1_M2_106980_30300 n1_M2_108060_30300 0.988200
R3460 n1_M2_108060_30300 n1_M2_109140_30300 0.988200
R3461 n1_M2_109140_30300 n1_M2_110220_30300 0.988200
R3462 n1_M2_110220_30300 n1_M2_111300_30300 0.988200
R3463 n1_M2_111300_30300 n1_M2_112380_30300 0.988200
R3464 n1_M2_112380_30300 n1_M2_113460_30300 0.988200
R3465 n1_M2_113460_30300 n1_M2_114540_30300 0.988200
R3466 n1_M2_114540_30300 n1_M2_115620_30300 0.988200
R3467 n1_M2_115620_30300 n1_M2_116700_30300 0.988200
R3468 n1_M2_116700_30300 n1_M2_117780_30300 0.988200
R3469 n1_M2_117780_30300 n1_M2_118860_30300 0.988200
R3470 n1_M2_118860_30300 n1_M2_119940_30300 0.988200
R3471 n1_M2_119940_30300 n1_M2_121020_30300 0.988200
R3472 n1_M2_121020_30300 n1_M2_122100_30300 0.988200
R3473 n1_M2_122100_30300 n1_M2_123180_30300 0.988200
R3474 n1_M2_123180_30300 n1_M2_124260_30300 0.988200
R3475 n1_M2_124260_30300 n1_M2_125340_30300 0.988200
R3476 n1_M2_125340_30300 n1_M2_126420_30300 0.988200
R3477 n1_M2_126420_30300 n1_M2_127500_30300 0.988200
R3478 n1_M2_127500_30300 n1_M2_128580_30300 0.988200
R3479 n1_M2_128580_30300 n1_M2_129660_30300 0.988200
R3480 n1_M2_60_31380 n1_M2_1140_31380 0.988200
R3481 n1_M2_1140_31380 n1_M2_2220_31380 0.988200
R3482 n1_M2_2220_31380 n1_M2_3300_31380 0.988200
R3483 n1_M2_3300_31380 n1_M2_4380_31380 0.988200
R3484 n1_M2_4380_31380 n1_M2_5460_31380 0.988200
R3485 n1_M2_5460_31380 n1_M2_6540_31380 0.988200
R3486 n1_M2_6540_31380 n1_M2_7620_31380 0.988200
R3487 n1_M2_7620_31380 n1_M2_8700_31380 0.988200
R3488 n1_M2_8700_31380 n1_M2_9780_31380 0.988200
R3489 n1_M2_9780_31380 n1_M2_10860_31380 0.988200
R3490 n1_M2_10860_31380 n1_M2_11940_31380 0.988200
R3491 n1_M2_11940_31380 n1_M2_13020_31380 0.988200
R3492 n1_M2_13020_31380 n1_M2_14100_31380 0.988200
R3493 n1_M2_14100_31380 n1_M2_15180_31380 0.988200
R3494 n1_M2_15180_31380 n1_M2_16260_31380 0.988200
R3495 n1_M2_16260_31380 n1_M2_17340_31380 0.988200
R3496 n1_M2_17340_31380 n1_M2_18420_31380 0.988200
R3497 n1_M2_18420_31380 n1_M2_19500_31380 0.988200
R3498 n1_M2_19500_31380 n1_M2_20580_31380 0.988200
R3499 n1_M2_20580_31380 n1_M2_21660_31380 0.988200
R3500 n1_M2_21660_31380 n1_M2_22740_31380 0.988200
R3501 n1_M2_22740_31380 n1_M2_23820_31380 0.988200
R3502 n1_M2_23820_31380 n1_M2_24900_31380 0.988200
R3503 n1_M2_24900_31380 n1_M2_25980_31380 0.988200
R3504 n1_M2_25980_31380 n1_M2_27060_31380 0.988200
R3505 n1_M2_27060_31380 n1_M2_28140_31380 0.988200
R3506 n1_M2_28140_31380 n1_M2_29220_31380 0.988200
R3507 n1_M2_29220_31380 n1_M2_30300_31380 0.988200
R3508 n1_M2_30300_31380 n1_M2_31380_31380 0.988200
R3509 n1_M2_31380_31380 n1_M2_32460_31380 0.988200
R3510 n1_M2_32460_31380 n1_M2_33540_31380 0.988200
R3511 n1_M2_33540_31380 n1_M2_34620_31380 0.988200
R3512 n1_M2_34620_31380 n1_M2_35700_31380 0.988200
R3513 n1_M2_35700_31380 n1_M2_36780_31380 0.988200
R3514 n1_M2_36780_31380 n1_M2_37860_31380 0.988200
R3515 n1_M2_37860_31380 n1_M2_38940_31380 0.988200
R3516 n1_M2_38940_31380 n1_M2_40020_31380 0.988200
R3517 n1_M2_40020_31380 n1_M2_41100_31380 0.988200
R3518 n1_M2_41100_31380 n1_M2_42180_31380 0.988200
R3519 n1_M2_42180_31380 n1_M2_43260_31380 0.988200
R3520 n1_M2_43260_31380 n1_M2_44340_31380 0.988200
R3521 n1_M2_44340_31380 n1_M2_45420_31380 0.988200
R3522 n1_M2_45420_31380 n1_M2_46500_31380 0.988200
R3523 n1_M2_46500_31380 n1_M2_47580_31380 0.988200
R3524 n1_M2_47580_31380 n1_M2_48660_31380 0.988200
R3525 n1_M2_48660_31380 n1_M2_49740_31380 0.988200
R3526 n1_M2_49740_31380 n1_M2_50820_31380 0.988200
R3527 n1_M2_50820_31380 n1_M2_51900_31380 0.988200
R3528 n1_M2_51900_31380 n1_M2_52980_31380 0.988200
R3529 n1_M2_52980_31380 n1_M2_54060_31380 0.988200
R3530 n1_M2_54060_31380 n1_M2_55140_31380 0.988200
R3531 n1_M2_55140_31380 n1_M2_56220_31380 0.988200
R3532 n1_M2_56220_31380 n1_M2_57300_31380 0.988200
R3533 n1_M2_57300_31380 n1_M2_58380_31380 0.988200
R3534 n1_M2_58380_31380 n1_M2_59460_31380 0.988200
R3535 n1_M2_59460_31380 n1_M2_60540_31380 0.988200
R3536 n1_M2_60540_31380 n1_M2_61620_31380 0.988200
R3537 n1_M2_61620_31380 n1_M2_62700_31380 0.988200
R3538 n1_M2_62700_31380 n1_M2_63780_31380 0.988200
R3539 n1_M2_63780_31380 n1_M2_64860_31380 0.988200
R3540 n1_M2_64860_31380 n1_M2_65940_31380 0.988200
R3541 n1_M2_65940_31380 n1_M2_67020_31380 0.988200
R3542 n1_M2_67020_31380 n1_M2_68100_31380 0.988200
R3543 n1_M2_68100_31380 n1_M2_69180_31380 0.988200
R3544 n1_M2_69180_31380 n1_M2_70260_31380 0.988200
R3545 n1_M2_70260_31380 n1_M2_71340_31380 0.988200
R3546 n1_M2_71340_31380 n1_M2_72420_31380 0.988200
R3547 n1_M2_72420_31380 n1_M2_73500_31380 0.988200
R3548 n1_M2_73500_31380 n1_M2_74580_31380 0.988200
R3549 n1_M2_74580_31380 n1_M2_75660_31380 0.988200
R3550 n1_M2_75660_31380 n1_M2_76740_31380 0.988200
R3551 n1_M2_76740_31380 n1_M2_77820_31380 0.988200
R3552 n1_M2_77820_31380 n1_M2_78900_31380 0.988200
R3553 n1_M2_78900_31380 n1_M2_79980_31380 0.988200
R3554 n1_M2_79980_31380 n1_M2_81060_31380 0.988200
R3555 n1_M2_81060_31380 n1_M2_82140_31380 0.988200
R3556 n1_M2_82140_31380 n1_M2_83220_31380 0.988200
R3557 n1_M2_83220_31380 n1_M2_84300_31380 0.988200
R3558 n1_M2_84300_31380 n1_M2_85380_31380 0.988200
R3559 n1_M2_85380_31380 n1_M2_86460_31380 0.988200
R3560 n1_M2_86460_31380 n1_M2_87540_31380 0.988200
R3561 n1_M2_87540_31380 n1_M2_88620_31380 0.988200
R3562 n1_M2_88620_31380 n1_M2_89700_31380 0.988200
R3563 n1_M2_89700_31380 n1_M2_90780_31380 0.988200
R3564 n1_M2_90780_31380 n1_M2_91860_31380 0.988200
R3565 n1_M2_91860_31380 n1_M2_92940_31380 0.988200
R3566 n1_M2_92940_31380 n1_M2_94020_31380 0.988200
R3567 n1_M2_94020_31380 n1_M2_95100_31380 0.988200
R3568 n1_M2_95100_31380 n1_M2_96180_31380 0.988200
R3569 n1_M2_96180_31380 n1_M2_97260_31380 0.988200
R3570 n1_M2_97260_31380 n1_M2_98340_31380 0.988200
R3571 n1_M2_98340_31380 n1_M2_99420_31380 0.988200
R3572 n1_M2_99420_31380 n1_M2_100500_31380 0.988200
R3573 n1_M2_100500_31380 n1_M2_101580_31380 0.988200
R3574 n1_M2_101580_31380 n1_M2_102660_31380 0.988200
R3575 n1_M2_102660_31380 n1_M2_103740_31380 0.988200
R3576 n1_M2_103740_31380 n1_M2_104820_31380 0.988200
R3577 n1_M2_104820_31380 n1_M2_105900_31380 0.988200
R3578 n1_M2_105900_31380 n1_M2_106980_31380 0.988200
R3579 n1_M2_106980_31380 n1_M2_108060_31380 0.988200
R3580 n1_M2_108060_31380 n1_M2_109140_31380 0.988200
R3581 n1_M2_109140_31380 n1_M2_110220_31380 0.988200
R3582 n1_M2_110220_31380 n1_M2_111300_31380 0.988200
R3583 n1_M2_111300_31380 n1_M2_112380_31380 0.988200
R3584 n1_M2_112380_31380 n1_M2_113460_31380 0.988200
R3585 n1_M2_113460_31380 n1_M2_114540_31380 0.988200
R3586 n1_M2_114540_31380 n1_M2_115620_31380 0.988200
R3587 n1_M2_115620_31380 n1_M2_116700_31380 0.988200
R3588 n1_M2_116700_31380 n1_M2_117780_31380 0.988200
R3589 n1_M2_117780_31380 n1_M2_118860_31380 0.988200
R3590 n1_M2_118860_31380 n1_M2_119940_31380 0.988200
R3591 n1_M2_119940_31380 n1_M2_121020_31380 0.988200
R3592 n1_M2_121020_31380 n1_M2_122100_31380 0.988200
R3593 n1_M2_122100_31380 n1_M2_123180_31380 0.988200
R3594 n1_M2_123180_31380 n1_M2_124260_31380 0.988200
R3595 n1_M2_124260_31380 n1_M2_125340_31380 0.988200
R3596 n1_M2_125340_31380 n1_M2_126420_31380 0.988200
R3597 n1_M2_126420_31380 n1_M2_127500_31380 0.988200
R3598 n1_M2_127500_31380 n1_M2_128580_31380 0.988200
R3599 n1_M2_128580_31380 n1_M2_129660_31380 0.988200
R3600 n1_M2_60_32460 n1_M2_1140_32460 0.988200
R3601 n1_M2_1140_32460 n1_M2_2220_32460 0.988200
R3602 n1_M2_2220_32460 n1_M2_3300_32460 0.988200
R3603 n1_M2_3300_32460 n1_M2_4380_32460 0.988200
R3604 n1_M2_4380_32460 n1_M2_5460_32460 0.988200
R3605 n1_M2_5460_32460 n1_M2_6540_32460 0.988200
R3606 n1_M2_6540_32460 n1_M2_7620_32460 0.988200
R3607 n1_M2_7620_32460 n1_M2_8700_32460 0.988200
R3608 n1_M2_8700_32460 n1_M2_9780_32460 0.988200
R3609 n1_M2_9780_32460 n1_M2_10860_32460 0.988200
R3610 n1_M2_10860_32460 n1_M2_11940_32460 0.988200
R3611 n1_M2_11940_32460 n1_M2_13020_32460 0.988200
R3612 n1_M2_13020_32460 n1_M2_14100_32460 0.988200
R3613 n1_M2_14100_32460 n1_M2_15180_32460 0.988200
R3614 n1_M2_15180_32460 n1_M2_16260_32460 0.988200
R3615 n1_M2_16260_32460 n1_M2_17340_32460 0.988200
R3616 n1_M2_17340_32460 n1_M2_18420_32460 0.988200
R3617 n1_M2_18420_32460 n1_M2_19500_32460 0.988200
R3618 n1_M2_19500_32460 n1_M2_20580_32460 0.988200
R3619 n1_M2_20580_32460 n1_M2_21660_32460 0.988200
R3620 n1_M2_21660_32460 n1_M2_22740_32460 0.988200
R3621 n1_M2_22740_32460 n1_M2_23820_32460 0.988200
R3622 n1_M2_23820_32460 n1_M2_24900_32460 0.988200
R3623 n1_M2_24900_32460 n1_M2_25980_32460 0.988200
R3624 n1_M2_25980_32460 n1_M2_27060_32460 0.988200
R3625 n1_M2_27060_32460 n1_M2_28140_32460 0.988200
R3626 n1_M2_28140_32460 n1_M2_29220_32460 0.988200
R3627 n1_M2_29220_32460 n1_M2_30300_32460 0.988200
R3628 n1_M2_30300_32460 n1_M2_31380_32460 0.988200
R3629 n1_M2_31380_32460 n1_M2_32460_32460 0.988200
R3630 n1_M2_32460_32460 n1_M2_33540_32460 0.988200
R3631 n1_M2_33540_32460 n1_M2_34620_32460 0.988200
R3632 n1_M2_34620_32460 n1_M2_35700_32460 0.988200
R3633 n1_M2_35700_32460 n1_M2_36780_32460 0.988200
R3634 n1_M2_36780_32460 n1_M2_37860_32460 0.988200
R3635 n1_M2_37860_32460 n1_M2_38940_32460 0.988200
R3636 n1_M2_38940_32460 n1_M2_40020_32460 0.988200
R3637 n1_M2_40020_32460 n1_M2_41100_32460 0.988200
R3638 n1_M2_41100_32460 n1_M2_42180_32460 0.988200
R3639 n1_M2_42180_32460 n1_M2_43260_32460 0.988200
R3640 n1_M2_43260_32460 n1_M2_44340_32460 0.988200
R3641 n1_M2_44340_32460 n1_M2_45420_32460 0.988200
R3642 n1_M2_45420_32460 n1_M2_46500_32460 0.988200
R3643 n1_M2_46500_32460 n1_M2_47580_32460 0.988200
R3644 n1_M2_47580_32460 n1_M2_48660_32460 0.988200
R3645 n1_M2_48660_32460 n1_M2_49740_32460 0.988200
R3646 n1_M2_49740_32460 n1_M2_50820_32460 0.988200
R3647 n1_M2_50820_32460 n1_M2_51900_32460 0.988200
R3648 n1_M2_51900_32460 n1_M2_52980_32460 0.988200
R3649 n1_M2_52980_32460 n1_M2_54060_32460 0.988200
R3650 n1_M2_54060_32460 n1_M2_55140_32460 0.988200
R3651 n1_M2_55140_32460 n1_M2_56220_32460 0.988200
R3652 n1_M2_56220_32460 n1_M2_57300_32460 0.988200
R3653 n1_M2_57300_32460 n1_M2_58380_32460 0.988200
R3654 n1_M2_58380_32460 n1_M2_59460_32460 0.988200
R3655 n1_M2_59460_32460 n1_M2_60540_32460 0.988200
R3656 n1_M2_60540_32460 n1_M2_61620_32460 0.988200
R3657 n1_M2_61620_32460 n1_M2_62700_32460 0.988200
R3658 n1_M2_62700_32460 n1_M2_63780_32460 0.988200
R3659 n1_M2_63780_32460 n1_M2_64860_32460 0.988200
R3660 n1_M2_64860_32460 n1_M2_65940_32460 0.988200
R3661 n1_M2_65940_32460 n1_M2_67020_32460 0.988200
R3662 n1_M2_67020_32460 n1_M2_68100_32460 0.988200
R3663 n1_M2_68100_32460 n1_M2_69180_32460 0.988200
R3664 n1_M2_69180_32460 n1_M2_70260_32460 0.988200
R3665 n1_M2_70260_32460 n1_M2_71340_32460 0.988200
R3666 n1_M2_71340_32460 n1_M2_72420_32460 0.988200
R3667 n1_M2_72420_32460 n1_M2_73500_32460 0.988200
R3668 n1_M2_73500_32460 n1_M2_74580_32460 0.988200
R3669 n1_M2_74580_32460 n1_M2_75660_32460 0.988200
R3670 n1_M2_75660_32460 n1_M2_76740_32460 0.988200
R3671 n1_M2_76740_32460 n1_M2_77820_32460 0.988200
R3672 n1_M2_77820_32460 n1_M2_78900_32460 0.988200
R3673 n1_M2_78900_32460 n1_M2_79980_32460 0.988200
R3674 n1_M2_79980_32460 n1_M2_81060_32460 0.988200
R3675 n1_M2_81060_32460 n1_M2_82140_32460 0.988200
R3676 n1_M2_82140_32460 n1_M2_83220_32460 0.988200
R3677 n1_M2_83220_32460 n1_M2_84300_32460 0.988200
R3678 n1_M2_84300_32460 n1_M2_85380_32460 0.988200
R3679 n1_M2_85380_32460 n1_M2_86460_32460 0.988200
R3680 n1_M2_86460_32460 n1_M2_87540_32460 0.988200
R3681 n1_M2_87540_32460 n1_M2_88620_32460 0.988200
R3682 n1_M2_88620_32460 n1_M2_89700_32460 0.988200
R3683 n1_M2_89700_32460 n1_M2_90780_32460 0.988200
R3684 n1_M2_90780_32460 n1_M2_91860_32460 0.988200
R3685 n1_M2_91860_32460 n1_M2_92940_32460 0.988200
R3686 n1_M2_92940_32460 n1_M2_94020_32460 0.988200
R3687 n1_M2_94020_32460 n1_M2_95100_32460 0.988200
R3688 n1_M2_95100_32460 n1_M2_96180_32460 0.988200
R3689 n1_M2_96180_32460 n1_M2_97260_32460 0.988200
R3690 n1_M2_97260_32460 n1_M2_98340_32460 0.988200
R3691 n1_M2_98340_32460 n1_M2_99420_32460 0.988200
R3692 n1_M2_99420_32460 n1_M2_100500_32460 0.988200
R3693 n1_M2_100500_32460 n1_M2_101580_32460 0.988200
R3694 n1_M2_101580_32460 n1_M2_102660_32460 0.988200
R3695 n1_M2_102660_32460 n1_M2_103740_32460 0.988200
R3696 n1_M2_103740_32460 n1_M2_104820_32460 0.988200
R3697 n1_M2_104820_32460 n1_M2_105900_32460 0.988200
R3698 n1_M2_105900_32460 n1_M2_106980_32460 0.988200
R3699 n1_M2_106980_32460 n1_M2_108060_32460 0.988200
R3700 n1_M2_108060_32460 n1_M2_109140_32460 0.988200
R3701 n1_M2_109140_32460 n1_M2_110220_32460 0.988200
R3702 n1_M2_110220_32460 n1_M2_111300_32460 0.988200
R3703 n1_M2_111300_32460 n1_M2_112380_32460 0.988200
R3704 n1_M2_112380_32460 n1_M2_113460_32460 0.988200
R3705 n1_M2_113460_32460 n1_M2_114540_32460 0.988200
R3706 n1_M2_114540_32460 n1_M2_115620_32460 0.988200
R3707 n1_M2_115620_32460 n1_M2_116700_32460 0.988200
R3708 n1_M2_116700_32460 n1_M2_117780_32460 0.988200
R3709 n1_M2_117780_32460 n1_M2_118860_32460 0.988200
R3710 n1_M2_118860_32460 n1_M2_119940_32460 0.988200
R3711 n1_M2_119940_32460 n1_M2_121020_32460 0.988200
R3712 n1_M2_121020_32460 n1_M2_122100_32460 0.988200
R3713 n1_M2_122100_32460 n1_M2_123180_32460 0.988200
R3714 n1_M2_123180_32460 n1_M2_124260_32460 0.988200
R3715 n1_M2_124260_32460 n1_M2_125340_32460 0.988200
R3716 n1_M2_125340_32460 n1_M2_126420_32460 0.988200
R3717 n1_M2_126420_32460 n1_M2_127500_32460 0.988200
R3718 n1_M2_127500_32460 n1_M2_128580_32460 0.988200
R3719 n1_M2_128580_32460 n1_M2_129660_32460 0.988200
R3720 n1_M2_60_33540 n1_M2_1140_33540 0.988200
R3721 n1_M2_1140_33540 n1_M2_2220_33540 0.988200
R3722 n1_M2_2220_33540 n1_M2_3300_33540 0.988200
R3723 n1_M2_3300_33540 n1_M2_4380_33540 0.988200
R3724 n1_M2_4380_33540 n1_M2_5460_33540 0.988200
R3725 n1_M2_5460_33540 n1_M2_6540_33540 0.988200
R3726 n1_M2_6540_33540 n1_M2_7620_33540 0.988200
R3727 n1_M2_7620_33540 n1_M2_8700_33540 0.988200
R3728 n1_M2_8700_33540 n1_M2_9780_33540 0.988200
R3729 n1_M2_9780_33540 n1_M2_10860_33540 0.988200
R3730 n1_M2_10860_33540 n1_M2_11940_33540 0.988200
R3731 n1_M2_11940_33540 n1_M2_13020_33540 0.988200
R3732 n1_M2_13020_33540 n1_M2_14100_33540 0.988200
R3733 n1_M2_14100_33540 n1_M2_15180_33540 0.988200
R3734 n1_M2_15180_33540 n1_M2_16260_33540 0.988200
R3735 n1_M2_16260_33540 n1_M2_17340_33540 0.988200
R3736 n1_M2_17340_33540 n1_M2_18420_33540 0.988200
R3737 n1_M2_18420_33540 n1_M2_19500_33540 0.988200
R3738 n1_M2_19500_33540 n1_M2_20580_33540 0.988200
R3739 n1_M2_20580_33540 n1_M2_21660_33540 0.988200
R3740 n1_M2_21660_33540 n1_M2_22740_33540 0.988200
R3741 n1_M2_22740_33540 n1_M2_23820_33540 0.988200
R3742 n1_M2_23820_33540 n1_M2_24900_33540 0.988200
R3743 n1_M2_24900_33540 n1_M2_25980_33540 0.988200
R3744 n1_M2_25980_33540 n1_M2_27060_33540 0.988200
R3745 n1_M2_27060_33540 n1_M2_28140_33540 0.988200
R3746 n1_M2_28140_33540 n1_M2_29220_33540 0.988200
R3747 n1_M2_29220_33540 n1_M2_30300_33540 0.988200
R3748 n1_M2_30300_33540 n1_M2_31380_33540 0.988200
R3749 n1_M2_31380_33540 n1_M2_32460_33540 0.988200
R3750 n1_M2_32460_33540 n1_M2_33540_33540 0.988200
R3751 n1_M2_33540_33540 n1_M2_34620_33540 0.988200
R3752 n1_M2_34620_33540 n1_M2_35700_33540 0.988200
R3753 n1_M2_35700_33540 n1_M2_36780_33540 0.988200
R3754 n1_M2_36780_33540 n1_M2_37860_33540 0.988200
R3755 n1_M2_37860_33540 n1_M2_38940_33540 0.988200
R3756 n1_M2_38940_33540 n1_M2_40020_33540 0.988200
R3757 n1_M2_40020_33540 n1_M2_41100_33540 0.988200
R3758 n1_M2_41100_33540 n1_M2_42180_33540 0.988200
R3759 n1_M2_42180_33540 n1_M2_43260_33540 0.988200
R3760 n1_M2_43260_33540 n1_M2_44340_33540 0.988200
R3761 n1_M2_44340_33540 n1_M2_45420_33540 0.988200
R3762 n1_M2_45420_33540 n1_M2_46500_33540 0.988200
R3763 n1_M2_46500_33540 n1_M2_47580_33540 0.988200
R3764 n1_M2_47580_33540 n1_M2_48660_33540 0.988200
R3765 n1_M2_48660_33540 n1_M2_49740_33540 0.988200
R3766 n1_M2_49740_33540 n1_M2_50820_33540 0.988200
R3767 n1_M2_50820_33540 n1_M2_51900_33540 0.988200
R3768 n1_M2_51900_33540 n1_M2_52980_33540 0.988200
R3769 n1_M2_52980_33540 n1_M2_54060_33540 0.988200
R3770 n1_M2_54060_33540 n1_M2_55140_33540 0.988200
R3771 n1_M2_55140_33540 n1_M2_56220_33540 0.988200
R3772 n1_M2_56220_33540 n1_M2_57300_33540 0.988200
R3773 n1_M2_57300_33540 n1_M2_58380_33540 0.988200
R3774 n1_M2_58380_33540 n1_M2_59460_33540 0.988200
R3775 n1_M2_59460_33540 n1_M2_60540_33540 0.988200
R3776 n1_M2_60540_33540 n1_M2_61620_33540 0.988200
R3777 n1_M2_61620_33540 n1_M2_62700_33540 0.988200
R3778 n1_M2_62700_33540 n1_M2_63780_33540 0.988200
R3779 n1_M2_63780_33540 n1_M2_64860_33540 0.988200
R3780 n1_M2_64860_33540 n1_M2_65940_33540 0.988200
R3781 n1_M2_65940_33540 n1_M2_67020_33540 0.988200
R3782 n1_M2_67020_33540 n1_M2_68100_33540 0.988200
R3783 n1_M2_68100_33540 n1_M2_69180_33540 0.988200
R3784 n1_M2_69180_33540 n1_M2_70260_33540 0.988200
R3785 n1_M2_70260_33540 n1_M2_71340_33540 0.988200
R3786 n1_M2_71340_33540 n1_M2_72420_33540 0.988200
R3787 n1_M2_72420_33540 n1_M2_73500_33540 0.988200
R3788 n1_M2_73500_33540 n1_M2_74580_33540 0.988200
R3789 n1_M2_74580_33540 n1_M2_75660_33540 0.988200
R3790 n1_M2_75660_33540 n1_M2_76740_33540 0.988200
R3791 n1_M2_76740_33540 n1_M2_77820_33540 0.988200
R3792 n1_M2_77820_33540 n1_M2_78900_33540 0.988200
R3793 n1_M2_78900_33540 n1_M2_79980_33540 0.988200
R3794 n1_M2_79980_33540 n1_M2_81060_33540 0.988200
R3795 n1_M2_81060_33540 n1_M2_82140_33540 0.988200
R3796 n1_M2_82140_33540 n1_M2_83220_33540 0.988200
R3797 n1_M2_83220_33540 n1_M2_84300_33540 0.988200
R3798 n1_M2_84300_33540 n1_M2_85380_33540 0.988200
R3799 n1_M2_85380_33540 n1_M2_86460_33540 0.988200
R3800 n1_M2_86460_33540 n1_M2_87540_33540 0.988200
R3801 n1_M2_87540_33540 n1_M2_88620_33540 0.988200
R3802 n1_M2_88620_33540 n1_M2_89700_33540 0.988200
R3803 n1_M2_89700_33540 n1_M2_90780_33540 0.988200
R3804 n1_M2_90780_33540 n1_M2_91860_33540 0.988200
R3805 n1_M2_91860_33540 n1_M2_92940_33540 0.988200
R3806 n1_M2_92940_33540 n1_M2_94020_33540 0.988200
R3807 n1_M2_94020_33540 n1_M2_95100_33540 0.988200
R3808 n1_M2_95100_33540 n1_M2_96180_33540 0.988200
R3809 n1_M2_96180_33540 n1_M2_97260_33540 0.988200
R3810 n1_M2_97260_33540 n1_M2_98340_33540 0.988200
R3811 n1_M2_98340_33540 n1_M2_99420_33540 0.988200
R3812 n1_M2_99420_33540 n1_M2_100500_33540 0.988200
R3813 n1_M2_100500_33540 n1_M2_101580_33540 0.988200
R3814 n1_M2_101580_33540 n1_M2_102660_33540 0.988200
R3815 n1_M2_102660_33540 n1_M2_103740_33540 0.988200
R3816 n1_M2_103740_33540 n1_M2_104820_33540 0.988200
R3817 n1_M2_104820_33540 n1_M2_105900_33540 0.988200
R3818 n1_M2_105900_33540 n1_M2_106980_33540 0.988200
R3819 n1_M2_106980_33540 n1_M2_108060_33540 0.988200
R3820 n1_M2_108060_33540 n1_M2_109140_33540 0.988200
R3821 n1_M2_109140_33540 n1_M2_110220_33540 0.988200
R3822 n1_M2_110220_33540 n1_M2_111300_33540 0.988200
R3823 n1_M2_111300_33540 n1_M2_112380_33540 0.988200
R3824 n1_M2_112380_33540 n1_M2_113460_33540 0.988200
R3825 n1_M2_113460_33540 n1_M2_114540_33540 0.988200
R3826 n1_M2_114540_33540 n1_M2_115620_33540 0.988200
R3827 n1_M2_115620_33540 n1_M2_116700_33540 0.988200
R3828 n1_M2_116700_33540 n1_M2_117780_33540 0.988200
R3829 n1_M2_117780_33540 n1_M2_118860_33540 0.988200
R3830 n1_M2_118860_33540 n1_M2_119940_33540 0.988200
R3831 n1_M2_119940_33540 n1_M2_121020_33540 0.988200
R3832 n1_M2_121020_33540 n1_M2_122100_33540 0.988200
R3833 n1_M2_122100_33540 n1_M2_123180_33540 0.988200
R3834 n1_M2_123180_33540 n1_M2_124260_33540 0.988200
R3835 n1_M2_124260_33540 n1_M2_125340_33540 0.988200
R3836 n1_M2_125340_33540 n1_M2_126420_33540 0.988200
R3837 n1_M2_126420_33540 n1_M2_127500_33540 0.988200
R3838 n1_M2_127500_33540 n1_M2_128580_33540 0.988200
R3839 n1_M2_128580_33540 n1_M2_129660_33540 0.988200
R3840 n1_M2_60_34620 n1_M2_1140_34620 0.988200
R3841 n1_M2_1140_34620 n1_M2_2220_34620 0.988200
R3842 n1_M2_2220_34620 n1_M2_3300_34620 0.988200
R3843 n1_M2_3300_34620 n1_M2_4380_34620 0.988200
R3844 n1_M2_4380_34620 n1_M2_5460_34620 0.988200
R3845 n1_M2_5460_34620 n1_M2_6540_34620 0.988200
R3846 n1_M2_6540_34620 n1_M2_7620_34620 0.988200
R3847 n1_M2_7620_34620 n1_M2_8700_34620 0.988200
R3848 n1_M2_8700_34620 n1_M2_9780_34620 0.988200
R3849 n1_M2_9780_34620 n1_M2_10860_34620 0.988200
R3850 n1_M2_10860_34620 n1_M2_11940_34620 0.988200
R3851 n1_M2_11940_34620 n1_M2_13020_34620 0.988200
R3852 n1_M2_13020_34620 n1_M2_14100_34620 0.988200
R3853 n1_M2_14100_34620 n1_M2_15180_34620 0.988200
R3854 n1_M2_15180_34620 n1_M2_16260_34620 0.988200
R3855 n1_M2_16260_34620 n1_M2_17340_34620 0.988200
R3856 n1_M2_17340_34620 n1_M2_18420_34620 0.988200
R3857 n1_M2_18420_34620 n1_M2_19500_34620 0.988200
R3858 n1_M2_19500_34620 n1_M2_20580_34620 0.988200
R3859 n1_M2_20580_34620 n1_M2_21660_34620 0.988200
R3860 n1_M2_21660_34620 n1_M2_22740_34620 0.988200
R3861 n1_M2_22740_34620 n1_M2_23820_34620 0.988200
R3862 n1_M2_23820_34620 n1_M2_24900_34620 0.988200
R3863 n1_M2_24900_34620 n1_M2_25980_34620 0.988200
R3864 n1_M2_25980_34620 n1_M2_27060_34620 0.988200
R3865 n1_M2_27060_34620 n1_M2_28140_34620 0.988200
R3866 n1_M2_28140_34620 n1_M2_29220_34620 0.988200
R3867 n1_M2_29220_34620 n1_M2_30300_34620 0.988200
R3868 n1_M2_30300_34620 n1_M2_31380_34620 0.988200
R3869 n1_M2_31380_34620 n1_M2_32460_34620 0.988200
R3870 n1_M2_32460_34620 n1_M2_33540_34620 0.988200
R3871 n1_M2_33540_34620 n1_M2_34620_34620 0.988200
R3872 n1_M2_34620_34620 n1_M2_35700_34620 0.988200
R3873 n1_M2_35700_34620 n1_M2_36780_34620 0.988200
R3874 n1_M2_36780_34620 n1_M2_37860_34620 0.988200
R3875 n1_M2_37860_34620 n1_M2_38940_34620 0.988200
R3876 n1_M2_38940_34620 n1_M2_40020_34620 0.988200
R3877 n1_M2_40020_34620 n1_M2_41100_34620 0.988200
R3878 n1_M2_41100_34620 n1_M2_42180_34620 0.988200
R3879 n1_M2_42180_34620 n1_M2_43260_34620 0.988200
R3880 n1_M2_43260_34620 n1_M2_44340_34620 0.988200
R3881 n1_M2_44340_34620 n1_M2_45420_34620 0.988200
R3882 n1_M2_45420_34620 n1_M2_46500_34620 0.988200
R3883 n1_M2_46500_34620 n1_M2_47580_34620 0.988200
R3884 n1_M2_47580_34620 n1_M2_48660_34620 0.988200
R3885 n1_M2_48660_34620 n1_M2_49740_34620 0.988200
R3886 n1_M2_49740_34620 n1_M2_50820_34620 0.988200
R3887 n1_M2_50820_34620 n1_M2_51900_34620 0.988200
R3888 n1_M2_51900_34620 n1_M2_52980_34620 0.988200
R3889 n1_M2_52980_34620 n1_M2_54060_34620 0.988200
R3890 n1_M2_54060_34620 n1_M2_55140_34620 0.988200
R3891 n1_M2_55140_34620 n1_M2_56220_34620 0.988200
R3892 n1_M2_56220_34620 n1_M2_57300_34620 0.988200
R3893 n1_M2_57300_34620 n1_M2_58380_34620 0.988200
R3894 n1_M2_58380_34620 n1_M2_59460_34620 0.988200
R3895 n1_M2_59460_34620 n1_M2_60540_34620 0.988200
R3896 n1_M2_60540_34620 n1_M2_61620_34620 0.988200
R3897 n1_M2_61620_34620 n1_M2_62700_34620 0.988200
R3898 n1_M2_62700_34620 n1_M2_63780_34620 0.988200
R3899 n1_M2_63780_34620 n1_M2_64860_34620 0.988200
R3900 n1_M2_64860_34620 n1_M2_65940_34620 0.988200
R3901 n1_M2_65940_34620 n1_M2_67020_34620 0.988200
R3902 n1_M2_67020_34620 n1_M2_68100_34620 0.988200
R3903 n1_M2_68100_34620 n1_M2_69180_34620 0.988200
R3904 n1_M2_69180_34620 n1_M2_70260_34620 0.988200
R3905 n1_M2_70260_34620 n1_M2_71340_34620 0.988200
R3906 n1_M2_71340_34620 n1_M2_72420_34620 0.988200
R3907 n1_M2_72420_34620 n1_M2_73500_34620 0.988200
R3908 n1_M2_73500_34620 n1_M2_74580_34620 0.988200
R3909 n1_M2_74580_34620 n1_M2_75660_34620 0.988200
R3910 n1_M2_75660_34620 n1_M2_76740_34620 0.988200
R3911 n1_M2_76740_34620 n1_M2_77820_34620 0.988200
R3912 n1_M2_77820_34620 n1_M2_78900_34620 0.988200
R3913 n1_M2_78900_34620 n1_M2_79980_34620 0.988200
R3914 n1_M2_79980_34620 n1_M2_81060_34620 0.988200
R3915 n1_M2_81060_34620 n1_M2_82140_34620 0.988200
R3916 n1_M2_82140_34620 n1_M2_83220_34620 0.988200
R3917 n1_M2_83220_34620 n1_M2_84300_34620 0.988200
R3918 n1_M2_84300_34620 n1_M2_85380_34620 0.988200
R3919 n1_M2_85380_34620 n1_M2_86460_34620 0.988200
R3920 n1_M2_86460_34620 n1_M2_87540_34620 0.988200
R3921 n1_M2_87540_34620 n1_M2_88620_34620 0.988200
R3922 n1_M2_88620_34620 n1_M2_89700_34620 0.988200
R3923 n1_M2_89700_34620 n1_M2_90780_34620 0.988200
R3924 n1_M2_90780_34620 n1_M2_91860_34620 0.988200
R3925 n1_M2_91860_34620 n1_M2_92940_34620 0.988200
R3926 n1_M2_92940_34620 n1_M2_94020_34620 0.988200
R3927 n1_M2_94020_34620 n1_M2_95100_34620 0.988200
R3928 n1_M2_95100_34620 n1_M2_96180_34620 0.988200
R3929 n1_M2_96180_34620 n1_M2_97260_34620 0.988200
R3930 n1_M2_97260_34620 n1_M2_98340_34620 0.988200
R3931 n1_M2_98340_34620 n1_M2_99420_34620 0.988200
R3932 n1_M2_99420_34620 n1_M2_100500_34620 0.988200
R3933 n1_M2_100500_34620 n1_M2_101580_34620 0.988200
R3934 n1_M2_101580_34620 n1_M2_102660_34620 0.988200
R3935 n1_M2_102660_34620 n1_M2_103740_34620 0.988200
R3936 n1_M2_103740_34620 n1_M2_104820_34620 0.988200
R3937 n1_M2_104820_34620 n1_M2_105900_34620 0.988200
R3938 n1_M2_105900_34620 n1_M2_106980_34620 0.988200
R3939 n1_M2_106980_34620 n1_M2_108060_34620 0.988200
R3940 n1_M2_108060_34620 n1_M2_109140_34620 0.988200
R3941 n1_M2_109140_34620 n1_M2_110220_34620 0.988200
R3942 n1_M2_110220_34620 n1_M2_111300_34620 0.988200
R3943 n1_M2_111300_34620 n1_M2_112380_34620 0.988200
R3944 n1_M2_112380_34620 n1_M2_113460_34620 0.988200
R3945 n1_M2_113460_34620 n1_M2_114540_34620 0.988200
R3946 n1_M2_114540_34620 n1_M2_115620_34620 0.988200
R3947 n1_M2_115620_34620 n1_M2_116700_34620 0.988200
R3948 n1_M2_116700_34620 n1_M2_117780_34620 0.988200
R3949 n1_M2_117780_34620 n1_M2_118860_34620 0.988200
R3950 n1_M2_118860_34620 n1_M2_119940_34620 0.988200
R3951 n1_M2_119940_34620 n1_M2_121020_34620 0.988200
R3952 n1_M2_121020_34620 n1_M2_122100_34620 0.988200
R3953 n1_M2_122100_34620 n1_M2_123180_34620 0.988200
R3954 n1_M2_123180_34620 n1_M2_124260_34620 0.988200
R3955 n1_M2_124260_34620 n1_M2_125340_34620 0.988200
R3956 n1_M2_125340_34620 n1_M2_126420_34620 0.988200
R3957 n1_M2_126420_34620 n1_M2_127500_34620 0.988200
R3958 n1_M2_127500_34620 n1_M2_128580_34620 0.988200
R3959 n1_M2_128580_34620 n1_M2_129660_34620 0.988200
R3960 n1_M2_60_35700 n1_M2_1140_35700 0.988200
R3961 n1_M2_1140_35700 n1_M2_2220_35700 0.988200
R3962 n1_M2_2220_35700 n1_M2_3300_35700 0.988200
R3963 n1_M2_3300_35700 n1_M2_4380_35700 0.988200
R3964 n1_M2_4380_35700 n1_M2_5460_35700 0.988200
R3965 n1_M2_5460_35700 n1_M2_6540_35700 0.988200
R3966 n1_M2_6540_35700 n1_M2_7620_35700 0.988200
R3967 n1_M2_7620_35700 n1_M2_8700_35700 0.988200
R3968 n1_M2_8700_35700 n1_M2_9780_35700 0.988200
R3969 n1_M2_9780_35700 n1_M2_10860_35700 0.988200
R3970 n1_M2_10860_35700 n1_M2_11940_35700 0.988200
R3971 n1_M2_11940_35700 n1_M2_13020_35700 0.988200
R3972 n1_M2_13020_35700 n1_M2_14100_35700 0.988200
R3973 n1_M2_14100_35700 n1_M2_15180_35700 0.988200
R3974 n1_M2_15180_35700 n1_M2_16260_35700 0.988200
R3975 n1_M2_16260_35700 n1_M2_17340_35700 0.988200
R3976 n1_M2_17340_35700 n1_M2_18420_35700 0.988200
R3977 n1_M2_18420_35700 n1_M2_19500_35700 0.988200
R3978 n1_M2_19500_35700 n1_M2_20580_35700 0.988200
R3979 n1_M2_20580_35700 n1_M2_21660_35700 0.988200
R3980 n1_M2_21660_35700 n1_M2_22740_35700 0.988200
R3981 n1_M2_22740_35700 n1_M2_23820_35700 0.988200
R3982 n1_M2_23820_35700 n1_M2_24900_35700 0.988200
R3983 n1_M2_24900_35700 n1_M2_25980_35700 0.988200
R3984 n1_M2_25980_35700 n1_M2_27060_35700 0.988200
R3985 n1_M2_27060_35700 n1_M2_28140_35700 0.988200
R3986 n1_M2_28140_35700 n1_M2_29220_35700 0.988200
R3987 n1_M2_29220_35700 n1_M2_30300_35700 0.988200
R3988 n1_M2_30300_35700 n1_M2_31380_35700 0.988200
R3989 n1_M2_31380_35700 n1_M2_32460_35700 0.988200
R3990 n1_M2_32460_35700 n1_M2_33540_35700 0.988200
R3991 n1_M2_33540_35700 n1_M2_34620_35700 0.988200
R3992 n1_M2_34620_35700 n1_M2_35700_35700 0.988200
R3993 n1_M2_35700_35700 n1_M2_36780_35700 0.988200
R3994 n1_M2_36780_35700 n1_M2_37860_35700 0.988200
R3995 n1_M2_37860_35700 n1_M2_38940_35700 0.988200
R3996 n1_M2_38940_35700 n1_M2_40020_35700 0.988200
R3997 n1_M2_40020_35700 n1_M2_41100_35700 0.988200
R3998 n1_M2_41100_35700 n1_M2_42180_35700 0.988200
R3999 n1_M2_42180_35700 n1_M2_43260_35700 0.988200
R4000 n1_M2_43260_35700 n1_M2_44340_35700 0.988200
R4001 n1_M2_44340_35700 n1_M2_45420_35700 0.988200
R4002 n1_M2_45420_35700 n1_M2_46500_35700 0.988200
R4003 n1_M2_46500_35700 n1_M2_47580_35700 0.988200
R4004 n1_M2_47580_35700 n1_M2_48660_35700 0.988200
R4005 n1_M2_48660_35700 n1_M2_49740_35700 0.988200
R4006 n1_M2_49740_35700 n1_M2_50820_35700 0.988200
R4007 n1_M2_50820_35700 n1_M2_51900_35700 0.988200
R4008 n1_M2_51900_35700 n1_M2_52980_35700 0.988200
R4009 n1_M2_52980_35700 n1_M2_54060_35700 0.988200
R4010 n1_M2_54060_35700 n1_M2_55140_35700 0.988200
R4011 n1_M2_55140_35700 n1_M2_56220_35700 0.988200
R4012 n1_M2_56220_35700 n1_M2_57300_35700 0.988200
R4013 n1_M2_57300_35700 n1_M2_58380_35700 0.988200
R4014 n1_M2_58380_35700 n1_M2_59460_35700 0.988200
R4015 n1_M2_59460_35700 n1_M2_60540_35700 0.988200
R4016 n1_M2_60540_35700 n1_M2_61620_35700 0.988200
R4017 n1_M2_61620_35700 n1_M2_62700_35700 0.988200
R4018 n1_M2_62700_35700 n1_M2_63780_35700 0.988200
R4019 n1_M2_63780_35700 n1_M2_64860_35700 0.988200
R4020 n1_M2_64860_35700 n1_M2_65940_35700 0.988200
R4021 n1_M2_65940_35700 n1_M2_67020_35700 0.988200
R4022 n1_M2_67020_35700 n1_M2_68100_35700 0.988200
R4023 n1_M2_68100_35700 n1_M2_69180_35700 0.988200
R4024 n1_M2_69180_35700 n1_M2_70260_35700 0.988200
R4025 n1_M2_70260_35700 n1_M2_71340_35700 0.988200
R4026 n1_M2_71340_35700 n1_M2_72420_35700 0.988200
R4027 n1_M2_72420_35700 n1_M2_73500_35700 0.988200
R4028 n1_M2_73500_35700 n1_M2_74580_35700 0.988200
R4029 n1_M2_74580_35700 n1_M2_75660_35700 0.988200
R4030 n1_M2_75660_35700 n1_M2_76740_35700 0.988200
R4031 n1_M2_76740_35700 n1_M2_77820_35700 0.988200
R4032 n1_M2_77820_35700 n1_M2_78900_35700 0.988200
R4033 n1_M2_78900_35700 n1_M2_79980_35700 0.988200
R4034 n1_M2_79980_35700 n1_M2_81060_35700 0.988200
R4035 n1_M2_81060_35700 n1_M2_82140_35700 0.988200
R4036 n1_M2_82140_35700 n1_M2_83220_35700 0.988200
R4037 n1_M2_83220_35700 n1_M2_84300_35700 0.988200
R4038 n1_M2_84300_35700 n1_M2_85380_35700 0.988200
R4039 n1_M2_85380_35700 n1_M2_86460_35700 0.988200
R4040 n1_M2_86460_35700 n1_M2_87540_35700 0.988200
R4041 n1_M2_87540_35700 n1_M2_88620_35700 0.988200
R4042 n1_M2_88620_35700 n1_M2_89700_35700 0.988200
R4043 n1_M2_89700_35700 n1_M2_90780_35700 0.988200
R4044 n1_M2_90780_35700 n1_M2_91860_35700 0.988200
R4045 n1_M2_91860_35700 n1_M2_92940_35700 0.988200
R4046 n1_M2_92940_35700 n1_M2_94020_35700 0.988200
R4047 n1_M2_94020_35700 n1_M2_95100_35700 0.988200
R4048 n1_M2_95100_35700 n1_M2_96180_35700 0.988200
R4049 n1_M2_96180_35700 n1_M2_97260_35700 0.988200
R4050 n1_M2_97260_35700 n1_M2_98340_35700 0.988200
R4051 n1_M2_98340_35700 n1_M2_99420_35700 0.988200
R4052 n1_M2_99420_35700 n1_M2_100500_35700 0.988200
R4053 n1_M2_100500_35700 n1_M2_101580_35700 0.988200
R4054 n1_M2_101580_35700 n1_M2_102660_35700 0.988200
R4055 n1_M2_102660_35700 n1_M2_103740_35700 0.988200
R4056 n1_M2_103740_35700 n1_M2_104820_35700 0.988200
R4057 n1_M2_104820_35700 n1_M2_105900_35700 0.988200
R4058 n1_M2_105900_35700 n1_M2_106980_35700 0.988200
R4059 n1_M2_106980_35700 n1_M2_108060_35700 0.988200
R4060 n1_M2_108060_35700 n1_M2_109140_35700 0.988200
R4061 n1_M2_109140_35700 n1_M2_110220_35700 0.988200
R4062 n1_M2_110220_35700 n1_M2_111300_35700 0.988200
R4063 n1_M2_111300_35700 n1_M2_112380_35700 0.988200
R4064 n1_M2_112380_35700 n1_M2_113460_35700 0.988200
R4065 n1_M2_113460_35700 n1_M2_114540_35700 0.988200
R4066 n1_M2_114540_35700 n1_M2_115620_35700 0.988200
R4067 n1_M2_115620_35700 n1_M2_116700_35700 0.988200
R4068 n1_M2_116700_35700 n1_M2_117780_35700 0.988200
R4069 n1_M2_117780_35700 n1_M2_118860_35700 0.988200
R4070 n1_M2_118860_35700 n1_M2_119940_35700 0.988200
R4071 n1_M2_119940_35700 n1_M2_121020_35700 0.988200
R4072 n1_M2_121020_35700 n1_M2_122100_35700 0.988200
R4073 n1_M2_122100_35700 n1_M2_123180_35700 0.988200
R4074 n1_M2_123180_35700 n1_M2_124260_35700 0.988200
R4075 n1_M2_124260_35700 n1_M2_125340_35700 0.988200
R4076 n1_M2_125340_35700 n1_M2_126420_35700 0.988200
R4077 n1_M2_126420_35700 n1_M2_127500_35700 0.988200
R4078 n1_M2_127500_35700 n1_M2_128580_35700 0.988200
R4079 n1_M2_128580_35700 n1_M2_129660_35700 0.988200
R4080 n1_M2_60_36780 n1_M2_1140_36780 0.988200
R4081 n1_M2_1140_36780 n1_M2_2220_36780 0.988200
R4082 n1_M2_2220_36780 n1_M2_3300_36780 0.988200
R4083 n1_M2_3300_36780 n1_M2_4380_36780 0.988200
R4084 n1_M2_4380_36780 n1_M2_5460_36780 0.988200
R4085 n1_M2_5460_36780 n1_M2_6540_36780 0.988200
R4086 n1_M2_6540_36780 n1_M2_7620_36780 0.988200
R4087 n1_M2_7620_36780 n1_M2_8700_36780 0.988200
R4088 n1_M2_8700_36780 n1_M2_9780_36780 0.988200
R4089 n1_M2_9780_36780 n1_M2_10860_36780 0.988200
R4090 n1_M2_10860_36780 n1_M2_11940_36780 0.988200
R4091 n1_M2_11940_36780 n1_M2_13020_36780 0.988200
R4092 n1_M2_13020_36780 n1_M2_14100_36780 0.988200
R4093 n1_M2_14100_36780 n1_M2_15180_36780 0.988200
R4094 n1_M2_15180_36780 n1_M2_16260_36780 0.988200
R4095 n1_M2_16260_36780 n1_M2_17340_36780 0.988200
R4096 n1_M2_17340_36780 n1_M2_18420_36780 0.988200
R4097 n1_M2_18420_36780 n1_M2_19500_36780 0.988200
R4098 n1_M2_19500_36780 n1_M2_20580_36780 0.988200
R4099 n1_M2_20580_36780 n1_M2_21660_36780 0.988200
R4100 n1_M2_21660_36780 n1_M2_22740_36780 0.988200
R4101 n1_M2_22740_36780 n1_M2_23820_36780 0.988200
R4102 n1_M2_23820_36780 n1_M2_24900_36780 0.988200
R4103 n1_M2_24900_36780 n1_M2_25980_36780 0.988200
R4104 n1_M2_25980_36780 n1_M2_27060_36780 0.988200
R4105 n1_M2_27060_36780 n1_M2_28140_36780 0.988200
R4106 n1_M2_28140_36780 n1_M2_29220_36780 0.988200
R4107 n1_M2_29220_36780 n1_M2_30300_36780 0.988200
R4108 n1_M2_30300_36780 n1_M2_31380_36780 0.988200
R4109 n1_M2_31380_36780 n1_M2_32460_36780 0.988200
R4110 n1_M2_32460_36780 n1_M2_33540_36780 0.988200
R4111 n1_M2_33540_36780 n1_M2_34620_36780 0.988200
R4112 n1_M2_34620_36780 n1_M2_35700_36780 0.988200
R4113 n1_M2_35700_36780 n1_M2_36780_36780 0.988200
R4114 n1_M2_36780_36780 n1_M2_37860_36780 0.988200
R4115 n1_M2_37860_36780 n1_M2_38940_36780 0.988200
R4116 n1_M2_38940_36780 n1_M2_40020_36780 0.988200
R4117 n1_M2_40020_36780 n1_M2_41100_36780 0.988200
R4118 n1_M2_41100_36780 n1_M2_42180_36780 0.988200
R4119 n1_M2_42180_36780 n1_M2_43260_36780 0.988200
R4120 n1_M2_43260_36780 n1_M2_44340_36780 0.988200
R4121 n1_M2_44340_36780 n1_M2_45420_36780 0.988200
R4122 n1_M2_45420_36780 n1_M2_46500_36780 0.988200
R4123 n1_M2_46500_36780 n1_M2_47580_36780 0.988200
R4124 n1_M2_47580_36780 n1_M2_48660_36780 0.988200
R4125 n1_M2_48660_36780 n1_M2_49740_36780 0.988200
R4126 n1_M2_49740_36780 n1_M2_50820_36780 0.988200
R4127 n1_M2_50820_36780 n1_M2_51900_36780 0.988200
R4128 n1_M2_51900_36780 n1_M2_52980_36780 0.988200
R4129 n1_M2_52980_36780 n1_M2_54060_36780 0.988200
R4130 n1_M2_54060_36780 n1_M2_55140_36780 0.988200
R4131 n1_M2_55140_36780 n1_M2_56220_36780 0.988200
R4132 n1_M2_56220_36780 n1_M2_57300_36780 0.988200
R4133 n1_M2_57300_36780 n1_M2_58380_36780 0.988200
R4134 n1_M2_58380_36780 n1_M2_59460_36780 0.988200
R4135 n1_M2_59460_36780 n1_M2_60540_36780 0.988200
R4136 n1_M2_60540_36780 n1_M2_61620_36780 0.988200
R4137 n1_M2_61620_36780 n1_M2_62700_36780 0.988200
R4138 n1_M2_62700_36780 n1_M2_63780_36780 0.988200
R4139 n1_M2_63780_36780 n1_M2_64860_36780 0.988200
R4140 n1_M2_64860_36780 n1_M2_65940_36780 0.988200
R4141 n1_M2_65940_36780 n1_M2_67020_36780 0.988200
R4142 n1_M2_67020_36780 n1_M2_68100_36780 0.988200
R4143 n1_M2_68100_36780 n1_M2_69180_36780 0.988200
R4144 n1_M2_69180_36780 n1_M2_70260_36780 0.988200
R4145 n1_M2_70260_36780 n1_M2_71340_36780 0.988200
R4146 n1_M2_71340_36780 n1_M2_72420_36780 0.988200
R4147 n1_M2_72420_36780 n1_M2_73500_36780 0.988200
R4148 n1_M2_73500_36780 n1_M2_74580_36780 0.988200
R4149 n1_M2_74580_36780 n1_M2_75660_36780 0.988200
R4150 n1_M2_75660_36780 n1_M2_76740_36780 0.988200
R4151 n1_M2_76740_36780 n1_M2_77820_36780 0.988200
R4152 n1_M2_77820_36780 n1_M2_78900_36780 0.988200
R4153 n1_M2_78900_36780 n1_M2_79980_36780 0.988200
R4154 n1_M2_79980_36780 n1_M2_81060_36780 0.988200
R4155 n1_M2_81060_36780 n1_M2_82140_36780 0.988200
R4156 n1_M2_82140_36780 n1_M2_83220_36780 0.988200
R4157 n1_M2_83220_36780 n1_M2_84300_36780 0.988200
R4158 n1_M2_84300_36780 n1_M2_85380_36780 0.988200
R4159 n1_M2_85380_36780 n1_M2_86460_36780 0.988200
R4160 n1_M2_86460_36780 n1_M2_87540_36780 0.988200
R4161 n1_M2_87540_36780 n1_M2_88620_36780 0.988200
R4162 n1_M2_88620_36780 n1_M2_89700_36780 0.988200
R4163 n1_M2_89700_36780 n1_M2_90780_36780 0.988200
R4164 n1_M2_90780_36780 n1_M2_91860_36780 0.988200
R4165 n1_M2_91860_36780 n1_M2_92940_36780 0.988200
R4166 n1_M2_92940_36780 n1_M2_94020_36780 0.988200
R4167 n1_M2_94020_36780 n1_M2_95100_36780 0.988200
R4168 n1_M2_95100_36780 n1_M2_96180_36780 0.988200
R4169 n1_M2_96180_36780 n1_M2_97260_36780 0.988200
R4170 n1_M2_97260_36780 n1_M2_98340_36780 0.988200
R4171 n1_M2_98340_36780 n1_M2_99420_36780 0.988200
R4172 n1_M2_99420_36780 n1_M2_100500_36780 0.988200
R4173 n1_M2_100500_36780 n1_M2_101580_36780 0.988200
R4174 n1_M2_101580_36780 n1_M2_102660_36780 0.988200
R4175 n1_M2_102660_36780 n1_M2_103740_36780 0.988200
R4176 n1_M2_103740_36780 n1_M2_104820_36780 0.988200
R4177 n1_M2_104820_36780 n1_M2_105900_36780 0.988200
R4178 n1_M2_105900_36780 n1_M2_106980_36780 0.988200
R4179 n1_M2_106980_36780 n1_M2_108060_36780 0.988200
R4180 n1_M2_108060_36780 n1_M2_109140_36780 0.988200
R4181 n1_M2_109140_36780 n1_M2_110220_36780 0.988200
R4182 n1_M2_110220_36780 n1_M2_111300_36780 0.988200
R4183 n1_M2_111300_36780 n1_M2_112380_36780 0.988200
R4184 n1_M2_112380_36780 n1_M2_113460_36780 0.988200
R4185 n1_M2_113460_36780 n1_M2_114540_36780 0.988200
R4186 n1_M2_114540_36780 n1_M2_115620_36780 0.988200
R4187 n1_M2_115620_36780 n1_M2_116700_36780 0.988200
R4188 n1_M2_116700_36780 n1_M2_117780_36780 0.988200
R4189 n1_M2_117780_36780 n1_M2_118860_36780 0.988200
R4190 n1_M2_118860_36780 n1_M2_119940_36780 0.988200
R4191 n1_M2_119940_36780 n1_M2_121020_36780 0.988200
R4192 n1_M2_121020_36780 n1_M2_122100_36780 0.988200
R4193 n1_M2_122100_36780 n1_M2_123180_36780 0.988200
R4194 n1_M2_123180_36780 n1_M2_124260_36780 0.988200
R4195 n1_M2_124260_36780 n1_M2_125340_36780 0.988200
R4196 n1_M2_125340_36780 n1_M2_126420_36780 0.988200
R4197 n1_M2_126420_36780 n1_M2_127500_36780 0.988200
R4198 n1_M2_127500_36780 n1_M2_128580_36780 0.988200
R4199 n1_M2_128580_36780 n1_M2_129660_36780 0.988200
R4200 n1_M2_60_37860 n1_M2_1140_37860 0.988200
R4201 n1_M2_1140_37860 n1_M2_2220_37860 0.988200
R4202 n1_M2_2220_37860 n1_M2_3300_37860 0.988200
R4203 n1_M2_3300_37860 n1_M2_4380_37860 0.988200
R4204 n1_M2_4380_37860 n1_M2_5460_37860 0.988200
R4205 n1_M2_5460_37860 n1_M2_6540_37860 0.988200
R4206 n1_M2_6540_37860 n1_M2_7620_37860 0.988200
R4207 n1_M2_7620_37860 n1_M2_8700_37860 0.988200
R4208 n1_M2_8700_37860 n1_M2_9780_37860 0.988200
R4209 n1_M2_9780_37860 n1_M2_10860_37860 0.988200
R4210 n1_M2_10860_37860 n1_M2_11940_37860 0.988200
R4211 n1_M2_11940_37860 n1_M2_13020_37860 0.988200
R4212 n1_M2_13020_37860 n1_M2_14100_37860 0.988200
R4213 n1_M2_14100_37860 n1_M2_15180_37860 0.988200
R4214 n1_M2_15180_37860 n1_M2_16260_37860 0.988200
R4215 n1_M2_16260_37860 n1_M2_17340_37860 0.988200
R4216 n1_M2_17340_37860 n1_M2_18420_37860 0.988200
R4217 n1_M2_18420_37860 n1_M2_19500_37860 0.988200
R4218 n1_M2_19500_37860 n1_M2_20580_37860 0.988200
R4219 n1_M2_20580_37860 n1_M2_21660_37860 0.988200
R4220 n1_M2_21660_37860 n1_M2_22740_37860 0.988200
R4221 n1_M2_22740_37860 n1_M2_23820_37860 0.988200
R4222 n1_M2_23820_37860 n1_M2_24900_37860 0.988200
R4223 n1_M2_24900_37860 n1_M2_25980_37860 0.988200
R4224 n1_M2_25980_37860 n1_M2_27060_37860 0.988200
R4225 n1_M2_27060_37860 n1_M2_28140_37860 0.988200
R4226 n1_M2_28140_37860 n1_M2_29220_37860 0.988200
R4227 n1_M2_29220_37860 n1_M2_30300_37860 0.988200
R4228 n1_M2_30300_37860 n1_M2_31380_37860 0.988200
R4229 n1_M2_31380_37860 n1_M2_32460_37860 0.988200
R4230 n1_M2_32460_37860 n1_M2_33540_37860 0.988200
R4231 n1_M2_33540_37860 n1_M2_34620_37860 0.988200
R4232 n1_M2_34620_37860 n1_M2_35700_37860 0.988200
R4233 n1_M2_35700_37860 n1_M2_36780_37860 0.988200
R4234 n1_M2_36780_37860 n1_M2_37860_37860 0.988200
R4235 n1_M2_37860_37860 n1_M2_38940_37860 0.988200
R4236 n1_M2_38940_37860 n1_M2_40020_37860 0.988200
R4237 n1_M2_40020_37860 n1_M2_41100_37860 0.988200
R4238 n1_M2_41100_37860 n1_M2_42180_37860 0.988200
R4239 n1_M2_42180_37860 n1_M2_43260_37860 0.988200
R4240 n1_M2_43260_37860 n1_M2_44340_37860 0.988200
R4241 n1_M2_44340_37860 n1_M2_45420_37860 0.988200
R4242 n1_M2_45420_37860 n1_M2_46500_37860 0.988200
R4243 n1_M2_46500_37860 n1_M2_47580_37860 0.988200
R4244 n1_M2_47580_37860 n1_M2_48660_37860 0.988200
R4245 n1_M2_48660_37860 n1_M2_49740_37860 0.988200
R4246 n1_M2_49740_37860 n1_M2_50820_37860 0.988200
R4247 n1_M2_50820_37860 n1_M2_51900_37860 0.988200
R4248 n1_M2_51900_37860 n1_M2_52980_37860 0.988200
R4249 n1_M2_52980_37860 n1_M2_54060_37860 0.988200
R4250 n1_M2_54060_37860 n1_M2_55140_37860 0.988200
R4251 n1_M2_55140_37860 n1_M2_56220_37860 0.988200
R4252 n1_M2_56220_37860 n1_M2_57300_37860 0.988200
R4253 n1_M2_57300_37860 n1_M2_58380_37860 0.988200
R4254 n1_M2_58380_37860 n1_M2_59460_37860 0.988200
R4255 n1_M2_59460_37860 n1_M2_60540_37860 0.988200
R4256 n1_M2_60540_37860 n1_M2_61620_37860 0.988200
R4257 n1_M2_61620_37860 n1_M2_62700_37860 0.988200
R4258 n1_M2_62700_37860 n1_M2_63780_37860 0.988200
R4259 n1_M2_63780_37860 n1_M2_64860_37860 0.988200
R4260 n1_M2_64860_37860 n1_M2_65940_37860 0.988200
R4261 n1_M2_65940_37860 n1_M2_67020_37860 0.988200
R4262 n1_M2_67020_37860 n1_M2_68100_37860 0.988200
R4263 n1_M2_68100_37860 n1_M2_69180_37860 0.988200
R4264 n1_M2_69180_37860 n1_M2_70260_37860 0.988200
R4265 n1_M2_70260_37860 n1_M2_71340_37860 0.988200
R4266 n1_M2_71340_37860 n1_M2_72420_37860 0.988200
R4267 n1_M2_72420_37860 n1_M2_73500_37860 0.988200
R4268 n1_M2_73500_37860 n1_M2_74580_37860 0.988200
R4269 n1_M2_74580_37860 n1_M2_75660_37860 0.988200
R4270 n1_M2_75660_37860 n1_M2_76740_37860 0.988200
R4271 n1_M2_76740_37860 n1_M2_77820_37860 0.988200
R4272 n1_M2_77820_37860 n1_M2_78900_37860 0.988200
R4273 n1_M2_78900_37860 n1_M2_79980_37860 0.988200
R4274 n1_M2_79980_37860 n1_M2_81060_37860 0.988200
R4275 n1_M2_81060_37860 n1_M2_82140_37860 0.988200
R4276 n1_M2_82140_37860 n1_M2_83220_37860 0.988200
R4277 n1_M2_83220_37860 n1_M2_84300_37860 0.988200
R4278 n1_M2_84300_37860 n1_M2_85380_37860 0.988200
R4279 n1_M2_85380_37860 n1_M2_86460_37860 0.988200
R4280 n1_M2_86460_37860 n1_M2_87540_37860 0.988200
R4281 n1_M2_87540_37860 n1_M2_88620_37860 0.988200
R4282 n1_M2_88620_37860 n1_M2_89700_37860 0.988200
R4283 n1_M2_89700_37860 n1_M2_90780_37860 0.988200
R4284 n1_M2_90780_37860 n1_M2_91860_37860 0.988200
R4285 n1_M2_91860_37860 n1_M2_92940_37860 0.988200
R4286 n1_M2_92940_37860 n1_M2_94020_37860 0.988200
R4287 n1_M2_94020_37860 n1_M2_95100_37860 0.988200
R4288 n1_M2_95100_37860 n1_M2_96180_37860 0.988200
R4289 n1_M2_96180_37860 n1_M2_97260_37860 0.988200
R4290 n1_M2_97260_37860 n1_M2_98340_37860 0.988200
R4291 n1_M2_98340_37860 n1_M2_99420_37860 0.988200
R4292 n1_M2_99420_37860 n1_M2_100500_37860 0.988200
R4293 n1_M2_100500_37860 n1_M2_101580_37860 0.988200
R4294 n1_M2_101580_37860 n1_M2_102660_37860 0.988200
R4295 n1_M2_102660_37860 n1_M2_103740_37860 0.988200
R4296 n1_M2_103740_37860 n1_M2_104820_37860 0.988200
R4297 n1_M2_104820_37860 n1_M2_105900_37860 0.988200
R4298 n1_M2_105900_37860 n1_M2_106980_37860 0.988200
R4299 n1_M2_106980_37860 n1_M2_108060_37860 0.988200
R4300 n1_M2_108060_37860 n1_M2_109140_37860 0.988200
R4301 n1_M2_109140_37860 n1_M2_110220_37860 0.988200
R4302 n1_M2_110220_37860 n1_M2_111300_37860 0.988200
R4303 n1_M2_111300_37860 n1_M2_112380_37860 0.988200
R4304 n1_M2_112380_37860 n1_M2_113460_37860 0.988200
R4305 n1_M2_113460_37860 n1_M2_114540_37860 0.988200
R4306 n1_M2_114540_37860 n1_M2_115620_37860 0.988200
R4307 n1_M2_115620_37860 n1_M2_116700_37860 0.988200
R4308 n1_M2_116700_37860 n1_M2_117780_37860 0.988200
R4309 n1_M2_117780_37860 n1_M2_118860_37860 0.988200
R4310 n1_M2_118860_37860 n1_M2_119940_37860 0.988200
R4311 n1_M2_119940_37860 n1_M2_121020_37860 0.988200
R4312 n1_M2_121020_37860 n1_M2_122100_37860 0.988200
R4313 n1_M2_122100_37860 n1_M2_123180_37860 0.988200
R4314 n1_M2_123180_37860 n1_M2_124260_37860 0.988200
R4315 n1_M2_124260_37860 n1_M2_125340_37860 0.988200
R4316 n1_M2_125340_37860 n1_M2_126420_37860 0.988200
R4317 n1_M2_126420_37860 n1_M2_127500_37860 0.988200
R4318 n1_M2_127500_37860 n1_M2_128580_37860 0.988200
R4319 n1_M2_128580_37860 n1_M2_129660_37860 0.988200
R4320 n1_M2_60_38940 n1_M2_1140_38940 0.988200
R4321 n1_M2_1140_38940 n1_M2_2220_38940 0.988200
R4322 n1_M2_2220_38940 n1_M2_3300_38940 0.988200
R4323 n1_M2_3300_38940 n1_M2_4380_38940 0.988200
R4324 n1_M2_4380_38940 n1_M2_5460_38940 0.988200
R4325 n1_M2_5460_38940 n1_M2_6540_38940 0.988200
R4326 n1_M2_6540_38940 n1_M2_7620_38940 0.988200
R4327 n1_M2_7620_38940 n1_M2_8700_38940 0.988200
R4328 n1_M2_8700_38940 n1_M2_9780_38940 0.988200
R4329 n1_M2_9780_38940 n1_M2_10860_38940 0.988200
R4330 n1_M2_10860_38940 n1_M2_11940_38940 0.988200
R4331 n1_M2_11940_38940 n1_M2_13020_38940 0.988200
R4332 n1_M2_13020_38940 n1_M2_14100_38940 0.988200
R4333 n1_M2_14100_38940 n1_M2_15180_38940 0.988200
R4334 n1_M2_15180_38940 n1_M2_16260_38940 0.988200
R4335 n1_M2_16260_38940 n1_M2_17340_38940 0.988200
R4336 n1_M2_17340_38940 n1_M2_18420_38940 0.988200
R4337 n1_M2_18420_38940 n1_M2_19500_38940 0.988200
R4338 n1_M2_19500_38940 n1_M2_20580_38940 0.988200
R4339 n1_M2_20580_38940 n1_M2_21660_38940 0.988200
R4340 n1_M2_21660_38940 n1_M2_22740_38940 0.988200
R4341 n1_M2_22740_38940 n1_M2_23820_38940 0.988200
R4342 n1_M2_23820_38940 n1_M2_24900_38940 0.988200
R4343 n1_M2_24900_38940 n1_M2_25980_38940 0.988200
R4344 n1_M2_25980_38940 n1_M2_27060_38940 0.988200
R4345 n1_M2_27060_38940 n1_M2_28140_38940 0.988200
R4346 n1_M2_28140_38940 n1_M2_29220_38940 0.988200
R4347 n1_M2_29220_38940 n1_M2_30300_38940 0.988200
R4348 n1_M2_30300_38940 n1_M2_31380_38940 0.988200
R4349 n1_M2_31380_38940 n1_M2_32460_38940 0.988200
R4350 n1_M2_32460_38940 n1_M2_33540_38940 0.988200
R4351 n1_M2_33540_38940 n1_M2_34620_38940 0.988200
R4352 n1_M2_34620_38940 n1_M2_35700_38940 0.988200
R4353 n1_M2_35700_38940 n1_M2_36780_38940 0.988200
R4354 n1_M2_36780_38940 n1_M2_37860_38940 0.988200
R4355 n1_M2_37860_38940 n1_M2_38940_38940 0.988200
R4356 n1_M2_38940_38940 n1_M2_40020_38940 0.988200
R4357 n1_M2_40020_38940 n1_M2_41100_38940 0.988200
R4358 n1_M2_41100_38940 n1_M2_42180_38940 0.988200
R4359 n1_M2_42180_38940 n1_M2_43260_38940 0.988200
R4360 n1_M2_43260_38940 n1_M2_44340_38940 0.988200
R4361 n1_M2_44340_38940 n1_M2_45420_38940 0.988200
R4362 n1_M2_45420_38940 n1_M2_46500_38940 0.988200
R4363 n1_M2_46500_38940 n1_M2_47580_38940 0.988200
R4364 n1_M2_47580_38940 n1_M2_48660_38940 0.988200
R4365 n1_M2_48660_38940 n1_M2_49740_38940 0.988200
R4366 n1_M2_49740_38940 n1_M2_50820_38940 0.988200
R4367 n1_M2_50820_38940 n1_M2_51900_38940 0.988200
R4368 n1_M2_51900_38940 n1_M2_52980_38940 0.988200
R4369 n1_M2_52980_38940 n1_M2_54060_38940 0.988200
R4370 n1_M2_54060_38940 n1_M2_55140_38940 0.988200
R4371 n1_M2_55140_38940 n1_M2_56220_38940 0.988200
R4372 n1_M2_56220_38940 n1_M2_57300_38940 0.988200
R4373 n1_M2_57300_38940 n1_M2_58380_38940 0.988200
R4374 n1_M2_58380_38940 n1_M2_59460_38940 0.988200
R4375 n1_M2_59460_38940 n1_M2_60540_38940 0.988200
R4376 n1_M2_60540_38940 n1_M2_61620_38940 0.988200
R4377 n1_M2_61620_38940 n1_M2_62700_38940 0.988200
R4378 n1_M2_62700_38940 n1_M2_63780_38940 0.988200
R4379 n1_M2_63780_38940 n1_M2_64860_38940 0.988200
R4380 n1_M2_64860_38940 n1_M2_65940_38940 0.988200
R4381 n1_M2_65940_38940 n1_M2_67020_38940 0.988200
R4382 n1_M2_67020_38940 n1_M2_68100_38940 0.988200
R4383 n1_M2_68100_38940 n1_M2_69180_38940 0.988200
R4384 n1_M2_69180_38940 n1_M2_70260_38940 0.988200
R4385 n1_M2_70260_38940 n1_M2_71340_38940 0.988200
R4386 n1_M2_71340_38940 n1_M2_72420_38940 0.988200
R4387 n1_M2_72420_38940 n1_M2_73500_38940 0.988200
R4388 n1_M2_73500_38940 n1_M2_74580_38940 0.988200
R4389 n1_M2_74580_38940 n1_M2_75660_38940 0.988200
R4390 n1_M2_75660_38940 n1_M2_76740_38940 0.988200
R4391 n1_M2_76740_38940 n1_M2_77820_38940 0.988200
R4392 n1_M2_77820_38940 n1_M2_78900_38940 0.988200
R4393 n1_M2_78900_38940 n1_M2_79980_38940 0.988200
R4394 n1_M2_79980_38940 n1_M2_81060_38940 0.988200
R4395 n1_M2_81060_38940 n1_M2_82140_38940 0.988200
R4396 n1_M2_82140_38940 n1_M2_83220_38940 0.988200
R4397 n1_M2_83220_38940 n1_M2_84300_38940 0.988200
R4398 n1_M2_84300_38940 n1_M2_85380_38940 0.988200
R4399 n1_M2_85380_38940 n1_M2_86460_38940 0.988200
R4400 n1_M2_86460_38940 n1_M2_87540_38940 0.988200
R4401 n1_M2_87540_38940 n1_M2_88620_38940 0.988200
R4402 n1_M2_88620_38940 n1_M2_89700_38940 0.988200
R4403 n1_M2_89700_38940 n1_M2_90780_38940 0.988200
R4404 n1_M2_90780_38940 n1_M2_91860_38940 0.988200
R4405 n1_M2_91860_38940 n1_M2_92940_38940 0.988200
R4406 n1_M2_92940_38940 n1_M2_94020_38940 0.988200
R4407 n1_M2_94020_38940 n1_M2_95100_38940 0.988200
R4408 n1_M2_95100_38940 n1_M2_96180_38940 0.988200
R4409 n1_M2_96180_38940 n1_M2_97260_38940 0.988200
R4410 n1_M2_97260_38940 n1_M2_98340_38940 0.988200
R4411 n1_M2_98340_38940 n1_M2_99420_38940 0.988200
R4412 n1_M2_99420_38940 n1_M2_100500_38940 0.988200
R4413 n1_M2_100500_38940 n1_M2_101580_38940 0.988200
R4414 n1_M2_101580_38940 n1_M2_102660_38940 0.988200
R4415 n1_M2_102660_38940 n1_M2_103740_38940 0.988200
R4416 n1_M2_103740_38940 n1_M2_104820_38940 0.988200
R4417 n1_M2_104820_38940 n1_M2_105900_38940 0.988200
R4418 n1_M2_105900_38940 n1_M2_106980_38940 0.988200
R4419 n1_M2_106980_38940 n1_M2_108060_38940 0.988200
R4420 n1_M2_108060_38940 n1_M2_109140_38940 0.988200
R4421 n1_M2_109140_38940 n1_M2_110220_38940 0.988200
R4422 n1_M2_110220_38940 n1_M2_111300_38940 0.988200
R4423 n1_M2_111300_38940 n1_M2_112380_38940 0.988200
R4424 n1_M2_112380_38940 n1_M2_113460_38940 0.988200
R4425 n1_M2_113460_38940 n1_M2_114540_38940 0.988200
R4426 n1_M2_114540_38940 n1_M2_115620_38940 0.988200
R4427 n1_M2_115620_38940 n1_M2_116700_38940 0.988200
R4428 n1_M2_116700_38940 n1_M2_117780_38940 0.988200
R4429 n1_M2_117780_38940 n1_M2_118860_38940 0.988200
R4430 n1_M2_118860_38940 n1_M2_119940_38940 0.988200
R4431 n1_M2_119940_38940 n1_M2_121020_38940 0.988200
R4432 n1_M2_121020_38940 n1_M2_122100_38940 0.988200
R4433 n1_M2_122100_38940 n1_M2_123180_38940 0.988200
R4434 n1_M2_123180_38940 n1_M2_124260_38940 0.988200
R4435 n1_M2_124260_38940 n1_M2_125340_38940 0.988200
R4436 n1_M2_125340_38940 n1_M2_126420_38940 0.988200
R4437 n1_M2_126420_38940 n1_M2_127500_38940 0.988200
R4438 n1_M2_127500_38940 n1_M2_128580_38940 0.988200
R4439 n1_M2_128580_38940 n1_M2_129660_38940 0.988200
R4440 n1_M2_60_40020 n1_M2_1140_40020 0.988200
R4441 n1_M2_1140_40020 n1_M2_2220_40020 0.988200
R4442 n1_M2_2220_40020 n1_M2_3300_40020 0.988200
R4443 n1_M2_3300_40020 n1_M2_4380_40020 0.988200
R4444 n1_M2_4380_40020 n1_M2_5460_40020 0.988200
R4445 n1_M2_5460_40020 n1_M2_6540_40020 0.988200
R4446 n1_M2_6540_40020 n1_M2_7620_40020 0.988200
R4447 n1_M2_7620_40020 n1_M2_8700_40020 0.988200
R4448 n1_M2_8700_40020 n1_M2_9780_40020 0.988200
R4449 n1_M2_9780_40020 n1_M2_10860_40020 0.988200
R4450 n1_M2_10860_40020 n1_M2_11940_40020 0.988200
R4451 n1_M2_11940_40020 n1_M2_13020_40020 0.988200
R4452 n1_M2_13020_40020 n1_M2_14100_40020 0.988200
R4453 n1_M2_14100_40020 n1_M2_15180_40020 0.988200
R4454 n1_M2_15180_40020 n1_M2_16260_40020 0.988200
R4455 n1_M2_16260_40020 n1_M2_17340_40020 0.988200
R4456 n1_M2_17340_40020 n1_M2_18420_40020 0.988200
R4457 n1_M2_18420_40020 n1_M2_19500_40020 0.988200
R4458 n1_M2_19500_40020 n1_M2_20580_40020 0.988200
R4459 n1_M2_20580_40020 n1_M2_21660_40020 0.988200
R4460 n1_M2_21660_40020 n1_M2_22740_40020 0.988200
R4461 n1_M2_22740_40020 n1_M2_23820_40020 0.988200
R4462 n1_M2_23820_40020 n1_M2_24900_40020 0.988200
R4463 n1_M2_24900_40020 n1_M2_25980_40020 0.988200
R4464 n1_M2_25980_40020 n1_M2_27060_40020 0.988200
R4465 n1_M2_27060_40020 n1_M2_28140_40020 0.988200
R4466 n1_M2_28140_40020 n1_M2_29220_40020 0.988200
R4467 n1_M2_29220_40020 n1_M2_30300_40020 0.988200
R4468 n1_M2_30300_40020 n1_M2_31380_40020 0.988200
R4469 n1_M2_31380_40020 n1_M2_32460_40020 0.988200
R4470 n1_M2_32460_40020 n1_M2_33540_40020 0.988200
R4471 n1_M2_33540_40020 n1_M2_34620_40020 0.988200
R4472 n1_M2_34620_40020 n1_M2_35700_40020 0.988200
R4473 n1_M2_35700_40020 n1_M2_36780_40020 0.988200
R4474 n1_M2_36780_40020 n1_M2_37860_40020 0.988200
R4475 n1_M2_37860_40020 n1_M2_38940_40020 0.988200
R4476 n1_M2_38940_40020 n1_M2_40020_40020 0.988200
R4477 n1_M2_40020_40020 n1_M2_41100_40020 0.988200
R4478 n1_M2_41100_40020 n1_M2_42180_40020 0.988200
R4479 n1_M2_42180_40020 n1_M2_43260_40020 0.988200
R4480 n1_M2_43260_40020 n1_M2_44340_40020 0.988200
R4481 n1_M2_44340_40020 n1_M2_45420_40020 0.988200
R4482 n1_M2_45420_40020 n1_M2_46500_40020 0.988200
R4483 n1_M2_46500_40020 n1_M2_47580_40020 0.988200
R4484 n1_M2_47580_40020 n1_M2_48660_40020 0.988200
R4485 n1_M2_48660_40020 n1_M2_49740_40020 0.988200
R4486 n1_M2_49740_40020 n1_M2_50820_40020 0.988200
R4487 n1_M2_50820_40020 n1_M2_51900_40020 0.988200
R4488 n1_M2_51900_40020 n1_M2_52980_40020 0.988200
R4489 n1_M2_52980_40020 n1_M2_54060_40020 0.988200
R4490 n1_M2_54060_40020 n1_M2_55140_40020 0.988200
R4491 n1_M2_55140_40020 n1_M2_56220_40020 0.988200
R4492 n1_M2_56220_40020 n1_M2_57300_40020 0.988200
R4493 n1_M2_57300_40020 n1_M2_58380_40020 0.988200
R4494 n1_M2_58380_40020 n1_M2_59460_40020 0.988200
R4495 n1_M2_59460_40020 n1_M2_60540_40020 0.988200
R4496 n1_M2_60540_40020 n1_M2_61620_40020 0.988200
R4497 n1_M2_61620_40020 n1_M2_62700_40020 0.988200
R4498 n1_M2_62700_40020 n1_M2_63780_40020 0.988200
R4499 n1_M2_63780_40020 n1_M2_64860_40020 0.988200
R4500 n1_M2_64860_40020 n1_M2_65940_40020 0.988200
R4501 n1_M2_65940_40020 n1_M2_67020_40020 0.988200
R4502 n1_M2_67020_40020 n1_M2_68100_40020 0.988200
R4503 n1_M2_68100_40020 n1_M2_69180_40020 0.988200
R4504 n1_M2_69180_40020 n1_M2_70260_40020 0.988200
R4505 n1_M2_70260_40020 n1_M2_71340_40020 0.988200
R4506 n1_M2_71340_40020 n1_M2_72420_40020 0.988200
R4507 n1_M2_72420_40020 n1_M2_73500_40020 0.988200
R4508 n1_M2_73500_40020 n1_M2_74580_40020 0.988200
R4509 n1_M2_74580_40020 n1_M2_75660_40020 0.988200
R4510 n1_M2_75660_40020 n1_M2_76740_40020 0.988200
R4511 n1_M2_76740_40020 n1_M2_77820_40020 0.988200
R4512 n1_M2_77820_40020 n1_M2_78900_40020 0.988200
R4513 n1_M2_78900_40020 n1_M2_79980_40020 0.988200
R4514 n1_M2_79980_40020 n1_M2_81060_40020 0.988200
R4515 n1_M2_81060_40020 n1_M2_82140_40020 0.988200
R4516 n1_M2_82140_40020 n1_M2_83220_40020 0.988200
R4517 n1_M2_83220_40020 n1_M2_84300_40020 0.988200
R4518 n1_M2_84300_40020 n1_M2_85380_40020 0.988200
R4519 n1_M2_85380_40020 n1_M2_86460_40020 0.988200
R4520 n1_M2_86460_40020 n1_M2_87540_40020 0.988200
R4521 n1_M2_87540_40020 n1_M2_88620_40020 0.988200
R4522 n1_M2_88620_40020 n1_M2_89700_40020 0.988200
R4523 n1_M2_89700_40020 n1_M2_90780_40020 0.988200
R4524 n1_M2_90780_40020 n1_M2_91860_40020 0.988200
R4525 n1_M2_91860_40020 n1_M2_92940_40020 0.988200
R4526 n1_M2_92940_40020 n1_M2_94020_40020 0.988200
R4527 n1_M2_94020_40020 n1_M2_95100_40020 0.988200
R4528 n1_M2_95100_40020 n1_M2_96180_40020 0.988200
R4529 n1_M2_96180_40020 n1_M2_97260_40020 0.988200
R4530 n1_M2_97260_40020 n1_M2_98340_40020 0.988200
R4531 n1_M2_98340_40020 n1_M2_99420_40020 0.988200
R4532 n1_M2_99420_40020 n1_M2_100500_40020 0.988200
R4533 n1_M2_100500_40020 n1_M2_101580_40020 0.988200
R4534 n1_M2_101580_40020 n1_M2_102660_40020 0.988200
R4535 n1_M2_102660_40020 n1_M2_103740_40020 0.988200
R4536 n1_M2_103740_40020 n1_M2_104820_40020 0.988200
R4537 n1_M2_104820_40020 n1_M2_105900_40020 0.988200
R4538 n1_M2_105900_40020 n1_M2_106980_40020 0.988200
R4539 n1_M2_106980_40020 n1_M2_108060_40020 0.988200
R4540 n1_M2_108060_40020 n1_M2_109140_40020 0.988200
R4541 n1_M2_109140_40020 n1_M2_110220_40020 0.988200
R4542 n1_M2_110220_40020 n1_M2_111300_40020 0.988200
R4543 n1_M2_111300_40020 n1_M2_112380_40020 0.988200
R4544 n1_M2_112380_40020 n1_M2_113460_40020 0.988200
R4545 n1_M2_113460_40020 n1_M2_114540_40020 0.988200
R4546 n1_M2_114540_40020 n1_M2_115620_40020 0.988200
R4547 n1_M2_115620_40020 n1_M2_116700_40020 0.988200
R4548 n1_M2_116700_40020 n1_M2_117780_40020 0.988200
R4549 n1_M2_117780_40020 n1_M2_118860_40020 0.988200
R4550 n1_M2_118860_40020 n1_M2_119940_40020 0.988200
R4551 n1_M2_119940_40020 n1_M2_121020_40020 0.988200
R4552 n1_M2_121020_40020 n1_M2_122100_40020 0.988200
R4553 n1_M2_122100_40020 n1_M2_123180_40020 0.988200
R4554 n1_M2_123180_40020 n1_M2_124260_40020 0.988200
R4555 n1_M2_124260_40020 n1_M2_125340_40020 0.988200
R4556 n1_M2_125340_40020 n1_M2_126420_40020 0.988200
R4557 n1_M2_126420_40020 n1_M2_127500_40020 0.988200
R4558 n1_M2_127500_40020 n1_M2_128580_40020 0.988200
R4559 n1_M2_128580_40020 n1_M2_129660_40020 0.988200
R4560 n1_M2_60_41100 n1_M2_1140_41100 0.988200
R4561 n1_M2_1140_41100 n1_M2_2220_41100 0.988200
R4562 n1_M2_2220_41100 n1_M2_3300_41100 0.988200
R4563 n1_M2_3300_41100 n1_M2_4380_41100 0.988200
R4564 n1_M2_4380_41100 n1_M2_5460_41100 0.988200
R4565 n1_M2_5460_41100 n1_M2_6540_41100 0.988200
R4566 n1_M2_6540_41100 n1_M2_7620_41100 0.988200
R4567 n1_M2_7620_41100 n1_M2_8700_41100 0.988200
R4568 n1_M2_8700_41100 n1_M2_9780_41100 0.988200
R4569 n1_M2_9780_41100 n1_M2_10860_41100 0.988200
R4570 n1_M2_10860_41100 n1_M2_11940_41100 0.988200
R4571 n1_M2_11940_41100 n1_M2_13020_41100 0.988200
R4572 n1_M2_13020_41100 n1_M2_14100_41100 0.988200
R4573 n1_M2_14100_41100 n1_M2_15180_41100 0.988200
R4574 n1_M2_15180_41100 n1_M2_16260_41100 0.988200
R4575 n1_M2_16260_41100 n1_M2_17340_41100 0.988200
R4576 n1_M2_17340_41100 n1_M2_18420_41100 0.988200
R4577 n1_M2_18420_41100 n1_M2_19500_41100 0.988200
R4578 n1_M2_19500_41100 n1_M2_20580_41100 0.988200
R4579 n1_M2_20580_41100 n1_M2_21660_41100 0.988200
R4580 n1_M2_21660_41100 n1_M2_22740_41100 0.988200
R4581 n1_M2_22740_41100 n1_M2_23820_41100 0.988200
R4582 n1_M2_23820_41100 n1_M2_24900_41100 0.988200
R4583 n1_M2_24900_41100 n1_M2_25980_41100 0.988200
R4584 n1_M2_25980_41100 n1_M2_27060_41100 0.988200
R4585 n1_M2_27060_41100 n1_M2_28140_41100 0.988200
R4586 n1_M2_28140_41100 n1_M2_29220_41100 0.988200
R4587 n1_M2_29220_41100 n1_M2_30300_41100 0.988200
R4588 n1_M2_30300_41100 n1_M2_31380_41100 0.988200
R4589 n1_M2_31380_41100 n1_M2_32460_41100 0.988200
R4590 n1_M2_32460_41100 n1_M2_33540_41100 0.988200
R4591 n1_M2_33540_41100 n1_M2_34620_41100 0.988200
R4592 n1_M2_34620_41100 n1_M2_35700_41100 0.988200
R4593 n1_M2_35700_41100 n1_M2_36780_41100 0.988200
R4594 n1_M2_36780_41100 n1_M2_37860_41100 0.988200
R4595 n1_M2_37860_41100 n1_M2_38940_41100 0.988200
R4596 n1_M2_38940_41100 n1_M2_40020_41100 0.988200
R4597 n1_M2_40020_41100 n1_M2_41100_41100 0.988200
R4598 n1_M2_41100_41100 n1_M2_42180_41100 0.988200
R4599 n1_M2_42180_41100 n1_M2_43260_41100 0.988200
R4600 n1_M2_43260_41100 n1_M2_44340_41100 0.988200
R4601 n1_M2_44340_41100 n1_M2_45420_41100 0.988200
R4602 n1_M2_45420_41100 n1_M2_46500_41100 0.988200
R4603 n1_M2_46500_41100 n1_M2_47580_41100 0.988200
R4604 n1_M2_47580_41100 n1_M2_48660_41100 0.988200
R4605 n1_M2_48660_41100 n1_M2_49740_41100 0.988200
R4606 n1_M2_49740_41100 n1_M2_50820_41100 0.988200
R4607 n1_M2_50820_41100 n1_M2_51900_41100 0.988200
R4608 n1_M2_51900_41100 n1_M2_52980_41100 0.988200
R4609 n1_M2_52980_41100 n1_M2_54060_41100 0.988200
R4610 n1_M2_54060_41100 n1_M2_55140_41100 0.988200
R4611 n1_M2_55140_41100 n1_M2_56220_41100 0.988200
R4612 n1_M2_56220_41100 n1_M2_57300_41100 0.988200
R4613 n1_M2_57300_41100 n1_M2_58380_41100 0.988200
R4614 n1_M2_58380_41100 n1_M2_59460_41100 0.988200
R4615 n1_M2_59460_41100 n1_M2_60540_41100 0.988200
R4616 n1_M2_60540_41100 n1_M2_61620_41100 0.988200
R4617 n1_M2_61620_41100 n1_M2_62700_41100 0.988200
R4618 n1_M2_62700_41100 n1_M2_63780_41100 0.988200
R4619 n1_M2_63780_41100 n1_M2_64860_41100 0.988200
R4620 n1_M2_64860_41100 n1_M2_65940_41100 0.988200
R4621 n1_M2_65940_41100 n1_M2_67020_41100 0.988200
R4622 n1_M2_67020_41100 n1_M2_68100_41100 0.988200
R4623 n1_M2_68100_41100 n1_M2_69180_41100 0.988200
R4624 n1_M2_69180_41100 n1_M2_70260_41100 0.988200
R4625 n1_M2_70260_41100 n1_M2_71340_41100 0.988200
R4626 n1_M2_71340_41100 n1_M2_72420_41100 0.988200
R4627 n1_M2_72420_41100 n1_M2_73500_41100 0.988200
R4628 n1_M2_73500_41100 n1_M2_74580_41100 0.988200
R4629 n1_M2_74580_41100 n1_M2_75660_41100 0.988200
R4630 n1_M2_75660_41100 n1_M2_76740_41100 0.988200
R4631 n1_M2_76740_41100 n1_M2_77820_41100 0.988200
R4632 n1_M2_77820_41100 n1_M2_78900_41100 0.988200
R4633 n1_M2_78900_41100 n1_M2_79980_41100 0.988200
R4634 n1_M2_79980_41100 n1_M2_81060_41100 0.988200
R4635 n1_M2_81060_41100 n1_M2_82140_41100 0.988200
R4636 n1_M2_82140_41100 n1_M2_83220_41100 0.988200
R4637 n1_M2_83220_41100 n1_M2_84300_41100 0.988200
R4638 n1_M2_84300_41100 n1_M2_85380_41100 0.988200
R4639 n1_M2_85380_41100 n1_M2_86460_41100 0.988200
R4640 n1_M2_86460_41100 n1_M2_87540_41100 0.988200
R4641 n1_M2_87540_41100 n1_M2_88620_41100 0.988200
R4642 n1_M2_88620_41100 n1_M2_89700_41100 0.988200
R4643 n1_M2_89700_41100 n1_M2_90780_41100 0.988200
R4644 n1_M2_90780_41100 n1_M2_91860_41100 0.988200
R4645 n1_M2_91860_41100 n1_M2_92940_41100 0.988200
R4646 n1_M2_92940_41100 n1_M2_94020_41100 0.988200
R4647 n1_M2_94020_41100 n1_M2_95100_41100 0.988200
R4648 n1_M2_95100_41100 n1_M2_96180_41100 0.988200
R4649 n1_M2_96180_41100 n1_M2_97260_41100 0.988200
R4650 n1_M2_97260_41100 n1_M2_98340_41100 0.988200
R4651 n1_M2_98340_41100 n1_M2_99420_41100 0.988200
R4652 n1_M2_99420_41100 n1_M2_100500_41100 0.988200
R4653 n1_M2_100500_41100 n1_M2_101580_41100 0.988200
R4654 n1_M2_101580_41100 n1_M2_102660_41100 0.988200
R4655 n1_M2_102660_41100 n1_M2_103740_41100 0.988200
R4656 n1_M2_103740_41100 n1_M2_104820_41100 0.988200
R4657 n1_M2_104820_41100 n1_M2_105900_41100 0.988200
R4658 n1_M2_105900_41100 n1_M2_106980_41100 0.988200
R4659 n1_M2_106980_41100 n1_M2_108060_41100 0.988200
R4660 n1_M2_108060_41100 n1_M2_109140_41100 0.988200
R4661 n1_M2_109140_41100 n1_M2_110220_41100 0.988200
R4662 n1_M2_110220_41100 n1_M2_111300_41100 0.988200
R4663 n1_M2_111300_41100 n1_M2_112380_41100 0.988200
R4664 n1_M2_112380_41100 n1_M2_113460_41100 0.988200
R4665 n1_M2_113460_41100 n1_M2_114540_41100 0.988200
R4666 n1_M2_114540_41100 n1_M2_115620_41100 0.988200
R4667 n1_M2_115620_41100 n1_M2_116700_41100 0.988200
R4668 n1_M2_116700_41100 n1_M2_117780_41100 0.988200
R4669 n1_M2_117780_41100 n1_M2_118860_41100 0.988200
R4670 n1_M2_118860_41100 n1_M2_119940_41100 0.988200
R4671 n1_M2_119940_41100 n1_M2_121020_41100 0.988200
R4672 n1_M2_121020_41100 n1_M2_122100_41100 0.988200
R4673 n1_M2_122100_41100 n1_M2_123180_41100 0.988200
R4674 n1_M2_123180_41100 n1_M2_124260_41100 0.988200
R4675 n1_M2_124260_41100 n1_M2_125340_41100 0.988200
R4676 n1_M2_125340_41100 n1_M2_126420_41100 0.988200
R4677 n1_M2_126420_41100 n1_M2_127500_41100 0.988200
R4678 n1_M2_127500_41100 n1_M2_128580_41100 0.988200
R4679 n1_M2_128580_41100 n1_M2_129660_41100 0.988200
R4680 n1_M2_60_42180 n1_M2_1140_42180 0.988200
R4681 n1_M2_1140_42180 n1_M2_2220_42180 0.988200
R4682 n1_M2_2220_42180 n1_M2_3300_42180 0.988200
R4683 n1_M2_3300_42180 n1_M2_4380_42180 0.988200
R4684 n1_M2_4380_42180 n1_M2_5460_42180 0.988200
R4685 n1_M2_5460_42180 n1_M2_6540_42180 0.988200
R4686 n1_M2_6540_42180 n1_M2_7620_42180 0.988200
R4687 n1_M2_7620_42180 n1_M2_8700_42180 0.988200
R4688 n1_M2_8700_42180 n1_M2_9780_42180 0.988200
R4689 n1_M2_9780_42180 n1_M2_10860_42180 0.988200
R4690 n1_M2_10860_42180 n1_M2_11940_42180 0.988200
R4691 n1_M2_11940_42180 n1_M2_13020_42180 0.988200
R4692 n1_M2_13020_42180 n1_M2_14100_42180 0.988200
R4693 n1_M2_14100_42180 n1_M2_15180_42180 0.988200
R4694 n1_M2_15180_42180 n1_M2_16260_42180 0.988200
R4695 n1_M2_16260_42180 n1_M2_17340_42180 0.988200
R4696 n1_M2_17340_42180 n1_M2_18420_42180 0.988200
R4697 n1_M2_18420_42180 n1_M2_19500_42180 0.988200
R4698 n1_M2_19500_42180 n1_M2_20580_42180 0.988200
R4699 n1_M2_20580_42180 n1_M2_21660_42180 0.988200
R4700 n1_M2_21660_42180 n1_M2_22740_42180 0.988200
R4701 n1_M2_22740_42180 n1_M2_23820_42180 0.988200
R4702 n1_M2_23820_42180 n1_M2_24900_42180 0.988200
R4703 n1_M2_24900_42180 n1_M2_25980_42180 0.988200
R4704 n1_M2_25980_42180 n1_M2_27060_42180 0.988200
R4705 n1_M2_27060_42180 n1_M2_28140_42180 0.988200
R4706 n1_M2_28140_42180 n1_M2_29220_42180 0.988200
R4707 n1_M2_29220_42180 n1_M2_30300_42180 0.988200
R4708 n1_M2_30300_42180 n1_M2_31380_42180 0.988200
R4709 n1_M2_31380_42180 n1_M2_32460_42180 0.988200
R4710 n1_M2_32460_42180 n1_M2_33540_42180 0.988200
R4711 n1_M2_33540_42180 n1_M2_34620_42180 0.988200
R4712 n1_M2_34620_42180 n1_M2_35700_42180 0.988200
R4713 n1_M2_35700_42180 n1_M2_36780_42180 0.988200
R4714 n1_M2_36780_42180 n1_M2_37860_42180 0.988200
R4715 n1_M2_37860_42180 n1_M2_38940_42180 0.988200
R4716 n1_M2_38940_42180 n1_M2_40020_42180 0.988200
R4717 n1_M2_40020_42180 n1_M2_41100_42180 0.988200
R4718 n1_M2_41100_42180 n1_M2_42180_42180 0.988200
R4719 n1_M2_42180_42180 n1_M2_43260_42180 0.988200
R4720 n1_M2_43260_42180 n1_M2_44340_42180 0.988200
R4721 n1_M2_44340_42180 n1_M2_45420_42180 0.988200
R4722 n1_M2_45420_42180 n1_M2_46500_42180 0.988200
R4723 n1_M2_46500_42180 n1_M2_47580_42180 0.988200
R4724 n1_M2_47580_42180 n1_M2_48660_42180 0.988200
R4725 n1_M2_48660_42180 n1_M2_49740_42180 0.988200
R4726 n1_M2_49740_42180 n1_M2_50820_42180 0.988200
R4727 n1_M2_50820_42180 n1_M2_51900_42180 0.988200
R4728 n1_M2_51900_42180 n1_M2_52980_42180 0.988200
R4729 n1_M2_52980_42180 n1_M2_54060_42180 0.988200
R4730 n1_M2_54060_42180 n1_M2_55140_42180 0.988200
R4731 n1_M2_55140_42180 n1_M2_56220_42180 0.988200
R4732 n1_M2_56220_42180 n1_M2_57300_42180 0.988200
R4733 n1_M2_57300_42180 n1_M2_58380_42180 0.988200
R4734 n1_M2_58380_42180 n1_M2_59460_42180 0.988200
R4735 n1_M2_59460_42180 n1_M2_60540_42180 0.988200
R4736 n1_M2_60540_42180 n1_M2_61620_42180 0.988200
R4737 n1_M2_61620_42180 n1_M2_62700_42180 0.988200
R4738 n1_M2_62700_42180 n1_M2_63780_42180 0.988200
R4739 n1_M2_63780_42180 n1_M2_64860_42180 0.988200
R4740 n1_M2_64860_42180 n1_M2_65940_42180 0.988200
R4741 n1_M2_65940_42180 n1_M2_67020_42180 0.988200
R4742 n1_M2_67020_42180 n1_M2_68100_42180 0.988200
R4743 n1_M2_68100_42180 n1_M2_69180_42180 0.988200
R4744 n1_M2_69180_42180 n1_M2_70260_42180 0.988200
R4745 n1_M2_70260_42180 n1_M2_71340_42180 0.988200
R4746 n1_M2_71340_42180 n1_M2_72420_42180 0.988200
R4747 n1_M2_72420_42180 n1_M2_73500_42180 0.988200
R4748 n1_M2_73500_42180 n1_M2_74580_42180 0.988200
R4749 n1_M2_74580_42180 n1_M2_75660_42180 0.988200
R4750 n1_M2_75660_42180 n1_M2_76740_42180 0.988200
R4751 n1_M2_76740_42180 n1_M2_77820_42180 0.988200
R4752 n1_M2_77820_42180 n1_M2_78900_42180 0.988200
R4753 n1_M2_78900_42180 n1_M2_79980_42180 0.988200
R4754 n1_M2_79980_42180 n1_M2_81060_42180 0.988200
R4755 n1_M2_81060_42180 n1_M2_82140_42180 0.988200
R4756 n1_M2_82140_42180 n1_M2_83220_42180 0.988200
R4757 n1_M2_83220_42180 n1_M2_84300_42180 0.988200
R4758 n1_M2_84300_42180 n1_M2_85380_42180 0.988200
R4759 n1_M2_85380_42180 n1_M2_86460_42180 0.988200
R4760 n1_M2_86460_42180 n1_M2_87540_42180 0.988200
R4761 n1_M2_87540_42180 n1_M2_88620_42180 0.988200
R4762 n1_M2_88620_42180 n1_M2_89700_42180 0.988200
R4763 n1_M2_89700_42180 n1_M2_90780_42180 0.988200
R4764 n1_M2_90780_42180 n1_M2_91860_42180 0.988200
R4765 n1_M2_91860_42180 n1_M2_92940_42180 0.988200
R4766 n1_M2_92940_42180 n1_M2_94020_42180 0.988200
R4767 n1_M2_94020_42180 n1_M2_95100_42180 0.988200
R4768 n1_M2_95100_42180 n1_M2_96180_42180 0.988200
R4769 n1_M2_96180_42180 n1_M2_97260_42180 0.988200
R4770 n1_M2_97260_42180 n1_M2_98340_42180 0.988200
R4771 n1_M2_98340_42180 n1_M2_99420_42180 0.988200
R4772 n1_M2_99420_42180 n1_M2_100500_42180 0.988200
R4773 n1_M2_100500_42180 n1_M2_101580_42180 0.988200
R4774 n1_M2_101580_42180 n1_M2_102660_42180 0.988200
R4775 n1_M2_102660_42180 n1_M2_103740_42180 0.988200
R4776 n1_M2_103740_42180 n1_M2_104820_42180 0.988200
R4777 n1_M2_104820_42180 n1_M2_105900_42180 0.988200
R4778 n1_M2_105900_42180 n1_M2_106980_42180 0.988200
R4779 n1_M2_106980_42180 n1_M2_108060_42180 0.988200
R4780 n1_M2_108060_42180 n1_M2_109140_42180 0.988200
R4781 n1_M2_109140_42180 n1_M2_110220_42180 0.988200
R4782 n1_M2_110220_42180 n1_M2_111300_42180 0.988200
R4783 n1_M2_111300_42180 n1_M2_112380_42180 0.988200
R4784 n1_M2_112380_42180 n1_M2_113460_42180 0.988200
R4785 n1_M2_113460_42180 n1_M2_114540_42180 0.988200
R4786 n1_M2_114540_42180 n1_M2_115620_42180 0.988200
R4787 n1_M2_115620_42180 n1_M2_116700_42180 0.988200
R4788 n1_M2_116700_42180 n1_M2_117780_42180 0.988200
R4789 n1_M2_117780_42180 n1_M2_118860_42180 0.988200
R4790 n1_M2_118860_42180 n1_M2_119940_42180 0.988200
R4791 n1_M2_119940_42180 n1_M2_121020_42180 0.988200
R4792 n1_M2_121020_42180 n1_M2_122100_42180 0.988200
R4793 n1_M2_122100_42180 n1_M2_123180_42180 0.988200
R4794 n1_M2_123180_42180 n1_M2_124260_42180 0.988200
R4795 n1_M2_124260_42180 n1_M2_125340_42180 0.988200
R4796 n1_M2_125340_42180 n1_M2_126420_42180 0.988200
R4797 n1_M2_126420_42180 n1_M2_127500_42180 0.988200
R4798 n1_M2_127500_42180 n1_M2_128580_42180 0.988200
R4799 n1_M2_128580_42180 n1_M2_129660_42180 0.988200
R4800 n1_M2_60_43260 n1_M2_1140_43260 0.988200
R4801 n1_M2_1140_43260 n1_M2_2220_43260 0.988200
R4802 n1_M2_2220_43260 n1_M2_3300_43260 0.988200
R4803 n1_M2_3300_43260 n1_M2_4380_43260 0.988200
R4804 n1_M2_4380_43260 n1_M2_5460_43260 0.988200
R4805 n1_M2_5460_43260 n1_M2_6540_43260 0.988200
R4806 n1_M2_6540_43260 n1_M2_7620_43260 0.988200
R4807 n1_M2_7620_43260 n1_M2_8700_43260 0.988200
R4808 n1_M2_8700_43260 n1_M2_9780_43260 0.988200
R4809 n1_M2_9780_43260 n1_M2_10860_43260 0.988200
R4810 n1_M2_10860_43260 n1_M2_11940_43260 0.988200
R4811 n1_M2_11940_43260 n1_M2_13020_43260 0.988200
R4812 n1_M2_13020_43260 n1_M2_14100_43260 0.988200
R4813 n1_M2_14100_43260 n1_M2_15180_43260 0.988200
R4814 n1_M2_15180_43260 n1_M2_16260_43260 0.988200
R4815 n1_M2_16260_43260 n1_M2_17340_43260 0.988200
R4816 n1_M2_17340_43260 n1_M2_18420_43260 0.988200
R4817 n1_M2_18420_43260 n1_M2_19500_43260 0.988200
R4818 n1_M2_19500_43260 n1_M2_20580_43260 0.988200
R4819 n1_M2_20580_43260 n1_M2_21660_43260 0.988200
R4820 n1_M2_21660_43260 n1_M2_22740_43260 0.988200
R4821 n1_M2_22740_43260 n1_M2_23820_43260 0.988200
R4822 n1_M2_23820_43260 n1_M2_24900_43260 0.988200
R4823 n1_M2_24900_43260 n1_M2_25980_43260 0.988200
R4824 n1_M2_25980_43260 n1_M2_27060_43260 0.988200
R4825 n1_M2_27060_43260 n1_M2_28140_43260 0.988200
R4826 n1_M2_28140_43260 n1_M2_29220_43260 0.988200
R4827 n1_M2_29220_43260 n1_M2_30300_43260 0.988200
R4828 n1_M2_30300_43260 n1_M2_31380_43260 0.988200
R4829 n1_M2_31380_43260 n1_M2_32460_43260 0.988200
R4830 n1_M2_32460_43260 n1_M2_33540_43260 0.988200
R4831 n1_M2_33540_43260 n1_M2_34620_43260 0.988200
R4832 n1_M2_34620_43260 n1_M2_35700_43260 0.988200
R4833 n1_M2_35700_43260 n1_M2_36780_43260 0.988200
R4834 n1_M2_36780_43260 n1_M2_37860_43260 0.988200
R4835 n1_M2_37860_43260 n1_M2_38940_43260 0.988200
R4836 n1_M2_38940_43260 n1_M2_40020_43260 0.988200
R4837 n1_M2_40020_43260 n1_M2_41100_43260 0.988200
R4838 n1_M2_41100_43260 n1_M2_42180_43260 0.988200
R4839 n1_M2_42180_43260 n1_M2_43260_43260 0.988200
R4840 n1_M2_43260_43260 n1_M2_44340_43260 0.988200
R4841 n1_M2_44340_43260 n1_M2_45420_43260 0.988200
R4842 n1_M2_45420_43260 n1_M2_46500_43260 0.988200
R4843 n1_M2_46500_43260 n1_M2_47580_43260 0.988200
R4844 n1_M2_47580_43260 n1_M2_48660_43260 0.988200
R4845 n1_M2_48660_43260 n1_M2_49740_43260 0.988200
R4846 n1_M2_49740_43260 n1_M2_50820_43260 0.988200
R4847 n1_M2_50820_43260 n1_M2_51900_43260 0.988200
R4848 n1_M2_51900_43260 n1_M2_52980_43260 0.988200
R4849 n1_M2_52980_43260 n1_M2_54060_43260 0.988200
R4850 n1_M2_54060_43260 n1_M2_55140_43260 0.988200
R4851 n1_M2_55140_43260 n1_M2_56220_43260 0.988200
R4852 n1_M2_56220_43260 n1_M2_57300_43260 0.988200
R4853 n1_M2_57300_43260 n1_M2_58380_43260 0.988200
R4854 n1_M2_58380_43260 n1_M2_59460_43260 0.988200
R4855 n1_M2_59460_43260 n1_M2_60540_43260 0.988200
R4856 n1_M2_60540_43260 n1_M2_61620_43260 0.988200
R4857 n1_M2_61620_43260 n1_M2_62700_43260 0.988200
R4858 n1_M2_62700_43260 n1_M2_63780_43260 0.988200
R4859 n1_M2_63780_43260 n1_M2_64860_43260 0.988200
R4860 n1_M2_64860_43260 n1_M2_65940_43260 0.988200
R4861 n1_M2_65940_43260 n1_M2_67020_43260 0.988200
R4862 n1_M2_67020_43260 n1_M2_68100_43260 0.988200
R4863 n1_M2_68100_43260 n1_M2_69180_43260 0.988200
R4864 n1_M2_69180_43260 n1_M2_70260_43260 0.988200
R4865 n1_M2_70260_43260 n1_M2_71340_43260 0.988200
R4866 n1_M2_71340_43260 n1_M2_72420_43260 0.988200
R4867 n1_M2_72420_43260 n1_M2_73500_43260 0.988200
R4868 n1_M2_73500_43260 n1_M2_74580_43260 0.988200
R4869 n1_M2_74580_43260 n1_M2_75660_43260 0.988200
R4870 n1_M2_75660_43260 n1_M2_76740_43260 0.988200
R4871 n1_M2_76740_43260 n1_M2_77820_43260 0.988200
R4872 n1_M2_77820_43260 n1_M2_78900_43260 0.988200
R4873 n1_M2_78900_43260 n1_M2_79980_43260 0.988200
R4874 n1_M2_79980_43260 n1_M2_81060_43260 0.988200
R4875 n1_M2_81060_43260 n1_M2_82140_43260 0.988200
R4876 n1_M2_82140_43260 n1_M2_83220_43260 0.988200
R4877 n1_M2_83220_43260 n1_M2_84300_43260 0.988200
R4878 n1_M2_84300_43260 n1_M2_85380_43260 0.988200
R4879 n1_M2_85380_43260 n1_M2_86460_43260 0.988200
R4880 n1_M2_86460_43260 n1_M2_87540_43260 0.988200
R4881 n1_M2_87540_43260 n1_M2_88620_43260 0.988200
R4882 n1_M2_88620_43260 n1_M2_89700_43260 0.988200
R4883 n1_M2_89700_43260 n1_M2_90780_43260 0.988200
R4884 n1_M2_90780_43260 n1_M2_91860_43260 0.988200
R4885 n1_M2_91860_43260 n1_M2_92940_43260 0.988200
R4886 n1_M2_92940_43260 n1_M2_94020_43260 0.988200
R4887 n1_M2_94020_43260 n1_M2_95100_43260 0.988200
R4888 n1_M2_95100_43260 n1_M2_96180_43260 0.988200
R4889 n1_M2_96180_43260 n1_M2_97260_43260 0.988200
R4890 n1_M2_97260_43260 n1_M2_98340_43260 0.988200
R4891 n1_M2_98340_43260 n1_M2_99420_43260 0.988200
R4892 n1_M2_99420_43260 n1_M2_100500_43260 0.988200
R4893 n1_M2_100500_43260 n1_M2_101580_43260 0.988200
R4894 n1_M2_101580_43260 n1_M2_102660_43260 0.988200
R4895 n1_M2_102660_43260 n1_M2_103740_43260 0.988200
R4896 n1_M2_103740_43260 n1_M2_104820_43260 0.988200
R4897 n1_M2_104820_43260 n1_M2_105900_43260 0.988200
R4898 n1_M2_105900_43260 n1_M2_106980_43260 0.988200
R4899 n1_M2_106980_43260 n1_M2_108060_43260 0.988200
R4900 n1_M2_108060_43260 n1_M2_109140_43260 0.988200
R4901 n1_M2_109140_43260 n1_M2_110220_43260 0.988200
R4902 n1_M2_110220_43260 n1_M2_111300_43260 0.988200
R4903 n1_M2_111300_43260 n1_M2_112380_43260 0.988200
R4904 n1_M2_112380_43260 n1_M2_113460_43260 0.988200
R4905 n1_M2_113460_43260 n1_M2_114540_43260 0.988200
R4906 n1_M2_114540_43260 n1_M2_115620_43260 0.988200
R4907 n1_M2_115620_43260 n1_M2_116700_43260 0.988200
R4908 n1_M2_116700_43260 n1_M2_117780_43260 0.988200
R4909 n1_M2_117780_43260 n1_M2_118860_43260 0.988200
R4910 n1_M2_118860_43260 n1_M2_119940_43260 0.988200
R4911 n1_M2_119940_43260 n1_M2_121020_43260 0.988200
R4912 n1_M2_121020_43260 n1_M2_122100_43260 0.988200
R4913 n1_M2_122100_43260 n1_M2_123180_43260 0.988200
R4914 n1_M2_123180_43260 n1_M2_124260_43260 0.988200
R4915 n1_M2_124260_43260 n1_M2_125340_43260 0.988200
R4916 n1_M2_125340_43260 n1_M2_126420_43260 0.988200
R4917 n1_M2_126420_43260 n1_M2_127500_43260 0.988200
R4918 n1_M2_127500_43260 n1_M2_128580_43260 0.988200
R4919 n1_M2_128580_43260 n1_M2_129660_43260 0.988200
R4920 n1_M2_60_44340 n1_M2_1140_44340 0.988200
R4921 n1_M2_1140_44340 n1_M2_2220_44340 0.988200
R4922 n1_M2_2220_44340 n1_M2_3300_44340 0.988200
R4923 n1_M2_3300_44340 n1_M2_4380_44340 0.988200
R4924 n1_M2_4380_44340 n1_M2_5460_44340 0.988200
R4925 n1_M2_5460_44340 n1_M2_6540_44340 0.988200
R4926 n1_M2_6540_44340 n1_M2_7620_44340 0.988200
R4927 n1_M2_7620_44340 n1_M2_8700_44340 0.988200
R4928 n1_M2_8700_44340 n1_M2_9780_44340 0.988200
R4929 n1_M2_9780_44340 n1_M2_10860_44340 0.988200
R4930 n1_M2_10860_44340 n1_M2_11940_44340 0.988200
R4931 n1_M2_11940_44340 n1_M2_13020_44340 0.988200
R4932 n1_M2_13020_44340 n1_M2_14100_44340 0.988200
R4933 n1_M2_14100_44340 n1_M2_15180_44340 0.988200
R4934 n1_M2_15180_44340 n1_M2_16260_44340 0.988200
R4935 n1_M2_16260_44340 n1_M2_17340_44340 0.988200
R4936 n1_M2_17340_44340 n1_M2_18420_44340 0.988200
R4937 n1_M2_18420_44340 n1_M2_19500_44340 0.988200
R4938 n1_M2_19500_44340 n1_M2_20580_44340 0.988200
R4939 n1_M2_20580_44340 n1_M2_21660_44340 0.988200
R4940 n1_M2_21660_44340 n1_M2_22740_44340 0.988200
R4941 n1_M2_22740_44340 n1_M2_23820_44340 0.988200
R4942 n1_M2_23820_44340 n1_M2_24900_44340 0.988200
R4943 n1_M2_24900_44340 n1_M2_25980_44340 0.988200
R4944 n1_M2_25980_44340 n1_M2_27060_44340 0.988200
R4945 n1_M2_27060_44340 n1_M2_28140_44340 0.988200
R4946 n1_M2_28140_44340 n1_M2_29220_44340 0.988200
R4947 n1_M2_29220_44340 n1_M2_30300_44340 0.988200
R4948 n1_M2_30300_44340 n1_M2_31380_44340 0.988200
R4949 n1_M2_31380_44340 n1_M2_32460_44340 0.988200
R4950 n1_M2_32460_44340 n1_M2_33540_44340 0.988200
R4951 n1_M2_33540_44340 n1_M2_34620_44340 0.988200
R4952 n1_M2_34620_44340 n1_M2_35700_44340 0.988200
R4953 n1_M2_35700_44340 n1_M2_36780_44340 0.988200
R4954 n1_M2_36780_44340 n1_M2_37860_44340 0.988200
R4955 n1_M2_37860_44340 n1_M2_38940_44340 0.988200
R4956 n1_M2_38940_44340 n1_M2_40020_44340 0.988200
R4957 n1_M2_40020_44340 n1_M2_41100_44340 0.988200
R4958 n1_M2_41100_44340 n1_M2_42180_44340 0.988200
R4959 n1_M2_42180_44340 n1_M2_43260_44340 0.988200
R4960 n1_M2_43260_44340 n1_M2_44340_44340 0.988200
R4961 n1_M2_44340_44340 n1_M2_45420_44340 0.988200
R4962 n1_M2_45420_44340 n1_M2_46500_44340 0.988200
R4963 n1_M2_46500_44340 n1_M2_47580_44340 0.988200
R4964 n1_M2_47580_44340 n1_M2_48660_44340 0.988200
R4965 n1_M2_48660_44340 n1_M2_49740_44340 0.988200
R4966 n1_M2_49740_44340 n1_M2_50820_44340 0.988200
R4967 n1_M2_50820_44340 n1_M2_51900_44340 0.988200
R4968 n1_M2_51900_44340 n1_M2_52980_44340 0.988200
R4969 n1_M2_52980_44340 n1_M2_54060_44340 0.988200
R4970 n1_M2_54060_44340 n1_M2_55140_44340 0.988200
R4971 n1_M2_55140_44340 n1_M2_56220_44340 0.988200
R4972 n1_M2_56220_44340 n1_M2_57300_44340 0.988200
R4973 n1_M2_57300_44340 n1_M2_58380_44340 0.988200
R4974 n1_M2_58380_44340 n1_M2_59460_44340 0.988200
R4975 n1_M2_59460_44340 n1_M2_60540_44340 0.988200
R4976 n1_M2_60540_44340 n1_M2_61620_44340 0.988200
R4977 n1_M2_61620_44340 n1_M2_62700_44340 0.988200
R4978 n1_M2_62700_44340 n1_M2_63780_44340 0.988200
R4979 n1_M2_63780_44340 n1_M2_64860_44340 0.988200
R4980 n1_M2_64860_44340 n1_M2_65940_44340 0.988200
R4981 n1_M2_65940_44340 n1_M2_67020_44340 0.988200
R4982 n1_M2_67020_44340 n1_M2_68100_44340 0.988200
R4983 n1_M2_68100_44340 n1_M2_69180_44340 0.988200
R4984 n1_M2_69180_44340 n1_M2_70260_44340 0.988200
R4985 n1_M2_70260_44340 n1_M2_71340_44340 0.988200
R4986 n1_M2_71340_44340 n1_M2_72420_44340 0.988200
R4987 n1_M2_72420_44340 n1_M2_73500_44340 0.988200
R4988 n1_M2_73500_44340 n1_M2_74580_44340 0.988200
R4989 n1_M2_74580_44340 n1_M2_75660_44340 0.988200
R4990 n1_M2_75660_44340 n1_M2_76740_44340 0.988200
R4991 n1_M2_76740_44340 n1_M2_77820_44340 0.988200
R4992 n1_M2_77820_44340 n1_M2_78900_44340 0.988200
R4993 n1_M2_78900_44340 n1_M2_79980_44340 0.988200
R4994 n1_M2_79980_44340 n1_M2_81060_44340 0.988200
R4995 n1_M2_81060_44340 n1_M2_82140_44340 0.988200
R4996 n1_M2_82140_44340 n1_M2_83220_44340 0.988200
R4997 n1_M2_83220_44340 n1_M2_84300_44340 0.988200
R4998 n1_M2_84300_44340 n1_M2_85380_44340 0.988200
R4999 n1_M2_85380_44340 n1_M2_86460_44340 0.988200
R5000 n1_M2_86460_44340 n1_M2_87540_44340 0.988200
R5001 n1_M2_87540_44340 n1_M2_88620_44340 0.988200
R5002 n1_M2_88620_44340 n1_M2_89700_44340 0.988200
R5003 n1_M2_89700_44340 n1_M2_90780_44340 0.988200
R5004 n1_M2_90780_44340 n1_M2_91860_44340 0.988200
R5005 n1_M2_91860_44340 n1_M2_92940_44340 0.988200
R5006 n1_M2_92940_44340 n1_M2_94020_44340 0.988200
R5007 n1_M2_94020_44340 n1_M2_95100_44340 0.988200
R5008 n1_M2_95100_44340 n1_M2_96180_44340 0.988200
R5009 n1_M2_96180_44340 n1_M2_97260_44340 0.988200
R5010 n1_M2_97260_44340 n1_M2_98340_44340 0.988200
R5011 n1_M2_98340_44340 n1_M2_99420_44340 0.988200
R5012 n1_M2_99420_44340 n1_M2_100500_44340 0.988200
R5013 n1_M2_100500_44340 n1_M2_101580_44340 0.988200
R5014 n1_M2_101580_44340 n1_M2_102660_44340 0.988200
R5015 n1_M2_102660_44340 n1_M2_103740_44340 0.988200
R5016 n1_M2_103740_44340 n1_M2_104820_44340 0.988200
R5017 n1_M2_104820_44340 n1_M2_105900_44340 0.988200
R5018 n1_M2_105900_44340 n1_M2_106980_44340 0.988200
R5019 n1_M2_106980_44340 n1_M2_108060_44340 0.988200
R5020 n1_M2_108060_44340 n1_M2_109140_44340 0.988200
R5021 n1_M2_109140_44340 n1_M2_110220_44340 0.988200
R5022 n1_M2_110220_44340 n1_M2_111300_44340 0.988200
R5023 n1_M2_111300_44340 n1_M2_112380_44340 0.988200
R5024 n1_M2_112380_44340 n1_M2_113460_44340 0.988200
R5025 n1_M2_113460_44340 n1_M2_114540_44340 0.988200
R5026 n1_M2_114540_44340 n1_M2_115620_44340 0.988200
R5027 n1_M2_115620_44340 n1_M2_116700_44340 0.988200
R5028 n1_M2_116700_44340 n1_M2_117780_44340 0.988200
R5029 n1_M2_117780_44340 n1_M2_118860_44340 0.988200
R5030 n1_M2_118860_44340 n1_M2_119940_44340 0.988200
R5031 n1_M2_119940_44340 n1_M2_121020_44340 0.988200
R5032 n1_M2_121020_44340 n1_M2_122100_44340 0.988200
R5033 n1_M2_122100_44340 n1_M2_123180_44340 0.988200
R5034 n1_M2_123180_44340 n1_M2_124260_44340 0.988200
R5035 n1_M2_124260_44340 n1_M2_125340_44340 0.988200
R5036 n1_M2_125340_44340 n1_M2_126420_44340 0.988200
R5037 n1_M2_126420_44340 n1_M2_127500_44340 0.988200
R5038 n1_M2_127500_44340 n1_M2_128580_44340 0.988200
R5039 n1_M2_128580_44340 n1_M2_129660_44340 0.988200
R5040 n1_M2_60_45420 n1_M2_1140_45420 0.988200
R5041 n1_M2_1140_45420 n1_M2_2220_45420 0.988200
R5042 n1_M2_2220_45420 n1_M2_3300_45420 0.988200
R5043 n1_M2_3300_45420 n1_M2_4380_45420 0.988200
R5044 n1_M2_4380_45420 n1_M2_5460_45420 0.988200
R5045 n1_M2_5460_45420 n1_M2_6540_45420 0.988200
R5046 n1_M2_6540_45420 n1_M2_7620_45420 0.988200
R5047 n1_M2_7620_45420 n1_M2_8700_45420 0.988200
R5048 n1_M2_8700_45420 n1_M2_9780_45420 0.988200
R5049 n1_M2_9780_45420 n1_M2_10860_45420 0.988200
R5050 n1_M2_10860_45420 n1_M2_11940_45420 0.988200
R5051 n1_M2_11940_45420 n1_M2_13020_45420 0.988200
R5052 n1_M2_13020_45420 n1_M2_14100_45420 0.988200
R5053 n1_M2_14100_45420 n1_M2_15180_45420 0.988200
R5054 n1_M2_15180_45420 n1_M2_16260_45420 0.988200
R5055 n1_M2_16260_45420 n1_M2_17340_45420 0.988200
R5056 n1_M2_17340_45420 n1_M2_18420_45420 0.988200
R5057 n1_M2_18420_45420 n1_M2_19500_45420 0.988200
R5058 n1_M2_19500_45420 n1_M2_20580_45420 0.988200
R5059 n1_M2_20580_45420 n1_M2_21660_45420 0.988200
R5060 n1_M2_21660_45420 n1_M2_22740_45420 0.988200
R5061 n1_M2_22740_45420 n1_M2_23820_45420 0.988200
R5062 n1_M2_23820_45420 n1_M2_24900_45420 0.988200
R5063 n1_M2_24900_45420 n1_M2_25980_45420 0.988200
R5064 n1_M2_25980_45420 n1_M2_27060_45420 0.988200
R5065 n1_M2_27060_45420 n1_M2_28140_45420 0.988200
R5066 n1_M2_28140_45420 n1_M2_29220_45420 0.988200
R5067 n1_M2_29220_45420 n1_M2_30300_45420 0.988200
R5068 n1_M2_30300_45420 n1_M2_31380_45420 0.988200
R5069 n1_M2_31380_45420 n1_M2_32460_45420 0.988200
R5070 n1_M2_32460_45420 n1_M2_33540_45420 0.988200
R5071 n1_M2_33540_45420 n1_M2_34620_45420 0.988200
R5072 n1_M2_34620_45420 n1_M2_35700_45420 0.988200
R5073 n1_M2_35700_45420 n1_M2_36780_45420 0.988200
R5074 n1_M2_36780_45420 n1_M2_37860_45420 0.988200
R5075 n1_M2_37860_45420 n1_M2_38940_45420 0.988200
R5076 n1_M2_38940_45420 n1_M2_40020_45420 0.988200
R5077 n1_M2_40020_45420 n1_M2_41100_45420 0.988200
R5078 n1_M2_41100_45420 n1_M2_42180_45420 0.988200
R5079 n1_M2_42180_45420 n1_M2_43260_45420 0.988200
R5080 n1_M2_43260_45420 n1_M2_44340_45420 0.988200
R5081 n1_M2_44340_45420 n1_M2_45420_45420 0.988200
R5082 n1_M2_45420_45420 n1_M2_46500_45420 0.988200
R5083 n1_M2_46500_45420 n1_M2_47580_45420 0.988200
R5084 n1_M2_47580_45420 n1_M2_48660_45420 0.988200
R5085 n1_M2_48660_45420 n1_M2_49740_45420 0.988200
R5086 n1_M2_49740_45420 n1_M2_50820_45420 0.988200
R5087 n1_M2_50820_45420 n1_M2_51900_45420 0.988200
R5088 n1_M2_51900_45420 n1_M2_52980_45420 0.988200
R5089 n1_M2_52980_45420 n1_M2_54060_45420 0.988200
R5090 n1_M2_54060_45420 n1_M2_55140_45420 0.988200
R5091 n1_M2_55140_45420 n1_M2_56220_45420 0.988200
R5092 n1_M2_56220_45420 n1_M2_57300_45420 0.988200
R5093 n1_M2_57300_45420 n1_M2_58380_45420 0.988200
R5094 n1_M2_58380_45420 n1_M2_59460_45420 0.988200
R5095 n1_M2_59460_45420 n1_M2_60540_45420 0.988200
R5096 n1_M2_60540_45420 n1_M2_61620_45420 0.988200
R5097 n1_M2_61620_45420 n1_M2_62700_45420 0.988200
R5098 n1_M2_62700_45420 n1_M2_63780_45420 0.988200
R5099 n1_M2_63780_45420 n1_M2_64860_45420 0.988200
R5100 n1_M2_64860_45420 n1_M2_65940_45420 0.988200
R5101 n1_M2_65940_45420 n1_M2_67020_45420 0.988200
R5102 n1_M2_67020_45420 n1_M2_68100_45420 0.988200
R5103 n1_M2_68100_45420 n1_M2_69180_45420 0.988200
R5104 n1_M2_69180_45420 n1_M2_70260_45420 0.988200
R5105 n1_M2_70260_45420 n1_M2_71340_45420 0.988200
R5106 n1_M2_71340_45420 n1_M2_72420_45420 0.988200
R5107 n1_M2_72420_45420 n1_M2_73500_45420 0.988200
R5108 n1_M2_73500_45420 n1_M2_74580_45420 0.988200
R5109 n1_M2_74580_45420 n1_M2_75660_45420 0.988200
R5110 n1_M2_75660_45420 n1_M2_76740_45420 0.988200
R5111 n1_M2_76740_45420 n1_M2_77820_45420 0.988200
R5112 n1_M2_77820_45420 n1_M2_78900_45420 0.988200
R5113 n1_M2_78900_45420 n1_M2_79980_45420 0.988200
R5114 n1_M2_79980_45420 n1_M2_81060_45420 0.988200
R5115 n1_M2_81060_45420 n1_M2_82140_45420 0.988200
R5116 n1_M2_82140_45420 n1_M2_83220_45420 0.988200
R5117 n1_M2_83220_45420 n1_M2_84300_45420 0.988200
R5118 n1_M2_84300_45420 n1_M2_85380_45420 0.988200
R5119 n1_M2_85380_45420 n1_M2_86460_45420 0.988200
R5120 n1_M2_86460_45420 n1_M2_87540_45420 0.988200
R5121 n1_M2_87540_45420 n1_M2_88620_45420 0.988200
R5122 n1_M2_88620_45420 n1_M2_89700_45420 0.988200
R5123 n1_M2_89700_45420 n1_M2_90780_45420 0.988200
R5124 n1_M2_90780_45420 n1_M2_91860_45420 0.988200
R5125 n1_M2_91860_45420 n1_M2_92940_45420 0.988200
R5126 n1_M2_92940_45420 n1_M2_94020_45420 0.988200
R5127 n1_M2_94020_45420 n1_M2_95100_45420 0.988200
R5128 n1_M2_95100_45420 n1_M2_96180_45420 0.988200
R5129 n1_M2_96180_45420 n1_M2_97260_45420 0.988200
R5130 n1_M2_97260_45420 n1_M2_98340_45420 0.988200
R5131 n1_M2_98340_45420 n1_M2_99420_45420 0.988200
R5132 n1_M2_99420_45420 n1_M2_100500_45420 0.988200
R5133 n1_M2_100500_45420 n1_M2_101580_45420 0.988200
R5134 n1_M2_101580_45420 n1_M2_102660_45420 0.988200
R5135 n1_M2_102660_45420 n1_M2_103740_45420 0.988200
R5136 n1_M2_103740_45420 n1_M2_104820_45420 0.988200
R5137 n1_M2_104820_45420 n1_M2_105900_45420 0.988200
R5138 n1_M2_105900_45420 n1_M2_106980_45420 0.988200
R5139 n1_M2_106980_45420 n1_M2_108060_45420 0.988200
R5140 n1_M2_108060_45420 n1_M2_109140_45420 0.988200
R5141 n1_M2_109140_45420 n1_M2_110220_45420 0.988200
R5142 n1_M2_110220_45420 n1_M2_111300_45420 0.988200
R5143 n1_M2_111300_45420 n1_M2_112380_45420 0.988200
R5144 n1_M2_112380_45420 n1_M2_113460_45420 0.988200
R5145 n1_M2_113460_45420 n1_M2_114540_45420 0.988200
R5146 n1_M2_114540_45420 n1_M2_115620_45420 0.988200
R5147 n1_M2_115620_45420 n1_M2_116700_45420 0.988200
R5148 n1_M2_116700_45420 n1_M2_117780_45420 0.988200
R5149 n1_M2_117780_45420 n1_M2_118860_45420 0.988200
R5150 n1_M2_118860_45420 n1_M2_119940_45420 0.988200
R5151 n1_M2_119940_45420 n1_M2_121020_45420 0.988200
R5152 n1_M2_121020_45420 n1_M2_122100_45420 0.988200
R5153 n1_M2_122100_45420 n1_M2_123180_45420 0.988200
R5154 n1_M2_123180_45420 n1_M2_124260_45420 0.988200
R5155 n1_M2_124260_45420 n1_M2_125340_45420 0.988200
R5156 n1_M2_125340_45420 n1_M2_126420_45420 0.988200
R5157 n1_M2_126420_45420 n1_M2_127500_45420 0.988200
R5158 n1_M2_127500_45420 n1_M2_128580_45420 0.988200
R5159 n1_M2_128580_45420 n1_M2_129660_45420 0.988200
R5160 n1_M2_60_46500 n1_M2_1140_46500 0.988200
R5161 n1_M2_1140_46500 n1_M2_2220_46500 0.988200
R5162 n1_M2_2220_46500 n1_M2_3300_46500 0.988200
R5163 n1_M2_3300_46500 n1_M2_4380_46500 0.988200
R5164 n1_M2_4380_46500 n1_M2_5460_46500 0.988200
R5165 n1_M2_5460_46500 n1_M2_6540_46500 0.988200
R5166 n1_M2_6540_46500 n1_M2_7620_46500 0.988200
R5167 n1_M2_7620_46500 n1_M2_8700_46500 0.988200
R5168 n1_M2_8700_46500 n1_M2_9780_46500 0.988200
R5169 n1_M2_9780_46500 n1_M2_10860_46500 0.988200
R5170 n1_M2_10860_46500 n1_M2_11940_46500 0.988200
R5171 n1_M2_11940_46500 n1_M2_13020_46500 0.988200
R5172 n1_M2_13020_46500 n1_M2_14100_46500 0.988200
R5173 n1_M2_14100_46500 n1_M2_15180_46500 0.988200
R5174 n1_M2_15180_46500 n1_M2_16260_46500 0.988200
R5175 n1_M2_16260_46500 n1_M2_17340_46500 0.988200
R5176 n1_M2_17340_46500 n1_M2_18420_46500 0.988200
R5177 n1_M2_18420_46500 n1_M2_19500_46500 0.988200
R5178 n1_M2_19500_46500 n1_M2_20580_46500 0.988200
R5179 n1_M2_20580_46500 n1_M2_21660_46500 0.988200
R5180 n1_M2_21660_46500 n1_M2_22740_46500 0.988200
R5181 n1_M2_22740_46500 n1_M2_23820_46500 0.988200
R5182 n1_M2_23820_46500 n1_M2_24900_46500 0.988200
R5183 n1_M2_24900_46500 n1_M2_25980_46500 0.988200
R5184 n1_M2_25980_46500 n1_M2_27060_46500 0.988200
R5185 n1_M2_27060_46500 n1_M2_28140_46500 0.988200
R5186 n1_M2_28140_46500 n1_M2_29220_46500 0.988200
R5187 n1_M2_29220_46500 n1_M2_30300_46500 0.988200
R5188 n1_M2_30300_46500 n1_M2_31380_46500 0.988200
R5189 n1_M2_31380_46500 n1_M2_32460_46500 0.988200
R5190 n1_M2_32460_46500 n1_M2_33540_46500 0.988200
R5191 n1_M2_33540_46500 n1_M2_34620_46500 0.988200
R5192 n1_M2_34620_46500 n1_M2_35700_46500 0.988200
R5193 n1_M2_35700_46500 n1_M2_36780_46500 0.988200
R5194 n1_M2_36780_46500 n1_M2_37860_46500 0.988200
R5195 n1_M2_37860_46500 n1_M2_38940_46500 0.988200
R5196 n1_M2_38940_46500 n1_M2_40020_46500 0.988200
R5197 n1_M2_40020_46500 n1_M2_41100_46500 0.988200
R5198 n1_M2_41100_46500 n1_M2_42180_46500 0.988200
R5199 n1_M2_42180_46500 n1_M2_43260_46500 0.988200
R5200 n1_M2_43260_46500 n1_M2_44340_46500 0.988200
R5201 n1_M2_44340_46500 n1_M2_45420_46500 0.988200
R5202 n1_M2_45420_46500 n1_M2_46500_46500 0.988200
R5203 n1_M2_46500_46500 n1_M2_47580_46500 0.988200
R5204 n1_M2_47580_46500 n1_M2_48660_46500 0.988200
R5205 n1_M2_48660_46500 n1_M2_49740_46500 0.988200
R5206 n1_M2_49740_46500 n1_M2_50820_46500 0.988200
R5207 n1_M2_50820_46500 n1_M2_51900_46500 0.988200
R5208 n1_M2_51900_46500 n1_M2_52980_46500 0.988200
R5209 n1_M2_52980_46500 n1_M2_54060_46500 0.988200
R5210 n1_M2_54060_46500 n1_M2_55140_46500 0.988200
R5211 n1_M2_55140_46500 n1_M2_56220_46500 0.988200
R5212 n1_M2_56220_46500 n1_M2_57300_46500 0.988200
R5213 n1_M2_57300_46500 n1_M2_58380_46500 0.988200
R5214 n1_M2_58380_46500 n1_M2_59460_46500 0.988200
R5215 n1_M2_59460_46500 n1_M2_60540_46500 0.988200
R5216 n1_M2_60540_46500 n1_M2_61620_46500 0.988200
R5217 n1_M2_61620_46500 n1_M2_62700_46500 0.988200
R5218 n1_M2_62700_46500 n1_M2_63780_46500 0.988200
R5219 n1_M2_63780_46500 n1_M2_64860_46500 0.988200
R5220 n1_M2_64860_46500 n1_M2_65940_46500 0.988200
R5221 n1_M2_65940_46500 n1_M2_67020_46500 0.988200
R5222 n1_M2_67020_46500 n1_M2_68100_46500 0.988200
R5223 n1_M2_68100_46500 n1_M2_69180_46500 0.988200
R5224 n1_M2_69180_46500 n1_M2_70260_46500 0.988200
R5225 n1_M2_70260_46500 n1_M2_71340_46500 0.988200
R5226 n1_M2_71340_46500 n1_M2_72420_46500 0.988200
R5227 n1_M2_72420_46500 n1_M2_73500_46500 0.988200
R5228 n1_M2_73500_46500 n1_M2_74580_46500 0.988200
R5229 n1_M2_74580_46500 n1_M2_75660_46500 0.988200
R5230 n1_M2_75660_46500 n1_M2_76740_46500 0.988200
R5231 n1_M2_76740_46500 n1_M2_77820_46500 0.988200
R5232 n1_M2_77820_46500 n1_M2_78900_46500 0.988200
R5233 n1_M2_78900_46500 n1_M2_79980_46500 0.988200
R5234 n1_M2_79980_46500 n1_M2_81060_46500 0.988200
R5235 n1_M2_81060_46500 n1_M2_82140_46500 0.988200
R5236 n1_M2_82140_46500 n1_M2_83220_46500 0.988200
R5237 n1_M2_83220_46500 n1_M2_84300_46500 0.988200
R5238 n1_M2_84300_46500 n1_M2_85380_46500 0.988200
R5239 n1_M2_85380_46500 n1_M2_86460_46500 0.988200
R5240 n1_M2_86460_46500 n1_M2_87540_46500 0.988200
R5241 n1_M2_87540_46500 n1_M2_88620_46500 0.988200
R5242 n1_M2_88620_46500 n1_M2_89700_46500 0.988200
R5243 n1_M2_89700_46500 n1_M2_90780_46500 0.988200
R5244 n1_M2_90780_46500 n1_M2_91860_46500 0.988200
R5245 n1_M2_91860_46500 n1_M2_92940_46500 0.988200
R5246 n1_M2_92940_46500 n1_M2_94020_46500 0.988200
R5247 n1_M2_94020_46500 n1_M2_95100_46500 0.988200
R5248 n1_M2_95100_46500 n1_M2_96180_46500 0.988200
R5249 n1_M2_96180_46500 n1_M2_97260_46500 0.988200
R5250 n1_M2_97260_46500 n1_M2_98340_46500 0.988200
R5251 n1_M2_98340_46500 n1_M2_99420_46500 0.988200
R5252 n1_M2_99420_46500 n1_M2_100500_46500 0.988200
R5253 n1_M2_100500_46500 n1_M2_101580_46500 0.988200
R5254 n1_M2_101580_46500 n1_M2_102660_46500 0.988200
R5255 n1_M2_102660_46500 n1_M2_103740_46500 0.988200
R5256 n1_M2_103740_46500 n1_M2_104820_46500 0.988200
R5257 n1_M2_104820_46500 n1_M2_105900_46500 0.988200
R5258 n1_M2_105900_46500 n1_M2_106980_46500 0.988200
R5259 n1_M2_106980_46500 n1_M2_108060_46500 0.988200
R5260 n1_M2_108060_46500 n1_M2_109140_46500 0.988200
R5261 n1_M2_109140_46500 n1_M2_110220_46500 0.988200
R5262 n1_M2_110220_46500 n1_M2_111300_46500 0.988200
R5263 n1_M2_111300_46500 n1_M2_112380_46500 0.988200
R5264 n1_M2_112380_46500 n1_M2_113460_46500 0.988200
R5265 n1_M2_113460_46500 n1_M2_114540_46500 0.988200
R5266 n1_M2_114540_46500 n1_M2_115620_46500 0.988200
R5267 n1_M2_115620_46500 n1_M2_116700_46500 0.988200
R5268 n1_M2_116700_46500 n1_M2_117780_46500 0.988200
R5269 n1_M2_117780_46500 n1_M2_118860_46500 0.988200
R5270 n1_M2_118860_46500 n1_M2_119940_46500 0.988200
R5271 n1_M2_119940_46500 n1_M2_121020_46500 0.988200
R5272 n1_M2_121020_46500 n1_M2_122100_46500 0.988200
R5273 n1_M2_122100_46500 n1_M2_123180_46500 0.988200
R5274 n1_M2_123180_46500 n1_M2_124260_46500 0.988200
R5275 n1_M2_124260_46500 n1_M2_125340_46500 0.988200
R5276 n1_M2_125340_46500 n1_M2_126420_46500 0.988200
R5277 n1_M2_126420_46500 n1_M2_127500_46500 0.988200
R5278 n1_M2_127500_46500 n1_M2_128580_46500 0.988200
R5279 n1_M2_128580_46500 n1_M2_129660_46500 0.988200
R5280 n1_M2_60_47580 n1_M2_1140_47580 0.988200
R5281 n1_M2_1140_47580 n1_M2_2220_47580 0.988200
R5282 n1_M2_2220_47580 n1_M2_3300_47580 0.988200
R5283 n1_M2_3300_47580 n1_M2_4380_47580 0.988200
R5284 n1_M2_4380_47580 n1_M2_5460_47580 0.988200
R5285 n1_M2_5460_47580 n1_M2_6540_47580 0.988200
R5286 n1_M2_6540_47580 n1_M2_7620_47580 0.988200
R5287 n1_M2_7620_47580 n1_M2_8700_47580 0.988200
R5288 n1_M2_8700_47580 n1_M2_9780_47580 0.988200
R5289 n1_M2_9780_47580 n1_M2_10860_47580 0.988200
R5290 n1_M2_10860_47580 n1_M2_11940_47580 0.988200
R5291 n1_M2_11940_47580 n1_M2_13020_47580 0.988200
R5292 n1_M2_13020_47580 n1_M2_14100_47580 0.988200
R5293 n1_M2_14100_47580 n1_M2_15180_47580 0.988200
R5294 n1_M2_15180_47580 n1_M2_16260_47580 0.988200
R5295 n1_M2_16260_47580 n1_M2_17340_47580 0.988200
R5296 n1_M2_17340_47580 n1_M2_18420_47580 0.988200
R5297 n1_M2_18420_47580 n1_M2_19500_47580 0.988200
R5298 n1_M2_19500_47580 n1_M2_20580_47580 0.988200
R5299 n1_M2_20580_47580 n1_M2_21660_47580 0.988200
R5300 n1_M2_21660_47580 n1_M2_22740_47580 0.988200
R5301 n1_M2_22740_47580 n1_M2_23820_47580 0.988200
R5302 n1_M2_23820_47580 n1_M2_24900_47580 0.988200
R5303 n1_M2_24900_47580 n1_M2_25980_47580 0.988200
R5304 n1_M2_25980_47580 n1_M2_27060_47580 0.988200
R5305 n1_M2_27060_47580 n1_M2_28140_47580 0.988200
R5306 n1_M2_28140_47580 n1_M2_29220_47580 0.988200
R5307 n1_M2_29220_47580 n1_M2_30300_47580 0.988200
R5308 n1_M2_30300_47580 n1_M2_31380_47580 0.988200
R5309 n1_M2_31380_47580 n1_M2_32460_47580 0.988200
R5310 n1_M2_32460_47580 n1_M2_33540_47580 0.988200
R5311 n1_M2_33540_47580 n1_M2_34620_47580 0.988200
R5312 n1_M2_34620_47580 n1_M2_35700_47580 0.988200
R5313 n1_M2_35700_47580 n1_M2_36780_47580 0.988200
R5314 n1_M2_36780_47580 n1_M2_37860_47580 0.988200
R5315 n1_M2_37860_47580 n1_M2_38940_47580 0.988200
R5316 n1_M2_38940_47580 n1_M2_40020_47580 0.988200
R5317 n1_M2_40020_47580 n1_M2_41100_47580 0.988200
R5318 n1_M2_41100_47580 n1_M2_42180_47580 0.988200
R5319 n1_M2_42180_47580 n1_M2_43260_47580 0.988200
R5320 n1_M2_43260_47580 n1_M2_44340_47580 0.988200
R5321 n1_M2_44340_47580 n1_M2_45420_47580 0.988200
R5322 n1_M2_45420_47580 n1_M2_46500_47580 0.988200
R5323 n1_M2_46500_47580 n1_M2_47580_47580 0.988200
R5324 n1_M2_47580_47580 n1_M2_48660_47580 0.988200
R5325 n1_M2_48660_47580 n1_M2_49740_47580 0.988200
R5326 n1_M2_49740_47580 n1_M2_50820_47580 0.988200
R5327 n1_M2_50820_47580 n1_M2_51900_47580 0.988200
R5328 n1_M2_51900_47580 n1_M2_52980_47580 0.988200
R5329 n1_M2_52980_47580 n1_M2_54060_47580 0.988200
R5330 n1_M2_54060_47580 n1_M2_55140_47580 0.988200
R5331 n1_M2_55140_47580 n1_M2_56220_47580 0.988200
R5332 n1_M2_56220_47580 n1_M2_57300_47580 0.988200
R5333 n1_M2_57300_47580 n1_M2_58380_47580 0.988200
R5334 n1_M2_58380_47580 n1_M2_59460_47580 0.988200
R5335 n1_M2_59460_47580 n1_M2_60540_47580 0.988200
R5336 n1_M2_60540_47580 n1_M2_61620_47580 0.988200
R5337 n1_M2_61620_47580 n1_M2_62700_47580 0.988200
R5338 n1_M2_62700_47580 n1_M2_63780_47580 0.988200
R5339 n1_M2_63780_47580 n1_M2_64860_47580 0.988200
R5340 n1_M2_64860_47580 n1_M2_65940_47580 0.988200
R5341 n1_M2_65940_47580 n1_M2_67020_47580 0.988200
R5342 n1_M2_67020_47580 n1_M2_68100_47580 0.988200
R5343 n1_M2_68100_47580 n1_M2_69180_47580 0.988200
R5344 n1_M2_69180_47580 n1_M2_70260_47580 0.988200
R5345 n1_M2_70260_47580 n1_M2_71340_47580 0.988200
R5346 n1_M2_71340_47580 n1_M2_72420_47580 0.988200
R5347 n1_M2_72420_47580 n1_M2_73500_47580 0.988200
R5348 n1_M2_73500_47580 n1_M2_74580_47580 0.988200
R5349 n1_M2_74580_47580 n1_M2_75660_47580 0.988200
R5350 n1_M2_75660_47580 n1_M2_76740_47580 0.988200
R5351 n1_M2_76740_47580 n1_M2_77820_47580 0.988200
R5352 n1_M2_77820_47580 n1_M2_78900_47580 0.988200
R5353 n1_M2_78900_47580 n1_M2_79980_47580 0.988200
R5354 n1_M2_79980_47580 n1_M2_81060_47580 0.988200
R5355 n1_M2_81060_47580 n1_M2_82140_47580 0.988200
R5356 n1_M2_82140_47580 n1_M2_83220_47580 0.988200
R5357 n1_M2_83220_47580 n1_M2_84300_47580 0.988200
R5358 n1_M2_84300_47580 n1_M2_85380_47580 0.988200
R5359 n1_M2_85380_47580 n1_M2_86460_47580 0.988200
R5360 n1_M2_86460_47580 n1_M2_87540_47580 0.988200
R5361 n1_M2_87540_47580 n1_M2_88620_47580 0.988200
R5362 n1_M2_88620_47580 n1_M2_89700_47580 0.988200
R5363 n1_M2_89700_47580 n1_M2_90780_47580 0.988200
R5364 n1_M2_90780_47580 n1_M2_91860_47580 0.988200
R5365 n1_M2_91860_47580 n1_M2_92940_47580 0.988200
R5366 n1_M2_92940_47580 n1_M2_94020_47580 0.988200
R5367 n1_M2_94020_47580 n1_M2_95100_47580 0.988200
R5368 n1_M2_95100_47580 n1_M2_96180_47580 0.988200
R5369 n1_M2_96180_47580 n1_M2_97260_47580 0.988200
R5370 n1_M2_97260_47580 n1_M2_98340_47580 0.988200
R5371 n1_M2_98340_47580 n1_M2_99420_47580 0.988200
R5372 n1_M2_99420_47580 n1_M2_100500_47580 0.988200
R5373 n1_M2_100500_47580 n1_M2_101580_47580 0.988200
R5374 n1_M2_101580_47580 n1_M2_102660_47580 0.988200
R5375 n1_M2_102660_47580 n1_M2_103740_47580 0.988200
R5376 n1_M2_103740_47580 n1_M2_104820_47580 0.988200
R5377 n1_M2_104820_47580 n1_M2_105900_47580 0.988200
R5378 n1_M2_105900_47580 n1_M2_106980_47580 0.988200
R5379 n1_M2_106980_47580 n1_M2_108060_47580 0.988200
R5380 n1_M2_108060_47580 n1_M2_109140_47580 0.988200
R5381 n1_M2_109140_47580 n1_M2_110220_47580 0.988200
R5382 n1_M2_110220_47580 n1_M2_111300_47580 0.988200
R5383 n1_M2_111300_47580 n1_M2_112380_47580 0.988200
R5384 n1_M2_112380_47580 n1_M2_113460_47580 0.988200
R5385 n1_M2_113460_47580 n1_M2_114540_47580 0.988200
R5386 n1_M2_114540_47580 n1_M2_115620_47580 0.988200
R5387 n1_M2_115620_47580 n1_M2_116700_47580 0.988200
R5388 n1_M2_116700_47580 n1_M2_117780_47580 0.988200
R5389 n1_M2_117780_47580 n1_M2_118860_47580 0.988200
R5390 n1_M2_118860_47580 n1_M2_119940_47580 0.988200
R5391 n1_M2_119940_47580 n1_M2_121020_47580 0.988200
R5392 n1_M2_121020_47580 n1_M2_122100_47580 0.988200
R5393 n1_M2_122100_47580 n1_M2_123180_47580 0.988200
R5394 n1_M2_123180_47580 n1_M2_124260_47580 0.988200
R5395 n1_M2_124260_47580 n1_M2_125340_47580 0.988200
R5396 n1_M2_125340_47580 n1_M2_126420_47580 0.988200
R5397 n1_M2_126420_47580 n1_M2_127500_47580 0.988200
R5398 n1_M2_127500_47580 n1_M2_128580_47580 0.988200
R5399 n1_M2_128580_47580 n1_M2_129660_47580 0.988200
R5400 n1_M2_60_48660 n1_M2_1140_48660 0.988200
R5401 n1_M2_1140_48660 n1_M2_2220_48660 0.988200
R5402 n1_M2_2220_48660 n1_M2_3300_48660 0.988200
R5403 n1_M2_3300_48660 n1_M2_4380_48660 0.988200
R5404 n1_M2_4380_48660 n1_M2_5460_48660 0.988200
R5405 n1_M2_5460_48660 n1_M2_6540_48660 0.988200
R5406 n1_M2_6540_48660 n1_M2_7620_48660 0.988200
R5407 n1_M2_7620_48660 n1_M2_8700_48660 0.988200
R5408 n1_M2_8700_48660 n1_M2_9780_48660 0.988200
R5409 n1_M2_9780_48660 n1_M2_10860_48660 0.988200
R5410 n1_M2_10860_48660 n1_M2_11940_48660 0.988200
R5411 n1_M2_11940_48660 n1_M2_13020_48660 0.988200
R5412 n1_M2_13020_48660 n1_M2_14100_48660 0.988200
R5413 n1_M2_14100_48660 n1_M2_15180_48660 0.988200
R5414 n1_M2_15180_48660 n1_M2_16260_48660 0.988200
R5415 n1_M2_16260_48660 n1_M2_17340_48660 0.988200
R5416 n1_M2_17340_48660 n1_M2_18420_48660 0.988200
R5417 n1_M2_18420_48660 n1_M2_19500_48660 0.988200
R5418 n1_M2_19500_48660 n1_M2_20580_48660 0.988200
R5419 n1_M2_20580_48660 n1_M2_21660_48660 0.988200
R5420 n1_M2_21660_48660 n1_M2_22740_48660 0.988200
R5421 n1_M2_22740_48660 n1_M2_23820_48660 0.988200
R5422 n1_M2_23820_48660 n1_M2_24900_48660 0.988200
R5423 n1_M2_24900_48660 n1_M2_25980_48660 0.988200
R5424 n1_M2_25980_48660 n1_M2_27060_48660 0.988200
R5425 n1_M2_27060_48660 n1_M2_28140_48660 0.988200
R5426 n1_M2_28140_48660 n1_M2_29220_48660 0.988200
R5427 n1_M2_29220_48660 n1_M2_30300_48660 0.988200
R5428 n1_M2_30300_48660 n1_M2_31380_48660 0.988200
R5429 n1_M2_31380_48660 n1_M2_32460_48660 0.988200
R5430 n1_M2_32460_48660 n1_M2_33540_48660 0.988200
R5431 n1_M2_33540_48660 n1_M2_34620_48660 0.988200
R5432 n1_M2_34620_48660 n1_M2_35700_48660 0.988200
R5433 n1_M2_35700_48660 n1_M2_36780_48660 0.988200
R5434 n1_M2_36780_48660 n1_M2_37860_48660 0.988200
R5435 n1_M2_37860_48660 n1_M2_38940_48660 0.988200
R5436 n1_M2_38940_48660 n1_M2_40020_48660 0.988200
R5437 n1_M2_40020_48660 n1_M2_41100_48660 0.988200
R5438 n1_M2_41100_48660 n1_M2_42180_48660 0.988200
R5439 n1_M2_42180_48660 n1_M2_43260_48660 0.988200
R5440 n1_M2_43260_48660 n1_M2_44340_48660 0.988200
R5441 n1_M2_44340_48660 n1_M2_45420_48660 0.988200
R5442 n1_M2_45420_48660 n1_M2_46500_48660 0.988200
R5443 n1_M2_46500_48660 n1_M2_47580_48660 0.988200
R5444 n1_M2_47580_48660 n1_M2_48660_48660 0.988200
R5445 n1_M2_48660_48660 n1_M2_49740_48660 0.988200
R5446 n1_M2_49740_48660 n1_M2_50820_48660 0.988200
R5447 n1_M2_50820_48660 n1_M2_51900_48660 0.988200
R5448 n1_M2_51900_48660 n1_M2_52980_48660 0.988200
R5449 n1_M2_52980_48660 n1_M2_54060_48660 0.988200
R5450 n1_M2_54060_48660 n1_M2_55140_48660 0.988200
R5451 n1_M2_55140_48660 n1_M2_56220_48660 0.988200
R5452 n1_M2_56220_48660 n1_M2_57300_48660 0.988200
R5453 n1_M2_57300_48660 n1_M2_58380_48660 0.988200
R5454 n1_M2_58380_48660 n1_M2_59460_48660 0.988200
R5455 n1_M2_59460_48660 n1_M2_60540_48660 0.988200
R5456 n1_M2_60540_48660 n1_M2_61620_48660 0.988200
R5457 n1_M2_61620_48660 n1_M2_62700_48660 0.988200
R5458 n1_M2_62700_48660 n1_M2_63780_48660 0.988200
R5459 n1_M2_63780_48660 n1_M2_64860_48660 0.988200
R5460 n1_M2_64860_48660 n1_M2_65940_48660 0.988200
R5461 n1_M2_65940_48660 n1_M2_67020_48660 0.988200
R5462 n1_M2_67020_48660 n1_M2_68100_48660 0.988200
R5463 n1_M2_68100_48660 n1_M2_69180_48660 0.988200
R5464 n1_M2_69180_48660 n1_M2_70260_48660 0.988200
R5465 n1_M2_70260_48660 n1_M2_71340_48660 0.988200
R5466 n1_M2_71340_48660 n1_M2_72420_48660 0.988200
R5467 n1_M2_72420_48660 n1_M2_73500_48660 0.988200
R5468 n1_M2_73500_48660 n1_M2_74580_48660 0.988200
R5469 n1_M2_74580_48660 n1_M2_75660_48660 0.988200
R5470 n1_M2_75660_48660 n1_M2_76740_48660 0.988200
R5471 n1_M2_76740_48660 n1_M2_77820_48660 0.988200
R5472 n1_M2_77820_48660 n1_M2_78900_48660 0.988200
R5473 n1_M2_78900_48660 n1_M2_79980_48660 0.988200
R5474 n1_M2_79980_48660 n1_M2_81060_48660 0.988200
R5475 n1_M2_81060_48660 n1_M2_82140_48660 0.988200
R5476 n1_M2_82140_48660 n1_M2_83220_48660 0.988200
R5477 n1_M2_83220_48660 n1_M2_84300_48660 0.988200
R5478 n1_M2_84300_48660 n1_M2_85380_48660 0.988200
R5479 n1_M2_85380_48660 n1_M2_86460_48660 0.988200
R5480 n1_M2_86460_48660 n1_M2_87540_48660 0.988200
R5481 n1_M2_87540_48660 n1_M2_88620_48660 0.988200
R5482 n1_M2_88620_48660 n1_M2_89700_48660 0.988200
R5483 n1_M2_89700_48660 n1_M2_90780_48660 0.988200
R5484 n1_M2_90780_48660 n1_M2_91860_48660 0.988200
R5485 n1_M2_91860_48660 n1_M2_92940_48660 0.988200
R5486 n1_M2_92940_48660 n1_M2_94020_48660 0.988200
R5487 n1_M2_94020_48660 n1_M2_95100_48660 0.988200
R5488 n1_M2_95100_48660 n1_M2_96180_48660 0.988200
R5489 n1_M2_96180_48660 n1_M2_97260_48660 0.988200
R5490 n1_M2_97260_48660 n1_M2_98340_48660 0.988200
R5491 n1_M2_98340_48660 n1_M2_99420_48660 0.988200
R5492 n1_M2_99420_48660 n1_M2_100500_48660 0.988200
R5493 n1_M2_100500_48660 n1_M2_101580_48660 0.988200
R5494 n1_M2_101580_48660 n1_M2_102660_48660 0.988200
R5495 n1_M2_102660_48660 n1_M2_103740_48660 0.988200
R5496 n1_M2_103740_48660 n1_M2_104820_48660 0.988200
R5497 n1_M2_104820_48660 n1_M2_105900_48660 0.988200
R5498 n1_M2_105900_48660 n1_M2_106980_48660 0.988200
R5499 n1_M2_106980_48660 n1_M2_108060_48660 0.988200
R5500 n1_M2_108060_48660 n1_M2_109140_48660 0.988200
R5501 n1_M2_109140_48660 n1_M2_110220_48660 0.988200
R5502 n1_M2_110220_48660 n1_M2_111300_48660 0.988200
R5503 n1_M2_111300_48660 n1_M2_112380_48660 0.988200
R5504 n1_M2_112380_48660 n1_M2_113460_48660 0.988200
R5505 n1_M2_113460_48660 n1_M2_114540_48660 0.988200
R5506 n1_M2_114540_48660 n1_M2_115620_48660 0.988200
R5507 n1_M2_115620_48660 n1_M2_116700_48660 0.988200
R5508 n1_M2_116700_48660 n1_M2_117780_48660 0.988200
R5509 n1_M2_117780_48660 n1_M2_118860_48660 0.988200
R5510 n1_M2_118860_48660 n1_M2_119940_48660 0.988200
R5511 n1_M2_119940_48660 n1_M2_121020_48660 0.988200
R5512 n1_M2_121020_48660 n1_M2_122100_48660 0.988200
R5513 n1_M2_122100_48660 n1_M2_123180_48660 0.988200
R5514 n1_M2_123180_48660 n1_M2_124260_48660 0.988200
R5515 n1_M2_124260_48660 n1_M2_125340_48660 0.988200
R5516 n1_M2_125340_48660 n1_M2_126420_48660 0.988200
R5517 n1_M2_126420_48660 n1_M2_127500_48660 0.988200
R5518 n1_M2_127500_48660 n1_M2_128580_48660 0.988200
R5519 n1_M2_128580_48660 n1_M2_129660_48660 0.988200
R5520 n1_M2_60_49740 n1_M2_1140_49740 0.988200
R5521 n1_M2_1140_49740 n1_M2_2220_49740 0.988200
R5522 n1_M2_2220_49740 n1_M2_3300_49740 0.988200
R5523 n1_M2_3300_49740 n1_M2_4380_49740 0.988200
R5524 n1_M2_4380_49740 n1_M2_5460_49740 0.988200
R5525 n1_M2_5460_49740 n1_M2_6540_49740 0.988200
R5526 n1_M2_6540_49740 n1_M2_7620_49740 0.988200
R5527 n1_M2_7620_49740 n1_M2_8700_49740 0.988200
R5528 n1_M2_8700_49740 n1_M2_9780_49740 0.988200
R5529 n1_M2_9780_49740 n1_M2_10860_49740 0.988200
R5530 n1_M2_10860_49740 n1_M2_11940_49740 0.988200
R5531 n1_M2_11940_49740 n1_M2_13020_49740 0.988200
R5532 n1_M2_13020_49740 n1_M2_14100_49740 0.988200
R5533 n1_M2_14100_49740 n1_M2_15180_49740 0.988200
R5534 n1_M2_15180_49740 n1_M2_16260_49740 0.988200
R5535 n1_M2_16260_49740 n1_M2_17340_49740 0.988200
R5536 n1_M2_17340_49740 n1_M2_18420_49740 0.988200
R5537 n1_M2_18420_49740 n1_M2_19500_49740 0.988200
R5538 n1_M2_19500_49740 n1_M2_20580_49740 0.988200
R5539 n1_M2_20580_49740 n1_M2_21660_49740 0.988200
R5540 n1_M2_21660_49740 n1_M2_22740_49740 0.988200
R5541 n1_M2_22740_49740 n1_M2_23820_49740 0.988200
R5542 n1_M2_23820_49740 n1_M2_24900_49740 0.988200
R5543 n1_M2_24900_49740 n1_M2_25980_49740 0.988200
R5544 n1_M2_25980_49740 n1_M2_27060_49740 0.988200
R5545 n1_M2_27060_49740 n1_M2_28140_49740 0.988200
R5546 n1_M2_28140_49740 n1_M2_29220_49740 0.988200
R5547 n1_M2_29220_49740 n1_M2_30300_49740 0.988200
R5548 n1_M2_30300_49740 n1_M2_31380_49740 0.988200
R5549 n1_M2_31380_49740 n1_M2_32460_49740 0.988200
R5550 n1_M2_32460_49740 n1_M2_33540_49740 0.988200
R5551 n1_M2_33540_49740 n1_M2_34620_49740 0.988200
R5552 n1_M2_34620_49740 n1_M2_35700_49740 0.988200
R5553 n1_M2_35700_49740 n1_M2_36780_49740 0.988200
R5554 n1_M2_36780_49740 n1_M2_37860_49740 0.988200
R5555 n1_M2_37860_49740 n1_M2_38940_49740 0.988200
R5556 n1_M2_38940_49740 n1_M2_40020_49740 0.988200
R5557 n1_M2_40020_49740 n1_M2_41100_49740 0.988200
R5558 n1_M2_41100_49740 n1_M2_42180_49740 0.988200
R5559 n1_M2_42180_49740 n1_M2_43260_49740 0.988200
R5560 n1_M2_43260_49740 n1_M2_44340_49740 0.988200
R5561 n1_M2_44340_49740 n1_M2_45420_49740 0.988200
R5562 n1_M2_45420_49740 n1_M2_46500_49740 0.988200
R5563 n1_M2_46500_49740 n1_M2_47580_49740 0.988200
R5564 n1_M2_47580_49740 n1_M2_48660_49740 0.988200
R5565 n1_M2_48660_49740 n1_M2_49740_49740 0.988200
R5566 n1_M2_49740_49740 n1_M2_50820_49740 0.988200
R5567 n1_M2_50820_49740 n1_M2_51900_49740 0.988200
R5568 n1_M2_51900_49740 n1_M2_52980_49740 0.988200
R5569 n1_M2_52980_49740 n1_M2_54060_49740 0.988200
R5570 n1_M2_54060_49740 n1_M2_55140_49740 0.988200
R5571 n1_M2_55140_49740 n1_M2_56220_49740 0.988200
R5572 n1_M2_56220_49740 n1_M2_57300_49740 0.988200
R5573 n1_M2_57300_49740 n1_M2_58380_49740 0.988200
R5574 n1_M2_58380_49740 n1_M2_59460_49740 0.988200
R5575 n1_M2_59460_49740 n1_M2_60540_49740 0.988200
R5576 n1_M2_60540_49740 n1_M2_61620_49740 0.988200
R5577 n1_M2_61620_49740 n1_M2_62700_49740 0.988200
R5578 n1_M2_62700_49740 n1_M2_63780_49740 0.988200
R5579 n1_M2_63780_49740 n1_M2_64860_49740 0.988200
R5580 n1_M2_64860_49740 n1_M2_65940_49740 0.988200
R5581 n1_M2_65940_49740 n1_M2_67020_49740 0.988200
R5582 n1_M2_67020_49740 n1_M2_68100_49740 0.988200
R5583 n1_M2_68100_49740 n1_M2_69180_49740 0.988200
R5584 n1_M2_69180_49740 n1_M2_70260_49740 0.988200
R5585 n1_M2_70260_49740 n1_M2_71340_49740 0.988200
R5586 n1_M2_71340_49740 n1_M2_72420_49740 0.988200
R5587 n1_M2_72420_49740 n1_M2_73500_49740 0.988200
R5588 n1_M2_73500_49740 n1_M2_74580_49740 0.988200
R5589 n1_M2_74580_49740 n1_M2_75660_49740 0.988200
R5590 n1_M2_75660_49740 n1_M2_76740_49740 0.988200
R5591 n1_M2_76740_49740 n1_M2_77820_49740 0.988200
R5592 n1_M2_77820_49740 n1_M2_78900_49740 0.988200
R5593 n1_M2_78900_49740 n1_M2_79980_49740 0.988200
R5594 n1_M2_79980_49740 n1_M2_81060_49740 0.988200
R5595 n1_M2_81060_49740 n1_M2_82140_49740 0.988200
R5596 n1_M2_82140_49740 n1_M2_83220_49740 0.988200
R5597 n1_M2_83220_49740 n1_M2_84300_49740 0.988200
R5598 n1_M2_84300_49740 n1_M2_85380_49740 0.988200
R5599 n1_M2_85380_49740 n1_M2_86460_49740 0.988200
R5600 n1_M2_86460_49740 n1_M2_87540_49740 0.988200
R5601 n1_M2_87540_49740 n1_M2_88620_49740 0.988200
R5602 n1_M2_88620_49740 n1_M2_89700_49740 0.988200
R5603 n1_M2_89700_49740 n1_M2_90780_49740 0.988200
R5604 n1_M2_90780_49740 n1_M2_91860_49740 0.988200
R5605 n1_M2_91860_49740 n1_M2_92940_49740 0.988200
R5606 n1_M2_92940_49740 n1_M2_94020_49740 0.988200
R5607 n1_M2_94020_49740 n1_M2_95100_49740 0.988200
R5608 n1_M2_95100_49740 n1_M2_96180_49740 0.988200
R5609 n1_M2_96180_49740 n1_M2_97260_49740 0.988200
R5610 n1_M2_97260_49740 n1_M2_98340_49740 0.988200
R5611 n1_M2_98340_49740 n1_M2_99420_49740 0.988200
R5612 n1_M2_99420_49740 n1_M2_100500_49740 0.988200
R5613 n1_M2_100500_49740 n1_M2_101580_49740 0.988200
R5614 n1_M2_101580_49740 n1_M2_102660_49740 0.988200
R5615 n1_M2_102660_49740 n1_M2_103740_49740 0.988200
R5616 n1_M2_103740_49740 n1_M2_104820_49740 0.988200
R5617 n1_M2_104820_49740 n1_M2_105900_49740 0.988200
R5618 n1_M2_105900_49740 n1_M2_106980_49740 0.988200
R5619 n1_M2_106980_49740 n1_M2_108060_49740 0.988200
R5620 n1_M2_108060_49740 n1_M2_109140_49740 0.988200
R5621 n1_M2_109140_49740 n1_M2_110220_49740 0.988200
R5622 n1_M2_110220_49740 n1_M2_111300_49740 0.988200
R5623 n1_M2_111300_49740 n1_M2_112380_49740 0.988200
R5624 n1_M2_112380_49740 n1_M2_113460_49740 0.988200
R5625 n1_M2_113460_49740 n1_M2_114540_49740 0.988200
R5626 n1_M2_114540_49740 n1_M2_115620_49740 0.988200
R5627 n1_M2_115620_49740 n1_M2_116700_49740 0.988200
R5628 n1_M2_116700_49740 n1_M2_117780_49740 0.988200
R5629 n1_M2_117780_49740 n1_M2_118860_49740 0.988200
R5630 n1_M2_118860_49740 n1_M2_119940_49740 0.988200
R5631 n1_M2_119940_49740 n1_M2_121020_49740 0.988200
R5632 n1_M2_121020_49740 n1_M2_122100_49740 0.988200
R5633 n1_M2_122100_49740 n1_M2_123180_49740 0.988200
R5634 n1_M2_123180_49740 n1_M2_124260_49740 0.988200
R5635 n1_M2_124260_49740 n1_M2_125340_49740 0.988200
R5636 n1_M2_125340_49740 n1_M2_126420_49740 0.988200
R5637 n1_M2_126420_49740 n1_M2_127500_49740 0.988200
R5638 n1_M2_127500_49740 n1_M2_128580_49740 0.988200
R5639 n1_M2_128580_49740 n1_M2_129660_49740 0.988200
R5640 n1_M2_60_50820 n1_M2_1140_50820 0.988200
R5641 n1_M2_1140_50820 n1_M2_2220_50820 0.988200
R5642 n1_M2_2220_50820 n1_M2_3300_50820 0.988200
R5643 n1_M2_3300_50820 n1_M2_4380_50820 0.988200
R5644 n1_M2_4380_50820 n1_M2_5460_50820 0.988200
R5645 n1_M2_5460_50820 n1_M2_6540_50820 0.988200
R5646 n1_M2_6540_50820 n1_M2_7620_50820 0.988200
R5647 n1_M2_7620_50820 n1_M2_8700_50820 0.988200
R5648 n1_M2_8700_50820 n1_M2_9780_50820 0.988200
R5649 n1_M2_9780_50820 n1_M2_10860_50820 0.988200
R5650 n1_M2_10860_50820 n1_M2_11940_50820 0.988200
R5651 n1_M2_11940_50820 n1_M2_13020_50820 0.988200
R5652 n1_M2_13020_50820 n1_M2_14100_50820 0.988200
R5653 n1_M2_14100_50820 n1_M2_15180_50820 0.988200
R5654 n1_M2_15180_50820 n1_M2_16260_50820 0.988200
R5655 n1_M2_16260_50820 n1_M2_17340_50820 0.988200
R5656 n1_M2_17340_50820 n1_M2_18420_50820 0.988200
R5657 n1_M2_18420_50820 n1_M2_19500_50820 0.988200
R5658 n1_M2_19500_50820 n1_M2_20580_50820 0.988200
R5659 n1_M2_20580_50820 n1_M2_21660_50820 0.988200
R5660 n1_M2_21660_50820 n1_M2_22740_50820 0.988200
R5661 n1_M2_22740_50820 n1_M2_23820_50820 0.988200
R5662 n1_M2_23820_50820 n1_M2_24900_50820 0.988200
R5663 n1_M2_24900_50820 n1_M2_25980_50820 0.988200
R5664 n1_M2_25980_50820 n1_M2_27060_50820 0.988200
R5665 n1_M2_27060_50820 n1_M2_28140_50820 0.988200
R5666 n1_M2_28140_50820 n1_M2_29220_50820 0.988200
R5667 n1_M2_29220_50820 n1_M2_30300_50820 0.988200
R5668 n1_M2_30300_50820 n1_M2_31380_50820 0.988200
R5669 n1_M2_31380_50820 n1_M2_32460_50820 0.988200
R5670 n1_M2_32460_50820 n1_M2_33540_50820 0.988200
R5671 n1_M2_33540_50820 n1_M2_34620_50820 0.988200
R5672 n1_M2_34620_50820 n1_M2_35700_50820 0.988200
R5673 n1_M2_35700_50820 n1_M2_36780_50820 0.988200
R5674 n1_M2_36780_50820 n1_M2_37860_50820 0.988200
R5675 n1_M2_37860_50820 n1_M2_38940_50820 0.988200
R5676 n1_M2_38940_50820 n1_M2_40020_50820 0.988200
R5677 n1_M2_40020_50820 n1_M2_41100_50820 0.988200
R5678 n1_M2_41100_50820 n1_M2_42180_50820 0.988200
R5679 n1_M2_42180_50820 n1_M2_43260_50820 0.988200
R5680 n1_M2_43260_50820 n1_M2_44340_50820 0.988200
R5681 n1_M2_44340_50820 n1_M2_45420_50820 0.988200
R5682 n1_M2_45420_50820 n1_M2_46500_50820 0.988200
R5683 n1_M2_46500_50820 n1_M2_47580_50820 0.988200
R5684 n1_M2_47580_50820 n1_M2_48660_50820 0.988200
R5685 n1_M2_48660_50820 n1_M2_49740_50820 0.988200
R5686 n1_M2_49740_50820 n1_M2_50820_50820 0.988200
R5687 n1_M2_50820_50820 n1_M2_51900_50820 0.988200
R5688 n1_M2_51900_50820 n1_M2_52980_50820 0.988200
R5689 n1_M2_52980_50820 n1_M2_54060_50820 0.988200
R5690 n1_M2_54060_50820 n1_M2_55140_50820 0.988200
R5691 n1_M2_55140_50820 n1_M2_56220_50820 0.988200
R5692 n1_M2_56220_50820 n1_M2_57300_50820 0.988200
R5693 n1_M2_57300_50820 n1_M2_58380_50820 0.988200
R5694 n1_M2_58380_50820 n1_M2_59460_50820 0.988200
R5695 n1_M2_59460_50820 n1_M2_60540_50820 0.988200
R5696 n1_M2_60540_50820 n1_M2_61620_50820 0.988200
R5697 n1_M2_61620_50820 n1_M2_62700_50820 0.988200
R5698 n1_M2_62700_50820 n1_M2_63780_50820 0.988200
R5699 n1_M2_63780_50820 n1_M2_64860_50820 0.988200
R5700 n1_M2_64860_50820 n1_M2_65940_50820 0.988200
R5701 n1_M2_65940_50820 n1_M2_67020_50820 0.988200
R5702 n1_M2_67020_50820 n1_M2_68100_50820 0.988200
R5703 n1_M2_68100_50820 n1_M2_69180_50820 0.988200
R5704 n1_M2_69180_50820 n1_M2_70260_50820 0.988200
R5705 n1_M2_70260_50820 n1_M2_71340_50820 0.988200
R5706 n1_M2_71340_50820 n1_M2_72420_50820 0.988200
R5707 n1_M2_72420_50820 n1_M2_73500_50820 0.988200
R5708 n1_M2_73500_50820 n1_M2_74580_50820 0.988200
R5709 n1_M2_74580_50820 n1_M2_75660_50820 0.988200
R5710 n1_M2_75660_50820 n1_M2_76740_50820 0.988200
R5711 n1_M2_76740_50820 n1_M2_77820_50820 0.988200
R5712 n1_M2_77820_50820 n1_M2_78900_50820 0.988200
R5713 n1_M2_78900_50820 n1_M2_79980_50820 0.988200
R5714 n1_M2_79980_50820 n1_M2_81060_50820 0.988200
R5715 n1_M2_81060_50820 n1_M2_82140_50820 0.988200
R5716 n1_M2_82140_50820 n1_M2_83220_50820 0.988200
R5717 n1_M2_83220_50820 n1_M2_84300_50820 0.988200
R5718 n1_M2_84300_50820 n1_M2_85380_50820 0.988200
R5719 n1_M2_85380_50820 n1_M2_86460_50820 0.988200
R5720 n1_M2_86460_50820 n1_M2_87540_50820 0.988200
R5721 n1_M2_87540_50820 n1_M2_88620_50820 0.988200
R5722 n1_M2_88620_50820 n1_M2_89700_50820 0.988200
R5723 n1_M2_89700_50820 n1_M2_90780_50820 0.988200
R5724 n1_M2_90780_50820 n1_M2_91860_50820 0.988200
R5725 n1_M2_91860_50820 n1_M2_92940_50820 0.988200
R5726 n1_M2_92940_50820 n1_M2_94020_50820 0.988200
R5727 n1_M2_94020_50820 n1_M2_95100_50820 0.988200
R5728 n1_M2_95100_50820 n1_M2_96180_50820 0.988200
R5729 n1_M2_96180_50820 n1_M2_97260_50820 0.988200
R5730 n1_M2_97260_50820 n1_M2_98340_50820 0.988200
R5731 n1_M2_98340_50820 n1_M2_99420_50820 0.988200
R5732 n1_M2_99420_50820 n1_M2_100500_50820 0.988200
R5733 n1_M2_100500_50820 n1_M2_101580_50820 0.988200
R5734 n1_M2_101580_50820 n1_M2_102660_50820 0.988200
R5735 n1_M2_102660_50820 n1_M2_103740_50820 0.988200
R5736 n1_M2_103740_50820 n1_M2_104820_50820 0.988200
R5737 n1_M2_104820_50820 n1_M2_105900_50820 0.988200
R5738 n1_M2_105900_50820 n1_M2_106980_50820 0.988200
R5739 n1_M2_106980_50820 n1_M2_108060_50820 0.988200
R5740 n1_M2_108060_50820 n1_M2_109140_50820 0.988200
R5741 n1_M2_109140_50820 n1_M2_110220_50820 0.988200
R5742 n1_M2_110220_50820 n1_M2_111300_50820 0.988200
R5743 n1_M2_111300_50820 n1_M2_112380_50820 0.988200
R5744 n1_M2_112380_50820 n1_M2_113460_50820 0.988200
R5745 n1_M2_113460_50820 n1_M2_114540_50820 0.988200
R5746 n1_M2_114540_50820 n1_M2_115620_50820 0.988200
R5747 n1_M2_115620_50820 n1_M2_116700_50820 0.988200
R5748 n1_M2_116700_50820 n1_M2_117780_50820 0.988200
R5749 n1_M2_117780_50820 n1_M2_118860_50820 0.988200
R5750 n1_M2_118860_50820 n1_M2_119940_50820 0.988200
R5751 n1_M2_119940_50820 n1_M2_121020_50820 0.988200
R5752 n1_M2_121020_50820 n1_M2_122100_50820 0.988200
R5753 n1_M2_122100_50820 n1_M2_123180_50820 0.988200
R5754 n1_M2_123180_50820 n1_M2_124260_50820 0.988200
R5755 n1_M2_124260_50820 n1_M2_125340_50820 0.988200
R5756 n1_M2_125340_50820 n1_M2_126420_50820 0.988200
R5757 n1_M2_126420_50820 n1_M2_127500_50820 0.988200
R5758 n1_M2_127500_50820 n1_M2_128580_50820 0.988200
R5759 n1_M2_128580_50820 n1_M2_129660_50820 0.988200
R5760 n1_M2_60_51900 n1_M2_1140_51900 0.988200
R5761 n1_M2_1140_51900 n1_M2_2220_51900 0.988200
R5762 n1_M2_2220_51900 n1_M2_3300_51900 0.988200
R5763 n1_M2_3300_51900 n1_M2_4380_51900 0.988200
R5764 n1_M2_4380_51900 n1_M2_5460_51900 0.988200
R5765 n1_M2_5460_51900 n1_M2_6540_51900 0.988200
R5766 n1_M2_6540_51900 n1_M2_7620_51900 0.988200
R5767 n1_M2_7620_51900 n1_M2_8700_51900 0.988200
R5768 n1_M2_8700_51900 n1_M2_9780_51900 0.988200
R5769 n1_M2_9780_51900 n1_M2_10860_51900 0.988200
R5770 n1_M2_10860_51900 n1_M2_11940_51900 0.988200
R5771 n1_M2_11940_51900 n1_M2_13020_51900 0.988200
R5772 n1_M2_13020_51900 n1_M2_14100_51900 0.988200
R5773 n1_M2_14100_51900 n1_M2_15180_51900 0.988200
R5774 n1_M2_15180_51900 n1_M2_16260_51900 0.988200
R5775 n1_M2_16260_51900 n1_M2_17340_51900 0.988200
R5776 n1_M2_17340_51900 n1_M2_18420_51900 0.988200
R5777 n1_M2_18420_51900 n1_M2_19500_51900 0.988200
R5778 n1_M2_19500_51900 n1_M2_20580_51900 0.988200
R5779 n1_M2_20580_51900 n1_M2_21660_51900 0.988200
R5780 n1_M2_21660_51900 n1_M2_22740_51900 0.988200
R5781 n1_M2_22740_51900 n1_M2_23820_51900 0.988200
R5782 n1_M2_23820_51900 n1_M2_24900_51900 0.988200
R5783 n1_M2_24900_51900 n1_M2_25980_51900 0.988200
R5784 n1_M2_25980_51900 n1_M2_27060_51900 0.988200
R5785 n1_M2_27060_51900 n1_M2_28140_51900 0.988200
R5786 n1_M2_28140_51900 n1_M2_29220_51900 0.988200
R5787 n1_M2_29220_51900 n1_M2_30300_51900 0.988200
R5788 n1_M2_30300_51900 n1_M2_31380_51900 0.988200
R5789 n1_M2_31380_51900 n1_M2_32460_51900 0.988200
R5790 n1_M2_32460_51900 n1_M2_33540_51900 0.988200
R5791 n1_M2_33540_51900 n1_M2_34620_51900 0.988200
R5792 n1_M2_34620_51900 n1_M2_35700_51900 0.988200
R5793 n1_M2_35700_51900 n1_M2_36780_51900 0.988200
R5794 n1_M2_36780_51900 n1_M2_37860_51900 0.988200
R5795 n1_M2_37860_51900 n1_M2_38940_51900 0.988200
R5796 n1_M2_38940_51900 n1_M2_40020_51900 0.988200
R5797 n1_M2_40020_51900 n1_M2_41100_51900 0.988200
R5798 n1_M2_41100_51900 n1_M2_42180_51900 0.988200
R5799 n1_M2_42180_51900 n1_M2_43260_51900 0.988200
R5800 n1_M2_43260_51900 n1_M2_44340_51900 0.988200
R5801 n1_M2_44340_51900 n1_M2_45420_51900 0.988200
R5802 n1_M2_45420_51900 n1_M2_46500_51900 0.988200
R5803 n1_M2_46500_51900 n1_M2_47580_51900 0.988200
R5804 n1_M2_47580_51900 n1_M2_48660_51900 0.988200
R5805 n1_M2_48660_51900 n1_M2_49740_51900 0.988200
R5806 n1_M2_49740_51900 n1_M2_50820_51900 0.988200
R5807 n1_M2_50820_51900 n1_M2_51900_51900 0.988200
R5808 n1_M2_51900_51900 n1_M2_52980_51900 0.988200
R5809 n1_M2_52980_51900 n1_M2_54060_51900 0.988200
R5810 n1_M2_54060_51900 n1_M2_55140_51900 0.988200
R5811 n1_M2_55140_51900 n1_M2_56220_51900 0.988200
R5812 n1_M2_56220_51900 n1_M2_57300_51900 0.988200
R5813 n1_M2_57300_51900 n1_M2_58380_51900 0.988200
R5814 n1_M2_58380_51900 n1_M2_59460_51900 0.988200
R5815 n1_M2_59460_51900 n1_M2_60540_51900 0.988200
R5816 n1_M2_60540_51900 n1_M2_61620_51900 0.988200
R5817 n1_M2_61620_51900 n1_M2_62700_51900 0.988200
R5818 n1_M2_62700_51900 n1_M2_63780_51900 0.988200
R5819 n1_M2_63780_51900 n1_M2_64860_51900 0.988200
R5820 n1_M2_64860_51900 n1_M2_65940_51900 0.988200
R5821 n1_M2_65940_51900 n1_M2_67020_51900 0.988200
R5822 n1_M2_67020_51900 n1_M2_68100_51900 0.988200
R5823 n1_M2_68100_51900 n1_M2_69180_51900 0.988200
R5824 n1_M2_69180_51900 n1_M2_70260_51900 0.988200
R5825 n1_M2_70260_51900 n1_M2_71340_51900 0.988200
R5826 n1_M2_71340_51900 n1_M2_72420_51900 0.988200
R5827 n1_M2_72420_51900 n1_M2_73500_51900 0.988200
R5828 n1_M2_73500_51900 n1_M2_74580_51900 0.988200
R5829 n1_M2_74580_51900 n1_M2_75660_51900 0.988200
R5830 n1_M2_75660_51900 n1_M2_76740_51900 0.988200
R5831 n1_M2_76740_51900 n1_M2_77820_51900 0.988200
R5832 n1_M2_77820_51900 n1_M2_78900_51900 0.988200
R5833 n1_M2_78900_51900 n1_M2_79980_51900 0.988200
R5834 n1_M2_79980_51900 n1_M2_81060_51900 0.988200
R5835 n1_M2_81060_51900 n1_M2_82140_51900 0.988200
R5836 n1_M2_82140_51900 n1_M2_83220_51900 0.988200
R5837 n1_M2_83220_51900 n1_M2_84300_51900 0.988200
R5838 n1_M2_84300_51900 n1_M2_85380_51900 0.988200
R5839 n1_M2_85380_51900 n1_M2_86460_51900 0.988200
R5840 n1_M2_86460_51900 n1_M2_87540_51900 0.988200
R5841 n1_M2_87540_51900 n1_M2_88620_51900 0.988200
R5842 n1_M2_88620_51900 n1_M2_89700_51900 0.988200
R5843 n1_M2_89700_51900 n1_M2_90780_51900 0.988200
R5844 n1_M2_90780_51900 n1_M2_91860_51900 0.988200
R5845 n1_M2_91860_51900 n1_M2_92940_51900 0.988200
R5846 n1_M2_92940_51900 n1_M2_94020_51900 0.988200
R5847 n1_M2_94020_51900 n1_M2_95100_51900 0.988200
R5848 n1_M2_95100_51900 n1_M2_96180_51900 0.988200
R5849 n1_M2_96180_51900 n1_M2_97260_51900 0.988200
R5850 n1_M2_97260_51900 n1_M2_98340_51900 0.988200
R5851 n1_M2_98340_51900 n1_M2_99420_51900 0.988200
R5852 n1_M2_99420_51900 n1_M2_100500_51900 0.988200
R5853 n1_M2_100500_51900 n1_M2_101580_51900 0.988200
R5854 n1_M2_101580_51900 n1_M2_102660_51900 0.988200
R5855 n1_M2_102660_51900 n1_M2_103740_51900 0.988200
R5856 n1_M2_103740_51900 n1_M2_104820_51900 0.988200
R5857 n1_M2_104820_51900 n1_M2_105900_51900 0.988200
R5858 n1_M2_105900_51900 n1_M2_106980_51900 0.988200
R5859 n1_M2_106980_51900 n1_M2_108060_51900 0.988200
R5860 n1_M2_108060_51900 n1_M2_109140_51900 0.988200
R5861 n1_M2_109140_51900 n1_M2_110220_51900 0.988200
R5862 n1_M2_110220_51900 n1_M2_111300_51900 0.988200
R5863 n1_M2_111300_51900 n1_M2_112380_51900 0.988200
R5864 n1_M2_112380_51900 n1_M2_113460_51900 0.988200
R5865 n1_M2_113460_51900 n1_M2_114540_51900 0.988200
R5866 n1_M2_114540_51900 n1_M2_115620_51900 0.988200
R5867 n1_M2_115620_51900 n1_M2_116700_51900 0.988200
R5868 n1_M2_116700_51900 n1_M2_117780_51900 0.988200
R5869 n1_M2_117780_51900 n1_M2_118860_51900 0.988200
R5870 n1_M2_118860_51900 n1_M2_119940_51900 0.988200
R5871 n1_M2_119940_51900 n1_M2_121020_51900 0.988200
R5872 n1_M2_121020_51900 n1_M2_122100_51900 0.988200
R5873 n1_M2_122100_51900 n1_M2_123180_51900 0.988200
R5874 n1_M2_123180_51900 n1_M2_124260_51900 0.988200
R5875 n1_M2_124260_51900 n1_M2_125340_51900 0.988200
R5876 n1_M2_125340_51900 n1_M2_126420_51900 0.988200
R5877 n1_M2_126420_51900 n1_M2_127500_51900 0.988200
R5878 n1_M2_127500_51900 n1_M2_128580_51900 0.988200
R5879 n1_M2_128580_51900 n1_M2_129660_51900 0.988200
R5880 n1_M2_60_52980 n1_M2_1140_52980 0.988200
R5881 n1_M2_1140_52980 n1_M2_2220_52980 0.988200
R5882 n1_M2_2220_52980 n1_M2_3300_52980 0.988200
R5883 n1_M2_3300_52980 n1_M2_4380_52980 0.988200
R5884 n1_M2_4380_52980 n1_M2_5460_52980 0.988200
R5885 n1_M2_5460_52980 n1_M2_6540_52980 0.988200
R5886 n1_M2_6540_52980 n1_M2_7620_52980 0.988200
R5887 n1_M2_7620_52980 n1_M2_8700_52980 0.988200
R5888 n1_M2_8700_52980 n1_M2_9780_52980 0.988200
R5889 n1_M2_9780_52980 n1_M2_10860_52980 0.988200
R5890 n1_M2_10860_52980 n1_M2_11940_52980 0.988200
R5891 n1_M2_11940_52980 n1_M2_13020_52980 0.988200
R5892 n1_M2_13020_52980 n1_M2_14100_52980 0.988200
R5893 n1_M2_14100_52980 n1_M2_15180_52980 0.988200
R5894 n1_M2_15180_52980 n1_M2_16260_52980 0.988200
R5895 n1_M2_16260_52980 n1_M2_17340_52980 0.988200
R5896 n1_M2_17340_52980 n1_M2_18420_52980 0.988200
R5897 n1_M2_18420_52980 n1_M2_19500_52980 0.988200
R5898 n1_M2_19500_52980 n1_M2_20580_52980 0.988200
R5899 n1_M2_20580_52980 n1_M2_21660_52980 0.988200
R5900 n1_M2_21660_52980 n1_M2_22740_52980 0.988200
R5901 n1_M2_22740_52980 n1_M2_23820_52980 0.988200
R5902 n1_M2_23820_52980 n1_M2_24900_52980 0.988200
R5903 n1_M2_24900_52980 n1_M2_25980_52980 0.988200
R5904 n1_M2_25980_52980 n1_M2_27060_52980 0.988200
R5905 n1_M2_27060_52980 n1_M2_28140_52980 0.988200
R5906 n1_M2_28140_52980 n1_M2_29220_52980 0.988200
R5907 n1_M2_29220_52980 n1_M2_30300_52980 0.988200
R5908 n1_M2_30300_52980 n1_M2_31380_52980 0.988200
R5909 n1_M2_31380_52980 n1_M2_32460_52980 0.988200
R5910 n1_M2_32460_52980 n1_M2_33540_52980 0.988200
R5911 n1_M2_33540_52980 n1_M2_34620_52980 0.988200
R5912 n1_M2_34620_52980 n1_M2_35700_52980 0.988200
R5913 n1_M2_35700_52980 n1_M2_36780_52980 0.988200
R5914 n1_M2_36780_52980 n1_M2_37860_52980 0.988200
R5915 n1_M2_37860_52980 n1_M2_38940_52980 0.988200
R5916 n1_M2_38940_52980 n1_M2_40020_52980 0.988200
R5917 n1_M2_40020_52980 n1_M2_41100_52980 0.988200
R5918 n1_M2_41100_52980 n1_M2_42180_52980 0.988200
R5919 n1_M2_42180_52980 n1_M2_43260_52980 0.988200
R5920 n1_M2_43260_52980 n1_M2_44340_52980 0.988200
R5921 n1_M2_44340_52980 n1_M2_45420_52980 0.988200
R5922 n1_M2_45420_52980 n1_M2_46500_52980 0.988200
R5923 n1_M2_46500_52980 n1_M2_47580_52980 0.988200
R5924 n1_M2_47580_52980 n1_M2_48660_52980 0.988200
R5925 n1_M2_48660_52980 n1_M2_49740_52980 0.988200
R5926 n1_M2_49740_52980 n1_M2_50820_52980 0.988200
R5927 n1_M2_50820_52980 n1_M2_51900_52980 0.988200
R5928 n1_M2_51900_52980 n1_M2_52980_52980 0.988200
R5929 n1_M2_52980_52980 n1_M2_54060_52980 0.988200
R5930 n1_M2_54060_52980 n1_M2_55140_52980 0.988200
R5931 n1_M2_55140_52980 n1_M2_56220_52980 0.988200
R5932 n1_M2_56220_52980 n1_M2_57300_52980 0.988200
R5933 n1_M2_57300_52980 n1_M2_58380_52980 0.988200
R5934 n1_M2_58380_52980 n1_M2_59460_52980 0.988200
R5935 n1_M2_59460_52980 n1_M2_60540_52980 0.988200
R5936 n1_M2_60540_52980 n1_M2_61620_52980 0.988200
R5937 n1_M2_61620_52980 n1_M2_62700_52980 0.988200
R5938 n1_M2_62700_52980 n1_M2_63780_52980 0.988200
R5939 n1_M2_63780_52980 n1_M2_64860_52980 0.988200
R5940 n1_M2_64860_52980 n1_M2_65940_52980 0.988200
R5941 n1_M2_65940_52980 n1_M2_67020_52980 0.988200
R5942 n1_M2_67020_52980 n1_M2_68100_52980 0.988200
R5943 n1_M2_68100_52980 n1_M2_69180_52980 0.988200
R5944 n1_M2_69180_52980 n1_M2_70260_52980 0.988200
R5945 n1_M2_70260_52980 n1_M2_71340_52980 0.988200
R5946 n1_M2_71340_52980 n1_M2_72420_52980 0.988200
R5947 n1_M2_72420_52980 n1_M2_73500_52980 0.988200
R5948 n1_M2_73500_52980 n1_M2_74580_52980 0.988200
R5949 n1_M2_74580_52980 n1_M2_75660_52980 0.988200
R5950 n1_M2_75660_52980 n1_M2_76740_52980 0.988200
R5951 n1_M2_76740_52980 n1_M2_77820_52980 0.988200
R5952 n1_M2_77820_52980 n1_M2_78900_52980 0.988200
R5953 n1_M2_78900_52980 n1_M2_79980_52980 0.988200
R5954 n1_M2_79980_52980 n1_M2_81060_52980 0.988200
R5955 n1_M2_81060_52980 n1_M2_82140_52980 0.988200
R5956 n1_M2_82140_52980 n1_M2_83220_52980 0.988200
R5957 n1_M2_83220_52980 n1_M2_84300_52980 0.988200
R5958 n1_M2_84300_52980 n1_M2_85380_52980 0.988200
R5959 n1_M2_85380_52980 n1_M2_86460_52980 0.988200
R5960 n1_M2_86460_52980 n1_M2_87540_52980 0.988200
R5961 n1_M2_87540_52980 n1_M2_88620_52980 0.988200
R5962 n1_M2_88620_52980 n1_M2_89700_52980 0.988200
R5963 n1_M2_89700_52980 n1_M2_90780_52980 0.988200
R5964 n1_M2_90780_52980 n1_M2_91860_52980 0.988200
R5965 n1_M2_91860_52980 n1_M2_92940_52980 0.988200
R5966 n1_M2_92940_52980 n1_M2_94020_52980 0.988200
R5967 n1_M2_94020_52980 n1_M2_95100_52980 0.988200
R5968 n1_M2_95100_52980 n1_M2_96180_52980 0.988200
R5969 n1_M2_96180_52980 n1_M2_97260_52980 0.988200
R5970 n1_M2_97260_52980 n1_M2_98340_52980 0.988200
R5971 n1_M2_98340_52980 n1_M2_99420_52980 0.988200
R5972 n1_M2_99420_52980 n1_M2_100500_52980 0.988200
R5973 n1_M2_100500_52980 n1_M2_101580_52980 0.988200
R5974 n1_M2_101580_52980 n1_M2_102660_52980 0.988200
R5975 n1_M2_102660_52980 n1_M2_103740_52980 0.988200
R5976 n1_M2_103740_52980 n1_M2_104820_52980 0.988200
R5977 n1_M2_104820_52980 n1_M2_105900_52980 0.988200
R5978 n1_M2_105900_52980 n1_M2_106980_52980 0.988200
R5979 n1_M2_106980_52980 n1_M2_108060_52980 0.988200
R5980 n1_M2_108060_52980 n1_M2_109140_52980 0.988200
R5981 n1_M2_109140_52980 n1_M2_110220_52980 0.988200
R5982 n1_M2_110220_52980 n1_M2_111300_52980 0.988200
R5983 n1_M2_111300_52980 n1_M2_112380_52980 0.988200
R5984 n1_M2_112380_52980 n1_M2_113460_52980 0.988200
R5985 n1_M2_113460_52980 n1_M2_114540_52980 0.988200
R5986 n1_M2_114540_52980 n1_M2_115620_52980 0.988200
R5987 n1_M2_115620_52980 n1_M2_116700_52980 0.988200
R5988 n1_M2_116700_52980 n1_M2_117780_52980 0.988200
R5989 n1_M2_117780_52980 n1_M2_118860_52980 0.988200
R5990 n1_M2_118860_52980 n1_M2_119940_52980 0.988200
R5991 n1_M2_119940_52980 n1_M2_121020_52980 0.988200
R5992 n1_M2_121020_52980 n1_M2_122100_52980 0.988200
R5993 n1_M2_122100_52980 n1_M2_123180_52980 0.988200
R5994 n1_M2_123180_52980 n1_M2_124260_52980 0.988200
R5995 n1_M2_124260_52980 n1_M2_125340_52980 0.988200
R5996 n1_M2_125340_52980 n1_M2_126420_52980 0.988200
R5997 n1_M2_126420_52980 n1_M2_127500_52980 0.988200
R5998 n1_M2_127500_52980 n1_M2_128580_52980 0.988200
R5999 n1_M2_128580_52980 n1_M2_129660_52980 0.988200
R6000 n1_M2_60_54060 n1_M2_1140_54060 0.988200
R6001 n1_M2_1140_54060 n1_M2_2220_54060 0.988200
R6002 n1_M2_2220_54060 n1_M2_3300_54060 0.988200
R6003 n1_M2_3300_54060 n1_M2_4380_54060 0.988200
R6004 n1_M2_4380_54060 n1_M2_5460_54060 0.988200
R6005 n1_M2_5460_54060 n1_M2_6540_54060 0.988200
R6006 n1_M2_6540_54060 n1_M2_7620_54060 0.988200
R6007 n1_M2_7620_54060 n1_M2_8700_54060 0.988200
R6008 n1_M2_8700_54060 n1_M2_9780_54060 0.988200
R6009 n1_M2_9780_54060 n1_M2_10860_54060 0.988200
R6010 n1_M2_10860_54060 n1_M2_11940_54060 0.988200
R6011 n1_M2_11940_54060 n1_M2_13020_54060 0.988200
R6012 n1_M2_13020_54060 n1_M2_14100_54060 0.988200
R6013 n1_M2_14100_54060 n1_M2_15180_54060 0.988200
R6014 n1_M2_15180_54060 n1_M2_16260_54060 0.988200
R6015 n1_M2_16260_54060 n1_M2_17340_54060 0.988200
R6016 n1_M2_17340_54060 n1_M2_18420_54060 0.988200
R6017 n1_M2_18420_54060 n1_M2_19500_54060 0.988200
R6018 n1_M2_19500_54060 n1_M2_20580_54060 0.988200
R6019 n1_M2_20580_54060 n1_M2_21660_54060 0.988200
R6020 n1_M2_21660_54060 n1_M2_22740_54060 0.988200
R6021 n1_M2_22740_54060 n1_M2_23820_54060 0.988200
R6022 n1_M2_23820_54060 n1_M2_24900_54060 0.988200
R6023 n1_M2_24900_54060 n1_M2_25980_54060 0.988200
R6024 n1_M2_25980_54060 n1_M2_27060_54060 0.988200
R6025 n1_M2_27060_54060 n1_M2_28140_54060 0.988200
R6026 n1_M2_28140_54060 n1_M2_29220_54060 0.988200
R6027 n1_M2_29220_54060 n1_M2_30300_54060 0.988200
R6028 n1_M2_30300_54060 n1_M2_31380_54060 0.988200
R6029 n1_M2_31380_54060 n1_M2_32460_54060 0.988200
R6030 n1_M2_32460_54060 n1_M2_33540_54060 0.988200
R6031 n1_M2_33540_54060 n1_M2_34620_54060 0.988200
R6032 n1_M2_34620_54060 n1_M2_35700_54060 0.988200
R6033 n1_M2_35700_54060 n1_M2_36780_54060 0.988200
R6034 n1_M2_36780_54060 n1_M2_37860_54060 0.988200
R6035 n1_M2_37860_54060 n1_M2_38940_54060 0.988200
R6036 n1_M2_38940_54060 n1_M2_40020_54060 0.988200
R6037 n1_M2_40020_54060 n1_M2_41100_54060 0.988200
R6038 n1_M2_41100_54060 n1_M2_42180_54060 0.988200
R6039 n1_M2_42180_54060 n1_M2_43260_54060 0.988200
R6040 n1_M2_43260_54060 n1_M2_44340_54060 0.988200
R6041 n1_M2_44340_54060 n1_M2_45420_54060 0.988200
R6042 n1_M2_45420_54060 n1_M2_46500_54060 0.988200
R6043 n1_M2_46500_54060 n1_M2_47580_54060 0.988200
R6044 n1_M2_47580_54060 n1_M2_48660_54060 0.988200
R6045 n1_M2_48660_54060 n1_M2_49740_54060 0.988200
R6046 n1_M2_49740_54060 n1_M2_50820_54060 0.988200
R6047 n1_M2_50820_54060 n1_M2_51900_54060 0.988200
R6048 n1_M2_51900_54060 n1_M2_52980_54060 0.988200
R6049 n1_M2_52980_54060 n1_M2_54060_54060 0.988200
R6050 n1_M2_54060_54060 n1_M2_55140_54060 0.988200
R6051 n1_M2_55140_54060 n1_M2_56220_54060 0.988200
R6052 n1_M2_56220_54060 n1_M2_57300_54060 0.988200
R6053 n1_M2_57300_54060 n1_M2_58380_54060 0.988200
R6054 n1_M2_58380_54060 n1_M2_59460_54060 0.988200
R6055 n1_M2_59460_54060 n1_M2_60540_54060 0.988200
R6056 n1_M2_60540_54060 n1_M2_61620_54060 0.988200
R6057 n1_M2_61620_54060 n1_M2_62700_54060 0.988200
R6058 n1_M2_62700_54060 n1_M2_63780_54060 0.988200
R6059 n1_M2_63780_54060 n1_M2_64860_54060 0.988200
R6060 n1_M2_64860_54060 n1_M2_65940_54060 0.988200
R6061 n1_M2_65940_54060 n1_M2_67020_54060 0.988200
R6062 n1_M2_67020_54060 n1_M2_68100_54060 0.988200
R6063 n1_M2_68100_54060 n1_M2_69180_54060 0.988200
R6064 n1_M2_69180_54060 n1_M2_70260_54060 0.988200
R6065 n1_M2_70260_54060 n1_M2_71340_54060 0.988200
R6066 n1_M2_71340_54060 n1_M2_72420_54060 0.988200
R6067 n1_M2_72420_54060 n1_M2_73500_54060 0.988200
R6068 n1_M2_73500_54060 n1_M2_74580_54060 0.988200
R6069 n1_M2_74580_54060 n1_M2_75660_54060 0.988200
R6070 n1_M2_75660_54060 n1_M2_76740_54060 0.988200
R6071 n1_M2_76740_54060 n1_M2_77820_54060 0.988200
R6072 n1_M2_77820_54060 n1_M2_78900_54060 0.988200
R6073 n1_M2_78900_54060 n1_M2_79980_54060 0.988200
R6074 n1_M2_79980_54060 n1_M2_81060_54060 0.988200
R6075 n1_M2_81060_54060 n1_M2_82140_54060 0.988200
R6076 n1_M2_82140_54060 n1_M2_83220_54060 0.988200
R6077 n1_M2_83220_54060 n1_M2_84300_54060 0.988200
R6078 n1_M2_84300_54060 n1_M2_85380_54060 0.988200
R6079 n1_M2_85380_54060 n1_M2_86460_54060 0.988200
R6080 n1_M2_86460_54060 n1_M2_87540_54060 0.988200
R6081 n1_M2_87540_54060 n1_M2_88620_54060 0.988200
R6082 n1_M2_88620_54060 n1_M2_89700_54060 0.988200
R6083 n1_M2_89700_54060 n1_M2_90780_54060 0.988200
R6084 n1_M2_90780_54060 n1_M2_91860_54060 0.988200
R6085 n1_M2_91860_54060 n1_M2_92940_54060 0.988200
R6086 n1_M2_92940_54060 n1_M2_94020_54060 0.988200
R6087 n1_M2_94020_54060 n1_M2_95100_54060 0.988200
R6088 n1_M2_95100_54060 n1_M2_96180_54060 0.988200
R6089 n1_M2_96180_54060 n1_M2_97260_54060 0.988200
R6090 n1_M2_97260_54060 n1_M2_98340_54060 0.988200
R6091 n1_M2_98340_54060 n1_M2_99420_54060 0.988200
R6092 n1_M2_99420_54060 n1_M2_100500_54060 0.988200
R6093 n1_M2_100500_54060 n1_M2_101580_54060 0.988200
R6094 n1_M2_101580_54060 n1_M2_102660_54060 0.988200
R6095 n1_M2_102660_54060 n1_M2_103740_54060 0.988200
R6096 n1_M2_103740_54060 n1_M2_104820_54060 0.988200
R6097 n1_M2_104820_54060 n1_M2_105900_54060 0.988200
R6098 n1_M2_105900_54060 n1_M2_106980_54060 0.988200
R6099 n1_M2_106980_54060 n1_M2_108060_54060 0.988200
R6100 n1_M2_108060_54060 n1_M2_109140_54060 0.988200
R6101 n1_M2_109140_54060 n1_M2_110220_54060 0.988200
R6102 n1_M2_110220_54060 n1_M2_111300_54060 0.988200
R6103 n1_M2_111300_54060 n1_M2_112380_54060 0.988200
R6104 n1_M2_112380_54060 n1_M2_113460_54060 0.988200
R6105 n1_M2_113460_54060 n1_M2_114540_54060 0.988200
R6106 n1_M2_114540_54060 n1_M2_115620_54060 0.988200
R6107 n1_M2_115620_54060 n1_M2_116700_54060 0.988200
R6108 n1_M2_116700_54060 n1_M2_117780_54060 0.988200
R6109 n1_M2_117780_54060 n1_M2_118860_54060 0.988200
R6110 n1_M2_118860_54060 n1_M2_119940_54060 0.988200
R6111 n1_M2_119940_54060 n1_M2_121020_54060 0.988200
R6112 n1_M2_121020_54060 n1_M2_122100_54060 0.988200
R6113 n1_M2_122100_54060 n1_M2_123180_54060 0.988200
R6114 n1_M2_123180_54060 n1_M2_124260_54060 0.988200
R6115 n1_M2_124260_54060 n1_M2_125340_54060 0.988200
R6116 n1_M2_125340_54060 n1_M2_126420_54060 0.988200
R6117 n1_M2_126420_54060 n1_M2_127500_54060 0.988200
R6118 n1_M2_127500_54060 n1_M2_128580_54060 0.988200
R6119 n1_M2_128580_54060 n1_M2_129660_54060 0.988200
R6120 n1_M2_60_55140 n1_M2_1140_55140 0.988200
R6121 n1_M2_1140_55140 n1_M2_2220_55140 0.988200
R6122 n1_M2_2220_55140 n1_M2_3300_55140 0.988200
R6123 n1_M2_3300_55140 n1_M2_4380_55140 0.988200
R6124 n1_M2_4380_55140 n1_M2_5460_55140 0.988200
R6125 n1_M2_5460_55140 n1_M2_6540_55140 0.988200
R6126 n1_M2_6540_55140 n1_M2_7620_55140 0.988200
R6127 n1_M2_7620_55140 n1_M2_8700_55140 0.988200
R6128 n1_M2_8700_55140 n1_M2_9780_55140 0.988200
R6129 n1_M2_9780_55140 n1_M2_10860_55140 0.988200
R6130 n1_M2_10860_55140 n1_M2_11940_55140 0.988200
R6131 n1_M2_11940_55140 n1_M2_13020_55140 0.988200
R6132 n1_M2_13020_55140 n1_M2_14100_55140 0.988200
R6133 n1_M2_14100_55140 n1_M2_15180_55140 0.988200
R6134 n1_M2_15180_55140 n1_M2_16260_55140 0.988200
R6135 n1_M2_16260_55140 n1_M2_17340_55140 0.988200
R6136 n1_M2_17340_55140 n1_M2_18420_55140 0.988200
R6137 n1_M2_18420_55140 n1_M2_19500_55140 0.988200
R6138 n1_M2_19500_55140 n1_M2_20580_55140 0.988200
R6139 n1_M2_20580_55140 n1_M2_21660_55140 0.988200
R6140 n1_M2_21660_55140 n1_M2_22740_55140 0.988200
R6141 n1_M2_22740_55140 n1_M2_23820_55140 0.988200
R6142 n1_M2_23820_55140 n1_M2_24900_55140 0.988200
R6143 n1_M2_24900_55140 n1_M2_25980_55140 0.988200
R6144 n1_M2_25980_55140 n1_M2_27060_55140 0.988200
R6145 n1_M2_27060_55140 n1_M2_28140_55140 0.988200
R6146 n1_M2_28140_55140 n1_M2_29220_55140 0.988200
R6147 n1_M2_29220_55140 n1_M2_30300_55140 0.988200
R6148 n1_M2_30300_55140 n1_M2_31380_55140 0.988200
R6149 n1_M2_31380_55140 n1_M2_32460_55140 0.988200
R6150 n1_M2_32460_55140 n1_M2_33540_55140 0.988200
R6151 n1_M2_33540_55140 n1_M2_34620_55140 0.988200
R6152 n1_M2_34620_55140 n1_M2_35700_55140 0.988200
R6153 n1_M2_35700_55140 n1_M2_36780_55140 0.988200
R6154 n1_M2_36780_55140 n1_M2_37860_55140 0.988200
R6155 n1_M2_37860_55140 n1_M2_38940_55140 0.988200
R6156 n1_M2_38940_55140 n1_M2_40020_55140 0.988200
R6157 n1_M2_40020_55140 n1_M2_41100_55140 0.988200
R6158 n1_M2_41100_55140 n1_M2_42180_55140 0.988200
R6159 n1_M2_42180_55140 n1_M2_43260_55140 0.988200
R6160 n1_M2_43260_55140 n1_M2_44340_55140 0.988200
R6161 n1_M2_44340_55140 n1_M2_45420_55140 0.988200
R6162 n1_M2_45420_55140 n1_M2_46500_55140 0.988200
R6163 n1_M2_46500_55140 n1_M2_47580_55140 0.988200
R6164 n1_M2_47580_55140 n1_M2_48660_55140 0.988200
R6165 n1_M2_48660_55140 n1_M2_49740_55140 0.988200
R6166 n1_M2_49740_55140 n1_M2_50820_55140 0.988200
R6167 n1_M2_50820_55140 n1_M2_51900_55140 0.988200
R6168 n1_M2_51900_55140 n1_M2_52980_55140 0.988200
R6169 n1_M2_52980_55140 n1_M2_54060_55140 0.988200
R6170 n1_M2_54060_55140 n1_M2_55140_55140 0.988200
R6171 n1_M2_55140_55140 n1_M2_56220_55140 0.988200
R6172 n1_M2_56220_55140 n1_M2_57300_55140 0.988200
R6173 n1_M2_57300_55140 n1_M2_58380_55140 0.988200
R6174 n1_M2_58380_55140 n1_M2_59460_55140 0.988200
R6175 n1_M2_59460_55140 n1_M2_60540_55140 0.988200
R6176 n1_M2_60540_55140 n1_M2_61620_55140 0.988200
R6177 n1_M2_61620_55140 n1_M2_62700_55140 0.988200
R6178 n1_M2_62700_55140 n1_M2_63780_55140 0.988200
R6179 n1_M2_63780_55140 n1_M2_64860_55140 0.988200
R6180 n1_M2_64860_55140 n1_M2_65940_55140 0.988200
R6181 n1_M2_65940_55140 n1_M2_67020_55140 0.988200
R6182 n1_M2_67020_55140 n1_M2_68100_55140 0.988200
R6183 n1_M2_68100_55140 n1_M2_69180_55140 0.988200
R6184 n1_M2_69180_55140 n1_M2_70260_55140 0.988200
R6185 n1_M2_70260_55140 n1_M2_71340_55140 0.988200
R6186 n1_M2_71340_55140 n1_M2_72420_55140 0.988200
R6187 n1_M2_72420_55140 n1_M2_73500_55140 0.988200
R6188 n1_M2_73500_55140 n1_M2_74580_55140 0.988200
R6189 n1_M2_74580_55140 n1_M2_75660_55140 0.988200
R6190 n1_M2_75660_55140 n1_M2_76740_55140 0.988200
R6191 n1_M2_76740_55140 n1_M2_77820_55140 0.988200
R6192 n1_M2_77820_55140 n1_M2_78900_55140 0.988200
R6193 n1_M2_78900_55140 n1_M2_79980_55140 0.988200
R6194 n1_M2_79980_55140 n1_M2_81060_55140 0.988200
R6195 n1_M2_81060_55140 n1_M2_82140_55140 0.988200
R6196 n1_M2_82140_55140 n1_M2_83220_55140 0.988200
R6197 n1_M2_83220_55140 n1_M2_84300_55140 0.988200
R6198 n1_M2_84300_55140 n1_M2_85380_55140 0.988200
R6199 n1_M2_85380_55140 n1_M2_86460_55140 0.988200
R6200 n1_M2_86460_55140 n1_M2_87540_55140 0.988200
R6201 n1_M2_87540_55140 n1_M2_88620_55140 0.988200
R6202 n1_M2_88620_55140 n1_M2_89700_55140 0.988200
R6203 n1_M2_89700_55140 n1_M2_90780_55140 0.988200
R6204 n1_M2_90780_55140 n1_M2_91860_55140 0.988200
R6205 n1_M2_91860_55140 n1_M2_92940_55140 0.988200
R6206 n1_M2_92940_55140 n1_M2_94020_55140 0.988200
R6207 n1_M2_94020_55140 n1_M2_95100_55140 0.988200
R6208 n1_M2_95100_55140 n1_M2_96180_55140 0.988200
R6209 n1_M2_96180_55140 n1_M2_97260_55140 0.988200
R6210 n1_M2_97260_55140 n1_M2_98340_55140 0.988200
R6211 n1_M2_98340_55140 n1_M2_99420_55140 0.988200
R6212 n1_M2_99420_55140 n1_M2_100500_55140 0.988200
R6213 n1_M2_100500_55140 n1_M2_101580_55140 0.988200
R6214 n1_M2_101580_55140 n1_M2_102660_55140 0.988200
R6215 n1_M2_102660_55140 n1_M2_103740_55140 0.988200
R6216 n1_M2_103740_55140 n1_M2_104820_55140 0.988200
R6217 n1_M2_104820_55140 n1_M2_105900_55140 0.988200
R6218 n1_M2_105900_55140 n1_M2_106980_55140 0.988200
R6219 n1_M2_106980_55140 n1_M2_108060_55140 0.988200
R6220 n1_M2_108060_55140 n1_M2_109140_55140 0.988200
R6221 n1_M2_109140_55140 n1_M2_110220_55140 0.988200
R6222 n1_M2_110220_55140 n1_M2_111300_55140 0.988200
R6223 n1_M2_111300_55140 n1_M2_112380_55140 0.988200
R6224 n1_M2_112380_55140 n1_M2_113460_55140 0.988200
R6225 n1_M2_113460_55140 n1_M2_114540_55140 0.988200
R6226 n1_M2_114540_55140 n1_M2_115620_55140 0.988200
R6227 n1_M2_115620_55140 n1_M2_116700_55140 0.988200
R6228 n1_M2_116700_55140 n1_M2_117780_55140 0.988200
R6229 n1_M2_117780_55140 n1_M2_118860_55140 0.988200
R6230 n1_M2_118860_55140 n1_M2_119940_55140 0.988200
R6231 n1_M2_119940_55140 n1_M2_121020_55140 0.988200
R6232 n1_M2_121020_55140 n1_M2_122100_55140 0.988200
R6233 n1_M2_122100_55140 n1_M2_123180_55140 0.988200
R6234 n1_M2_123180_55140 n1_M2_124260_55140 0.988200
R6235 n1_M2_124260_55140 n1_M2_125340_55140 0.988200
R6236 n1_M2_125340_55140 n1_M2_126420_55140 0.988200
R6237 n1_M2_126420_55140 n1_M2_127500_55140 0.988200
R6238 n1_M2_127500_55140 n1_M2_128580_55140 0.988200
R6239 n1_M2_128580_55140 n1_M2_129660_55140 0.988200
R6240 n1_M2_60_56220 n1_M2_1140_56220 0.988200
R6241 n1_M2_1140_56220 n1_M2_2220_56220 0.988200
R6242 n1_M2_2220_56220 n1_M2_3300_56220 0.988200
R6243 n1_M2_3300_56220 n1_M2_4380_56220 0.988200
R6244 n1_M2_4380_56220 n1_M2_5460_56220 0.988200
R6245 n1_M2_5460_56220 n1_M2_6540_56220 0.988200
R6246 n1_M2_6540_56220 n1_M2_7620_56220 0.988200
R6247 n1_M2_7620_56220 n1_M2_8700_56220 0.988200
R6248 n1_M2_8700_56220 n1_M2_9780_56220 0.988200
R6249 n1_M2_9780_56220 n1_M2_10860_56220 0.988200
R6250 n1_M2_10860_56220 n1_M2_11940_56220 0.988200
R6251 n1_M2_11940_56220 n1_M2_13020_56220 0.988200
R6252 n1_M2_13020_56220 n1_M2_14100_56220 0.988200
R6253 n1_M2_14100_56220 n1_M2_15180_56220 0.988200
R6254 n1_M2_15180_56220 n1_M2_16260_56220 0.988200
R6255 n1_M2_16260_56220 n1_M2_17340_56220 0.988200
R6256 n1_M2_17340_56220 n1_M2_18420_56220 0.988200
R6257 n1_M2_18420_56220 n1_M2_19500_56220 0.988200
R6258 n1_M2_19500_56220 n1_M2_20580_56220 0.988200
R6259 n1_M2_20580_56220 n1_M2_21660_56220 0.988200
R6260 n1_M2_21660_56220 n1_M2_22740_56220 0.988200
R6261 n1_M2_22740_56220 n1_M2_23820_56220 0.988200
R6262 n1_M2_23820_56220 n1_M2_24900_56220 0.988200
R6263 n1_M2_24900_56220 n1_M2_25980_56220 0.988200
R6264 n1_M2_25980_56220 n1_M2_27060_56220 0.988200
R6265 n1_M2_27060_56220 n1_M2_28140_56220 0.988200
R6266 n1_M2_28140_56220 n1_M2_29220_56220 0.988200
R6267 n1_M2_29220_56220 n1_M2_30300_56220 0.988200
R6268 n1_M2_30300_56220 n1_M2_31380_56220 0.988200
R6269 n1_M2_31380_56220 n1_M2_32460_56220 0.988200
R6270 n1_M2_32460_56220 n1_M2_33540_56220 0.988200
R6271 n1_M2_33540_56220 n1_M2_34620_56220 0.988200
R6272 n1_M2_34620_56220 n1_M2_35700_56220 0.988200
R6273 n1_M2_35700_56220 n1_M2_36780_56220 0.988200
R6274 n1_M2_36780_56220 n1_M2_37860_56220 0.988200
R6275 n1_M2_37860_56220 n1_M2_38940_56220 0.988200
R6276 n1_M2_38940_56220 n1_M2_40020_56220 0.988200
R6277 n1_M2_40020_56220 n1_M2_41100_56220 0.988200
R6278 n1_M2_41100_56220 n1_M2_42180_56220 0.988200
R6279 n1_M2_42180_56220 n1_M2_43260_56220 0.988200
R6280 n1_M2_43260_56220 n1_M2_44340_56220 0.988200
R6281 n1_M2_44340_56220 n1_M2_45420_56220 0.988200
R6282 n1_M2_45420_56220 n1_M2_46500_56220 0.988200
R6283 n1_M2_46500_56220 n1_M2_47580_56220 0.988200
R6284 n1_M2_47580_56220 n1_M2_48660_56220 0.988200
R6285 n1_M2_48660_56220 n1_M2_49740_56220 0.988200
R6286 n1_M2_49740_56220 n1_M2_50820_56220 0.988200
R6287 n1_M2_50820_56220 n1_M2_51900_56220 0.988200
R6288 n1_M2_51900_56220 n1_M2_52980_56220 0.988200
R6289 n1_M2_52980_56220 n1_M2_54060_56220 0.988200
R6290 n1_M2_54060_56220 n1_M2_55140_56220 0.988200
R6291 n1_M2_55140_56220 n1_M2_56220_56220 0.988200
R6292 n1_M2_56220_56220 n1_M2_57300_56220 0.988200
R6293 n1_M2_57300_56220 n1_M2_58380_56220 0.988200
R6294 n1_M2_58380_56220 n1_M2_59460_56220 0.988200
R6295 n1_M2_59460_56220 n1_M2_60540_56220 0.988200
R6296 n1_M2_60540_56220 n1_M2_61620_56220 0.988200
R6297 n1_M2_61620_56220 n1_M2_62700_56220 0.988200
R6298 n1_M2_62700_56220 n1_M2_63780_56220 0.988200
R6299 n1_M2_63780_56220 n1_M2_64860_56220 0.988200
R6300 n1_M2_64860_56220 n1_M2_65940_56220 0.988200
R6301 n1_M2_65940_56220 n1_M2_67020_56220 0.988200
R6302 n1_M2_67020_56220 n1_M2_68100_56220 0.988200
R6303 n1_M2_68100_56220 n1_M2_69180_56220 0.988200
R6304 n1_M2_69180_56220 n1_M2_70260_56220 0.988200
R6305 n1_M2_70260_56220 n1_M2_71340_56220 0.988200
R6306 n1_M2_71340_56220 n1_M2_72420_56220 0.988200
R6307 n1_M2_72420_56220 n1_M2_73500_56220 0.988200
R6308 n1_M2_73500_56220 n1_M2_74580_56220 0.988200
R6309 n1_M2_74580_56220 n1_M2_75660_56220 0.988200
R6310 n1_M2_75660_56220 n1_M2_76740_56220 0.988200
R6311 n1_M2_76740_56220 n1_M2_77820_56220 0.988200
R6312 n1_M2_77820_56220 n1_M2_78900_56220 0.988200
R6313 n1_M2_78900_56220 n1_M2_79980_56220 0.988200
R6314 n1_M2_79980_56220 n1_M2_81060_56220 0.988200
R6315 n1_M2_81060_56220 n1_M2_82140_56220 0.988200
R6316 n1_M2_82140_56220 n1_M2_83220_56220 0.988200
R6317 n1_M2_83220_56220 n1_M2_84300_56220 0.988200
R6318 n1_M2_84300_56220 n1_M2_85380_56220 0.988200
R6319 n1_M2_85380_56220 n1_M2_86460_56220 0.988200
R6320 n1_M2_86460_56220 n1_M2_87540_56220 0.988200
R6321 n1_M2_87540_56220 n1_M2_88620_56220 0.988200
R6322 n1_M2_88620_56220 n1_M2_89700_56220 0.988200
R6323 n1_M2_89700_56220 n1_M2_90780_56220 0.988200
R6324 n1_M2_90780_56220 n1_M2_91860_56220 0.988200
R6325 n1_M2_91860_56220 n1_M2_92940_56220 0.988200
R6326 n1_M2_92940_56220 n1_M2_94020_56220 0.988200
R6327 n1_M2_94020_56220 n1_M2_95100_56220 0.988200
R6328 n1_M2_95100_56220 n1_M2_96180_56220 0.988200
R6329 n1_M2_96180_56220 n1_M2_97260_56220 0.988200
R6330 n1_M2_97260_56220 n1_M2_98340_56220 0.988200
R6331 n1_M2_98340_56220 n1_M2_99420_56220 0.988200
R6332 n1_M2_99420_56220 n1_M2_100500_56220 0.988200
R6333 n1_M2_100500_56220 n1_M2_101580_56220 0.988200
R6334 n1_M2_101580_56220 n1_M2_102660_56220 0.988200
R6335 n1_M2_102660_56220 n1_M2_103740_56220 0.988200
R6336 n1_M2_103740_56220 n1_M2_104820_56220 0.988200
R6337 n1_M2_104820_56220 n1_M2_105900_56220 0.988200
R6338 n1_M2_105900_56220 n1_M2_106980_56220 0.988200
R6339 n1_M2_106980_56220 n1_M2_108060_56220 0.988200
R6340 n1_M2_108060_56220 n1_M2_109140_56220 0.988200
R6341 n1_M2_109140_56220 n1_M2_110220_56220 0.988200
R6342 n1_M2_110220_56220 n1_M2_111300_56220 0.988200
R6343 n1_M2_111300_56220 n1_M2_112380_56220 0.988200
R6344 n1_M2_112380_56220 n1_M2_113460_56220 0.988200
R6345 n1_M2_113460_56220 n1_M2_114540_56220 0.988200
R6346 n1_M2_114540_56220 n1_M2_115620_56220 0.988200
R6347 n1_M2_115620_56220 n1_M2_116700_56220 0.988200
R6348 n1_M2_116700_56220 n1_M2_117780_56220 0.988200
R6349 n1_M2_117780_56220 n1_M2_118860_56220 0.988200
R6350 n1_M2_118860_56220 n1_M2_119940_56220 0.988200
R6351 n1_M2_119940_56220 n1_M2_121020_56220 0.988200
R6352 n1_M2_121020_56220 n1_M2_122100_56220 0.988200
R6353 n1_M2_122100_56220 n1_M2_123180_56220 0.988200
R6354 n1_M2_123180_56220 n1_M2_124260_56220 0.988200
R6355 n1_M2_124260_56220 n1_M2_125340_56220 0.988200
R6356 n1_M2_125340_56220 n1_M2_126420_56220 0.988200
R6357 n1_M2_126420_56220 n1_M2_127500_56220 0.988200
R6358 n1_M2_127500_56220 n1_M2_128580_56220 0.988200
R6359 n1_M2_128580_56220 n1_M2_129660_56220 0.988200
R6360 n1_M2_60_57300 n1_M2_1140_57300 0.988200
R6361 n1_M2_1140_57300 n1_M2_2220_57300 0.988200
R6362 n1_M2_2220_57300 n1_M2_3300_57300 0.988200
R6363 n1_M2_3300_57300 n1_M2_4380_57300 0.988200
R6364 n1_M2_4380_57300 n1_M2_5460_57300 0.988200
R6365 n1_M2_5460_57300 n1_M2_6540_57300 0.988200
R6366 n1_M2_6540_57300 n1_M2_7620_57300 0.988200
R6367 n1_M2_7620_57300 n1_M2_8700_57300 0.988200
R6368 n1_M2_8700_57300 n1_M2_9780_57300 0.988200
R6369 n1_M2_9780_57300 n1_M2_10860_57300 0.988200
R6370 n1_M2_10860_57300 n1_M2_11940_57300 0.988200
R6371 n1_M2_11940_57300 n1_M2_13020_57300 0.988200
R6372 n1_M2_13020_57300 n1_M2_14100_57300 0.988200
R6373 n1_M2_14100_57300 n1_M2_15180_57300 0.988200
R6374 n1_M2_15180_57300 n1_M2_16260_57300 0.988200
R6375 n1_M2_16260_57300 n1_M2_17340_57300 0.988200
R6376 n1_M2_17340_57300 n1_M2_18420_57300 0.988200
R6377 n1_M2_18420_57300 n1_M2_19500_57300 0.988200
R6378 n1_M2_19500_57300 n1_M2_20580_57300 0.988200
R6379 n1_M2_20580_57300 n1_M2_21660_57300 0.988200
R6380 n1_M2_21660_57300 n1_M2_22740_57300 0.988200
R6381 n1_M2_22740_57300 n1_M2_23820_57300 0.988200
R6382 n1_M2_23820_57300 n1_M2_24900_57300 0.988200
R6383 n1_M2_24900_57300 n1_M2_25980_57300 0.988200
R6384 n1_M2_25980_57300 n1_M2_27060_57300 0.988200
R6385 n1_M2_27060_57300 n1_M2_28140_57300 0.988200
R6386 n1_M2_28140_57300 n1_M2_29220_57300 0.988200
R6387 n1_M2_29220_57300 n1_M2_30300_57300 0.988200
R6388 n1_M2_30300_57300 n1_M2_31380_57300 0.988200
R6389 n1_M2_31380_57300 n1_M2_32460_57300 0.988200
R6390 n1_M2_32460_57300 n1_M2_33540_57300 0.988200
R6391 n1_M2_33540_57300 n1_M2_34620_57300 0.988200
R6392 n1_M2_34620_57300 n1_M2_35700_57300 0.988200
R6393 n1_M2_35700_57300 n1_M2_36780_57300 0.988200
R6394 n1_M2_36780_57300 n1_M2_37860_57300 0.988200
R6395 n1_M2_37860_57300 n1_M2_38940_57300 0.988200
R6396 n1_M2_38940_57300 n1_M2_40020_57300 0.988200
R6397 n1_M2_40020_57300 n1_M2_41100_57300 0.988200
R6398 n1_M2_41100_57300 n1_M2_42180_57300 0.988200
R6399 n1_M2_42180_57300 n1_M2_43260_57300 0.988200
R6400 n1_M2_43260_57300 n1_M2_44340_57300 0.988200
R6401 n1_M2_44340_57300 n1_M2_45420_57300 0.988200
R6402 n1_M2_45420_57300 n1_M2_46500_57300 0.988200
R6403 n1_M2_46500_57300 n1_M2_47580_57300 0.988200
R6404 n1_M2_47580_57300 n1_M2_48660_57300 0.988200
R6405 n1_M2_48660_57300 n1_M2_49740_57300 0.988200
R6406 n1_M2_49740_57300 n1_M2_50820_57300 0.988200
R6407 n1_M2_50820_57300 n1_M2_51900_57300 0.988200
R6408 n1_M2_51900_57300 n1_M2_52980_57300 0.988200
R6409 n1_M2_52980_57300 n1_M2_54060_57300 0.988200
R6410 n1_M2_54060_57300 n1_M2_55140_57300 0.988200
R6411 n1_M2_55140_57300 n1_M2_56220_57300 0.988200
R6412 n1_M2_56220_57300 n1_M2_57300_57300 0.988200
R6413 n1_M2_57300_57300 n1_M2_58380_57300 0.988200
R6414 n1_M2_58380_57300 n1_M2_59460_57300 0.988200
R6415 n1_M2_59460_57300 n1_M2_60540_57300 0.988200
R6416 n1_M2_60540_57300 n1_M2_61620_57300 0.988200
R6417 n1_M2_61620_57300 n1_M2_62700_57300 0.988200
R6418 n1_M2_62700_57300 n1_M2_63780_57300 0.988200
R6419 n1_M2_63780_57300 n1_M2_64860_57300 0.988200
R6420 n1_M2_64860_57300 n1_M2_65940_57300 0.988200
R6421 n1_M2_65940_57300 n1_M2_67020_57300 0.988200
R6422 n1_M2_67020_57300 n1_M2_68100_57300 0.988200
R6423 n1_M2_68100_57300 n1_M2_69180_57300 0.988200
R6424 n1_M2_69180_57300 n1_M2_70260_57300 0.988200
R6425 n1_M2_70260_57300 n1_M2_71340_57300 0.988200
R6426 n1_M2_71340_57300 n1_M2_72420_57300 0.988200
R6427 n1_M2_72420_57300 n1_M2_73500_57300 0.988200
R6428 n1_M2_73500_57300 n1_M2_74580_57300 0.988200
R6429 n1_M2_74580_57300 n1_M2_75660_57300 0.988200
R6430 n1_M2_75660_57300 n1_M2_76740_57300 0.988200
R6431 n1_M2_76740_57300 n1_M2_77820_57300 0.988200
R6432 n1_M2_77820_57300 n1_M2_78900_57300 0.988200
R6433 n1_M2_78900_57300 n1_M2_79980_57300 0.988200
R6434 n1_M2_79980_57300 n1_M2_81060_57300 0.988200
R6435 n1_M2_81060_57300 n1_M2_82140_57300 0.988200
R6436 n1_M2_82140_57300 n1_M2_83220_57300 0.988200
R6437 n1_M2_83220_57300 n1_M2_84300_57300 0.988200
R6438 n1_M2_84300_57300 n1_M2_85380_57300 0.988200
R6439 n1_M2_85380_57300 n1_M2_86460_57300 0.988200
R6440 n1_M2_86460_57300 n1_M2_87540_57300 0.988200
R6441 n1_M2_87540_57300 n1_M2_88620_57300 0.988200
R6442 n1_M2_88620_57300 n1_M2_89700_57300 0.988200
R6443 n1_M2_89700_57300 n1_M2_90780_57300 0.988200
R6444 n1_M2_90780_57300 n1_M2_91860_57300 0.988200
R6445 n1_M2_91860_57300 n1_M2_92940_57300 0.988200
R6446 n1_M2_92940_57300 n1_M2_94020_57300 0.988200
R6447 n1_M2_94020_57300 n1_M2_95100_57300 0.988200
R6448 n1_M2_95100_57300 n1_M2_96180_57300 0.988200
R6449 n1_M2_96180_57300 n1_M2_97260_57300 0.988200
R6450 n1_M2_97260_57300 n1_M2_98340_57300 0.988200
R6451 n1_M2_98340_57300 n1_M2_99420_57300 0.988200
R6452 n1_M2_99420_57300 n1_M2_100500_57300 0.988200
R6453 n1_M2_100500_57300 n1_M2_101580_57300 0.988200
R6454 n1_M2_101580_57300 n1_M2_102660_57300 0.988200
R6455 n1_M2_102660_57300 n1_M2_103740_57300 0.988200
R6456 n1_M2_103740_57300 n1_M2_104820_57300 0.988200
R6457 n1_M2_104820_57300 n1_M2_105900_57300 0.988200
R6458 n1_M2_105900_57300 n1_M2_106980_57300 0.988200
R6459 n1_M2_106980_57300 n1_M2_108060_57300 0.988200
R6460 n1_M2_108060_57300 n1_M2_109140_57300 0.988200
R6461 n1_M2_109140_57300 n1_M2_110220_57300 0.988200
R6462 n1_M2_110220_57300 n1_M2_111300_57300 0.988200
R6463 n1_M2_111300_57300 n1_M2_112380_57300 0.988200
R6464 n1_M2_112380_57300 n1_M2_113460_57300 0.988200
R6465 n1_M2_113460_57300 n1_M2_114540_57300 0.988200
R6466 n1_M2_114540_57300 n1_M2_115620_57300 0.988200
R6467 n1_M2_115620_57300 n1_M2_116700_57300 0.988200
R6468 n1_M2_116700_57300 n1_M2_117780_57300 0.988200
R6469 n1_M2_117780_57300 n1_M2_118860_57300 0.988200
R6470 n1_M2_118860_57300 n1_M2_119940_57300 0.988200
R6471 n1_M2_119940_57300 n1_M2_121020_57300 0.988200
R6472 n1_M2_121020_57300 n1_M2_122100_57300 0.988200
R6473 n1_M2_122100_57300 n1_M2_123180_57300 0.988200
R6474 n1_M2_123180_57300 n1_M2_124260_57300 0.988200
R6475 n1_M2_124260_57300 n1_M2_125340_57300 0.988200
R6476 n1_M2_125340_57300 n1_M2_126420_57300 0.988200
R6477 n1_M2_126420_57300 n1_M2_127500_57300 0.988200
R6478 n1_M2_127500_57300 n1_M2_128580_57300 0.988200
R6479 n1_M2_128580_57300 n1_M2_129660_57300 0.988200
R6480 n1_M2_60_58380 n1_M2_1140_58380 0.988200
R6481 n1_M2_1140_58380 n1_M2_2220_58380 0.988200
R6482 n1_M2_2220_58380 n1_M2_3300_58380 0.988200
R6483 n1_M2_3300_58380 n1_M2_4380_58380 0.988200
R6484 n1_M2_4380_58380 n1_M2_5460_58380 0.988200
R6485 n1_M2_5460_58380 n1_M2_6540_58380 0.988200
R6486 n1_M2_6540_58380 n1_M2_7620_58380 0.988200
R6487 n1_M2_7620_58380 n1_M2_8700_58380 0.988200
R6488 n1_M2_8700_58380 n1_M2_9780_58380 0.988200
R6489 n1_M2_9780_58380 n1_M2_10860_58380 0.988200
R6490 n1_M2_10860_58380 n1_M2_11940_58380 0.988200
R6491 n1_M2_11940_58380 n1_M2_13020_58380 0.988200
R6492 n1_M2_13020_58380 n1_M2_14100_58380 0.988200
R6493 n1_M2_14100_58380 n1_M2_15180_58380 0.988200
R6494 n1_M2_15180_58380 n1_M2_16260_58380 0.988200
R6495 n1_M2_16260_58380 n1_M2_17340_58380 0.988200
R6496 n1_M2_17340_58380 n1_M2_18420_58380 0.988200
R6497 n1_M2_18420_58380 n1_M2_19500_58380 0.988200
R6498 n1_M2_19500_58380 n1_M2_20580_58380 0.988200
R6499 n1_M2_20580_58380 n1_M2_21660_58380 0.988200
R6500 n1_M2_21660_58380 n1_M2_22740_58380 0.988200
R6501 n1_M2_22740_58380 n1_M2_23820_58380 0.988200
R6502 n1_M2_23820_58380 n1_M2_24900_58380 0.988200
R6503 n1_M2_24900_58380 n1_M2_25980_58380 0.988200
R6504 n1_M2_25980_58380 n1_M2_27060_58380 0.988200
R6505 n1_M2_27060_58380 n1_M2_28140_58380 0.988200
R6506 n1_M2_28140_58380 n1_M2_29220_58380 0.988200
R6507 n1_M2_29220_58380 n1_M2_30300_58380 0.988200
R6508 n1_M2_30300_58380 n1_M2_31380_58380 0.988200
R6509 n1_M2_31380_58380 n1_M2_32460_58380 0.988200
R6510 n1_M2_32460_58380 n1_M2_33540_58380 0.988200
R6511 n1_M2_33540_58380 n1_M2_34620_58380 0.988200
R6512 n1_M2_34620_58380 n1_M2_35700_58380 0.988200
R6513 n1_M2_35700_58380 n1_M2_36780_58380 0.988200
R6514 n1_M2_36780_58380 n1_M2_37860_58380 0.988200
R6515 n1_M2_37860_58380 n1_M2_38940_58380 0.988200
R6516 n1_M2_38940_58380 n1_M2_40020_58380 0.988200
R6517 n1_M2_40020_58380 n1_M2_41100_58380 0.988200
R6518 n1_M2_41100_58380 n1_M2_42180_58380 0.988200
R6519 n1_M2_42180_58380 n1_M2_43260_58380 0.988200
R6520 n1_M2_43260_58380 n1_M2_44340_58380 0.988200
R6521 n1_M2_44340_58380 n1_M2_45420_58380 0.988200
R6522 n1_M2_45420_58380 n1_M2_46500_58380 0.988200
R6523 n1_M2_46500_58380 n1_M2_47580_58380 0.988200
R6524 n1_M2_47580_58380 n1_M2_48660_58380 0.988200
R6525 n1_M2_48660_58380 n1_M2_49740_58380 0.988200
R6526 n1_M2_49740_58380 n1_M2_50820_58380 0.988200
R6527 n1_M2_50820_58380 n1_M2_51900_58380 0.988200
R6528 n1_M2_51900_58380 n1_M2_52980_58380 0.988200
R6529 n1_M2_52980_58380 n1_M2_54060_58380 0.988200
R6530 n1_M2_54060_58380 n1_M2_55140_58380 0.988200
R6531 n1_M2_55140_58380 n1_M2_56220_58380 0.988200
R6532 n1_M2_56220_58380 n1_M2_57300_58380 0.988200
R6533 n1_M2_57300_58380 n1_M2_58380_58380 0.988200
R6534 n1_M2_58380_58380 n1_M2_59460_58380 0.988200
R6535 n1_M2_59460_58380 n1_M2_60540_58380 0.988200
R6536 n1_M2_60540_58380 n1_M2_61620_58380 0.988200
R6537 n1_M2_61620_58380 n1_M2_62700_58380 0.988200
R6538 n1_M2_62700_58380 n1_M2_63780_58380 0.988200
R6539 n1_M2_63780_58380 n1_M2_64860_58380 0.988200
R6540 n1_M2_64860_58380 n1_M2_65940_58380 0.988200
R6541 n1_M2_65940_58380 n1_M2_67020_58380 0.988200
R6542 n1_M2_67020_58380 n1_M2_68100_58380 0.988200
R6543 n1_M2_68100_58380 n1_M2_69180_58380 0.988200
R6544 n1_M2_69180_58380 n1_M2_70260_58380 0.988200
R6545 n1_M2_70260_58380 n1_M2_71340_58380 0.988200
R6546 n1_M2_71340_58380 n1_M2_72420_58380 0.988200
R6547 n1_M2_72420_58380 n1_M2_73500_58380 0.988200
R6548 n1_M2_73500_58380 n1_M2_74580_58380 0.988200
R6549 n1_M2_74580_58380 n1_M2_75660_58380 0.988200
R6550 n1_M2_75660_58380 n1_M2_76740_58380 0.988200
R6551 n1_M2_76740_58380 n1_M2_77820_58380 0.988200
R6552 n1_M2_77820_58380 n1_M2_78900_58380 0.988200
R6553 n1_M2_78900_58380 n1_M2_79980_58380 0.988200
R6554 n1_M2_79980_58380 n1_M2_81060_58380 0.988200
R6555 n1_M2_81060_58380 n1_M2_82140_58380 0.988200
R6556 n1_M2_82140_58380 n1_M2_83220_58380 0.988200
R6557 n1_M2_83220_58380 n1_M2_84300_58380 0.988200
R6558 n1_M2_84300_58380 n1_M2_85380_58380 0.988200
R6559 n1_M2_85380_58380 n1_M2_86460_58380 0.988200
R6560 n1_M2_86460_58380 n1_M2_87540_58380 0.988200
R6561 n1_M2_87540_58380 n1_M2_88620_58380 0.988200
R6562 n1_M2_88620_58380 n1_M2_89700_58380 0.988200
R6563 n1_M2_89700_58380 n1_M2_90780_58380 0.988200
R6564 n1_M2_90780_58380 n1_M2_91860_58380 0.988200
R6565 n1_M2_91860_58380 n1_M2_92940_58380 0.988200
R6566 n1_M2_92940_58380 n1_M2_94020_58380 0.988200
R6567 n1_M2_94020_58380 n1_M2_95100_58380 0.988200
R6568 n1_M2_95100_58380 n1_M2_96180_58380 0.988200
R6569 n1_M2_96180_58380 n1_M2_97260_58380 0.988200
R6570 n1_M2_97260_58380 n1_M2_98340_58380 0.988200
R6571 n1_M2_98340_58380 n1_M2_99420_58380 0.988200
R6572 n1_M2_99420_58380 n1_M2_100500_58380 0.988200
R6573 n1_M2_100500_58380 n1_M2_101580_58380 0.988200
R6574 n1_M2_101580_58380 n1_M2_102660_58380 0.988200
R6575 n1_M2_102660_58380 n1_M2_103740_58380 0.988200
R6576 n1_M2_103740_58380 n1_M2_104820_58380 0.988200
R6577 n1_M2_104820_58380 n1_M2_105900_58380 0.988200
R6578 n1_M2_105900_58380 n1_M2_106980_58380 0.988200
R6579 n1_M2_106980_58380 n1_M2_108060_58380 0.988200
R6580 n1_M2_108060_58380 n1_M2_109140_58380 0.988200
R6581 n1_M2_109140_58380 n1_M2_110220_58380 0.988200
R6582 n1_M2_110220_58380 n1_M2_111300_58380 0.988200
R6583 n1_M2_111300_58380 n1_M2_112380_58380 0.988200
R6584 n1_M2_112380_58380 n1_M2_113460_58380 0.988200
R6585 n1_M2_113460_58380 n1_M2_114540_58380 0.988200
R6586 n1_M2_114540_58380 n1_M2_115620_58380 0.988200
R6587 n1_M2_115620_58380 n1_M2_116700_58380 0.988200
R6588 n1_M2_116700_58380 n1_M2_117780_58380 0.988200
R6589 n1_M2_117780_58380 n1_M2_118860_58380 0.988200
R6590 n1_M2_118860_58380 n1_M2_119940_58380 0.988200
R6591 n1_M2_119940_58380 n1_M2_121020_58380 0.988200
R6592 n1_M2_121020_58380 n1_M2_122100_58380 0.988200
R6593 n1_M2_122100_58380 n1_M2_123180_58380 0.988200
R6594 n1_M2_123180_58380 n1_M2_124260_58380 0.988200
R6595 n1_M2_124260_58380 n1_M2_125340_58380 0.988200
R6596 n1_M2_125340_58380 n1_M2_126420_58380 0.988200
R6597 n1_M2_126420_58380 n1_M2_127500_58380 0.988200
R6598 n1_M2_127500_58380 n1_M2_128580_58380 0.988200
R6599 n1_M2_128580_58380 n1_M2_129660_58380 0.988200
R6600 n1_M2_60_59460 n1_M2_1140_59460 0.988200
R6601 n1_M2_1140_59460 n1_M2_2220_59460 0.988200
R6602 n1_M2_2220_59460 n1_M2_3300_59460 0.988200
R6603 n1_M2_3300_59460 n1_M2_4380_59460 0.988200
R6604 n1_M2_4380_59460 n1_M2_5460_59460 0.988200
R6605 n1_M2_5460_59460 n1_M2_6540_59460 0.988200
R6606 n1_M2_6540_59460 n1_M2_7620_59460 0.988200
R6607 n1_M2_7620_59460 n1_M2_8700_59460 0.988200
R6608 n1_M2_8700_59460 n1_M2_9780_59460 0.988200
R6609 n1_M2_9780_59460 n1_M2_10860_59460 0.988200
R6610 n1_M2_10860_59460 n1_M2_11940_59460 0.988200
R6611 n1_M2_11940_59460 n1_M2_13020_59460 0.988200
R6612 n1_M2_13020_59460 n1_M2_14100_59460 0.988200
R6613 n1_M2_14100_59460 n1_M2_15180_59460 0.988200
R6614 n1_M2_15180_59460 n1_M2_16260_59460 0.988200
R6615 n1_M2_16260_59460 n1_M2_17340_59460 0.988200
R6616 n1_M2_17340_59460 n1_M2_18420_59460 0.988200
R6617 n1_M2_18420_59460 n1_M2_19500_59460 0.988200
R6618 n1_M2_19500_59460 n1_M2_20580_59460 0.988200
R6619 n1_M2_20580_59460 n1_M2_21660_59460 0.988200
R6620 n1_M2_21660_59460 n1_M2_22740_59460 0.988200
R6621 n1_M2_22740_59460 n1_M2_23820_59460 0.988200
R6622 n1_M2_23820_59460 n1_M2_24900_59460 0.988200
R6623 n1_M2_24900_59460 n1_M2_25980_59460 0.988200
R6624 n1_M2_25980_59460 n1_M2_27060_59460 0.988200
R6625 n1_M2_27060_59460 n1_M2_28140_59460 0.988200
R6626 n1_M2_28140_59460 n1_M2_29220_59460 0.988200
R6627 n1_M2_29220_59460 n1_M2_30300_59460 0.988200
R6628 n1_M2_30300_59460 n1_M2_31380_59460 0.988200
R6629 n1_M2_31380_59460 n1_M2_32460_59460 0.988200
R6630 n1_M2_32460_59460 n1_M2_33540_59460 0.988200
R6631 n1_M2_33540_59460 n1_M2_34620_59460 0.988200
R6632 n1_M2_34620_59460 n1_M2_35700_59460 0.988200
R6633 n1_M2_35700_59460 n1_M2_36780_59460 0.988200
R6634 n1_M2_36780_59460 n1_M2_37860_59460 0.988200
R6635 n1_M2_37860_59460 n1_M2_38940_59460 0.988200
R6636 n1_M2_38940_59460 n1_M2_40020_59460 0.988200
R6637 n1_M2_40020_59460 n1_M2_41100_59460 0.988200
R6638 n1_M2_41100_59460 n1_M2_42180_59460 0.988200
R6639 n1_M2_42180_59460 n1_M2_43260_59460 0.988200
R6640 n1_M2_43260_59460 n1_M2_44340_59460 0.988200
R6641 n1_M2_44340_59460 n1_M2_45420_59460 0.988200
R6642 n1_M2_45420_59460 n1_M2_46500_59460 0.988200
R6643 n1_M2_46500_59460 n1_M2_47580_59460 0.988200
R6644 n1_M2_47580_59460 n1_M2_48660_59460 0.988200
R6645 n1_M2_48660_59460 n1_M2_49740_59460 0.988200
R6646 n1_M2_49740_59460 n1_M2_50820_59460 0.988200
R6647 n1_M2_50820_59460 n1_M2_51900_59460 0.988200
R6648 n1_M2_51900_59460 n1_M2_52980_59460 0.988200
R6649 n1_M2_52980_59460 n1_M2_54060_59460 0.988200
R6650 n1_M2_54060_59460 n1_M2_55140_59460 0.988200
R6651 n1_M2_55140_59460 n1_M2_56220_59460 0.988200
R6652 n1_M2_56220_59460 n1_M2_57300_59460 0.988200
R6653 n1_M2_57300_59460 n1_M2_58380_59460 0.988200
R6654 n1_M2_58380_59460 n1_M2_59460_59460 0.988200
R6655 n1_M2_59460_59460 n1_M2_60540_59460 0.988200
R6656 n1_M2_60540_59460 n1_M2_61620_59460 0.988200
R6657 n1_M2_61620_59460 n1_M2_62700_59460 0.988200
R6658 n1_M2_62700_59460 n1_M2_63780_59460 0.988200
R6659 n1_M2_63780_59460 n1_M2_64860_59460 0.988200
R6660 n1_M2_64860_59460 n1_M2_65940_59460 0.988200
R6661 n1_M2_65940_59460 n1_M2_67020_59460 0.988200
R6662 n1_M2_67020_59460 n1_M2_68100_59460 0.988200
R6663 n1_M2_68100_59460 n1_M2_69180_59460 0.988200
R6664 n1_M2_69180_59460 n1_M2_70260_59460 0.988200
R6665 n1_M2_70260_59460 n1_M2_71340_59460 0.988200
R6666 n1_M2_71340_59460 n1_M2_72420_59460 0.988200
R6667 n1_M2_72420_59460 n1_M2_73500_59460 0.988200
R6668 n1_M2_73500_59460 n1_M2_74580_59460 0.988200
R6669 n1_M2_74580_59460 n1_M2_75660_59460 0.988200
R6670 n1_M2_75660_59460 n1_M2_76740_59460 0.988200
R6671 n1_M2_76740_59460 n1_M2_77820_59460 0.988200
R6672 n1_M2_77820_59460 n1_M2_78900_59460 0.988200
R6673 n1_M2_78900_59460 n1_M2_79980_59460 0.988200
R6674 n1_M2_79980_59460 n1_M2_81060_59460 0.988200
R6675 n1_M2_81060_59460 n1_M2_82140_59460 0.988200
R6676 n1_M2_82140_59460 n1_M2_83220_59460 0.988200
R6677 n1_M2_83220_59460 n1_M2_84300_59460 0.988200
R6678 n1_M2_84300_59460 n1_M2_85380_59460 0.988200
R6679 n1_M2_85380_59460 n1_M2_86460_59460 0.988200
R6680 n1_M2_86460_59460 n1_M2_87540_59460 0.988200
R6681 n1_M2_87540_59460 n1_M2_88620_59460 0.988200
R6682 n1_M2_88620_59460 n1_M2_89700_59460 0.988200
R6683 n1_M2_89700_59460 n1_M2_90780_59460 0.988200
R6684 n1_M2_90780_59460 n1_M2_91860_59460 0.988200
R6685 n1_M2_91860_59460 n1_M2_92940_59460 0.988200
R6686 n1_M2_92940_59460 n1_M2_94020_59460 0.988200
R6687 n1_M2_94020_59460 n1_M2_95100_59460 0.988200
R6688 n1_M2_95100_59460 n1_M2_96180_59460 0.988200
R6689 n1_M2_96180_59460 n1_M2_97260_59460 0.988200
R6690 n1_M2_97260_59460 n1_M2_98340_59460 0.988200
R6691 n1_M2_98340_59460 n1_M2_99420_59460 0.988200
R6692 n1_M2_99420_59460 n1_M2_100500_59460 0.988200
R6693 n1_M2_100500_59460 n1_M2_101580_59460 0.988200
R6694 n1_M2_101580_59460 n1_M2_102660_59460 0.988200
R6695 n1_M2_102660_59460 n1_M2_103740_59460 0.988200
R6696 n1_M2_103740_59460 n1_M2_104820_59460 0.988200
R6697 n1_M2_104820_59460 n1_M2_105900_59460 0.988200
R6698 n1_M2_105900_59460 n1_M2_106980_59460 0.988200
R6699 n1_M2_106980_59460 n1_M2_108060_59460 0.988200
R6700 n1_M2_108060_59460 n1_M2_109140_59460 0.988200
R6701 n1_M2_109140_59460 n1_M2_110220_59460 0.988200
R6702 n1_M2_110220_59460 n1_M2_111300_59460 0.988200
R6703 n1_M2_111300_59460 n1_M2_112380_59460 0.988200
R6704 n1_M2_112380_59460 n1_M2_113460_59460 0.988200
R6705 n1_M2_113460_59460 n1_M2_114540_59460 0.988200
R6706 n1_M2_114540_59460 n1_M2_115620_59460 0.988200
R6707 n1_M2_115620_59460 n1_M2_116700_59460 0.988200
R6708 n1_M2_116700_59460 n1_M2_117780_59460 0.988200
R6709 n1_M2_117780_59460 n1_M2_118860_59460 0.988200
R6710 n1_M2_118860_59460 n1_M2_119940_59460 0.988200
R6711 n1_M2_119940_59460 n1_M2_121020_59460 0.988200
R6712 n1_M2_121020_59460 n1_M2_122100_59460 0.988200
R6713 n1_M2_122100_59460 n1_M2_123180_59460 0.988200
R6714 n1_M2_123180_59460 n1_M2_124260_59460 0.988200
R6715 n1_M2_124260_59460 n1_M2_125340_59460 0.988200
R6716 n1_M2_125340_59460 n1_M2_126420_59460 0.988200
R6717 n1_M2_126420_59460 n1_M2_127500_59460 0.988200
R6718 n1_M2_127500_59460 n1_M2_128580_59460 0.988200
R6719 n1_M2_128580_59460 n1_M2_129660_59460 0.988200
R6720 n1_M2_60_60540 n1_M2_1140_60540 0.988200
R6721 n1_M2_1140_60540 n1_M2_2220_60540 0.988200
R6722 n1_M2_2220_60540 n1_M2_3300_60540 0.988200
R6723 n1_M2_3300_60540 n1_M2_4380_60540 0.988200
R6724 n1_M2_4380_60540 n1_M2_5460_60540 0.988200
R6725 n1_M2_5460_60540 n1_M2_6540_60540 0.988200
R6726 n1_M2_6540_60540 n1_M2_7620_60540 0.988200
R6727 n1_M2_7620_60540 n1_M2_8700_60540 0.988200
R6728 n1_M2_8700_60540 n1_M2_9780_60540 0.988200
R6729 n1_M2_9780_60540 n1_M2_10860_60540 0.988200
R6730 n1_M2_10860_60540 n1_M2_11940_60540 0.988200
R6731 n1_M2_11940_60540 n1_M2_13020_60540 0.988200
R6732 n1_M2_13020_60540 n1_M2_14100_60540 0.988200
R6733 n1_M2_14100_60540 n1_M2_15180_60540 0.988200
R6734 n1_M2_15180_60540 n1_M2_16260_60540 0.988200
R6735 n1_M2_16260_60540 n1_M2_17340_60540 0.988200
R6736 n1_M2_17340_60540 n1_M2_18420_60540 0.988200
R6737 n1_M2_18420_60540 n1_M2_19500_60540 0.988200
R6738 n1_M2_19500_60540 n1_M2_20580_60540 0.988200
R6739 n1_M2_20580_60540 n1_M2_21660_60540 0.988200
R6740 n1_M2_21660_60540 n1_M2_22740_60540 0.988200
R6741 n1_M2_22740_60540 n1_M2_23820_60540 0.988200
R6742 n1_M2_23820_60540 n1_M2_24900_60540 0.988200
R6743 n1_M2_24900_60540 n1_M2_25980_60540 0.988200
R6744 n1_M2_25980_60540 n1_M2_27060_60540 0.988200
R6745 n1_M2_27060_60540 n1_M2_28140_60540 0.988200
R6746 n1_M2_28140_60540 n1_M2_29220_60540 0.988200
R6747 n1_M2_29220_60540 n1_M2_30300_60540 0.988200
R6748 n1_M2_30300_60540 n1_M2_31380_60540 0.988200
R6749 n1_M2_31380_60540 n1_M2_32460_60540 0.988200
R6750 n1_M2_32460_60540 n1_M2_33540_60540 0.988200
R6751 n1_M2_33540_60540 n1_M2_34620_60540 0.988200
R6752 n1_M2_34620_60540 n1_M2_35700_60540 0.988200
R6753 n1_M2_35700_60540 n1_M2_36780_60540 0.988200
R6754 n1_M2_36780_60540 n1_M2_37860_60540 0.988200
R6755 n1_M2_37860_60540 n1_M2_38940_60540 0.988200
R6756 n1_M2_38940_60540 n1_M2_40020_60540 0.988200
R6757 n1_M2_40020_60540 n1_M2_41100_60540 0.988200
R6758 n1_M2_41100_60540 n1_M2_42180_60540 0.988200
R6759 n1_M2_42180_60540 n1_M2_43260_60540 0.988200
R6760 n1_M2_43260_60540 n1_M2_44340_60540 0.988200
R6761 n1_M2_44340_60540 n1_M2_45420_60540 0.988200
R6762 n1_M2_45420_60540 n1_M2_46500_60540 0.988200
R6763 n1_M2_46500_60540 n1_M2_47580_60540 0.988200
R6764 n1_M2_47580_60540 n1_M2_48660_60540 0.988200
R6765 n1_M2_48660_60540 n1_M2_49740_60540 0.988200
R6766 n1_M2_49740_60540 n1_M2_50820_60540 0.988200
R6767 n1_M2_50820_60540 n1_M2_51900_60540 0.988200
R6768 n1_M2_51900_60540 n1_M2_52980_60540 0.988200
R6769 n1_M2_52980_60540 n1_M2_54060_60540 0.988200
R6770 n1_M2_54060_60540 n1_M2_55140_60540 0.988200
R6771 n1_M2_55140_60540 n1_M2_56220_60540 0.988200
R6772 n1_M2_56220_60540 n1_M2_57300_60540 0.988200
R6773 n1_M2_57300_60540 n1_M2_58380_60540 0.988200
R6774 n1_M2_58380_60540 n1_M2_59460_60540 0.988200
R6775 n1_M2_59460_60540 n1_M2_60540_60540 0.988200
R6776 n1_M2_60540_60540 n1_M2_61620_60540 0.988200
R6777 n1_M2_61620_60540 n1_M2_62700_60540 0.988200
R6778 n1_M2_62700_60540 n1_M2_63780_60540 0.988200
R6779 n1_M2_63780_60540 n1_M2_64860_60540 0.988200
R6780 n1_M2_64860_60540 n1_M2_65940_60540 0.988200
R6781 n1_M2_65940_60540 n1_M2_67020_60540 0.988200
R6782 n1_M2_67020_60540 n1_M2_68100_60540 0.988200
R6783 n1_M2_68100_60540 n1_M2_69180_60540 0.988200
R6784 n1_M2_69180_60540 n1_M2_70260_60540 0.988200
R6785 n1_M2_70260_60540 n1_M2_71340_60540 0.988200
R6786 n1_M2_71340_60540 n1_M2_72420_60540 0.988200
R6787 n1_M2_72420_60540 n1_M2_73500_60540 0.988200
R6788 n1_M2_73500_60540 n1_M2_74580_60540 0.988200
R6789 n1_M2_74580_60540 n1_M2_75660_60540 0.988200
R6790 n1_M2_75660_60540 n1_M2_76740_60540 0.988200
R6791 n1_M2_76740_60540 n1_M2_77820_60540 0.988200
R6792 n1_M2_77820_60540 n1_M2_78900_60540 0.988200
R6793 n1_M2_78900_60540 n1_M2_79980_60540 0.988200
R6794 n1_M2_79980_60540 n1_M2_81060_60540 0.988200
R6795 n1_M2_81060_60540 n1_M2_82140_60540 0.988200
R6796 n1_M2_82140_60540 n1_M2_83220_60540 0.988200
R6797 n1_M2_83220_60540 n1_M2_84300_60540 0.988200
R6798 n1_M2_84300_60540 n1_M2_85380_60540 0.988200
R6799 n1_M2_85380_60540 n1_M2_86460_60540 0.988200
R6800 n1_M2_86460_60540 n1_M2_87540_60540 0.988200
R6801 n1_M2_87540_60540 n1_M2_88620_60540 0.988200
R6802 n1_M2_88620_60540 n1_M2_89700_60540 0.988200
R6803 n1_M2_89700_60540 n1_M2_90780_60540 0.988200
R6804 n1_M2_90780_60540 n1_M2_91860_60540 0.988200
R6805 n1_M2_91860_60540 n1_M2_92940_60540 0.988200
R6806 n1_M2_92940_60540 n1_M2_94020_60540 0.988200
R6807 n1_M2_94020_60540 n1_M2_95100_60540 0.988200
R6808 n1_M2_95100_60540 n1_M2_96180_60540 0.988200
R6809 n1_M2_96180_60540 n1_M2_97260_60540 0.988200
R6810 n1_M2_97260_60540 n1_M2_98340_60540 0.988200
R6811 n1_M2_98340_60540 n1_M2_99420_60540 0.988200
R6812 n1_M2_99420_60540 n1_M2_100500_60540 0.988200
R6813 n1_M2_100500_60540 n1_M2_101580_60540 0.988200
R6814 n1_M2_101580_60540 n1_M2_102660_60540 0.988200
R6815 n1_M2_102660_60540 n1_M2_103740_60540 0.988200
R6816 n1_M2_103740_60540 n1_M2_104820_60540 0.988200
R6817 n1_M2_104820_60540 n1_M2_105900_60540 0.988200
R6818 n1_M2_105900_60540 n1_M2_106980_60540 0.988200
R6819 n1_M2_106980_60540 n1_M2_108060_60540 0.988200
R6820 n1_M2_108060_60540 n1_M2_109140_60540 0.988200
R6821 n1_M2_109140_60540 n1_M2_110220_60540 0.988200
R6822 n1_M2_110220_60540 n1_M2_111300_60540 0.988200
R6823 n1_M2_111300_60540 n1_M2_112380_60540 0.988200
R6824 n1_M2_112380_60540 n1_M2_113460_60540 0.988200
R6825 n1_M2_113460_60540 n1_M2_114540_60540 0.988200
R6826 n1_M2_114540_60540 n1_M2_115620_60540 0.988200
R6827 n1_M2_115620_60540 n1_M2_116700_60540 0.988200
R6828 n1_M2_116700_60540 n1_M2_117780_60540 0.988200
R6829 n1_M2_117780_60540 n1_M2_118860_60540 0.988200
R6830 n1_M2_118860_60540 n1_M2_119940_60540 0.988200
R6831 n1_M2_119940_60540 n1_M2_121020_60540 0.988200
R6832 n1_M2_121020_60540 n1_M2_122100_60540 0.988200
R6833 n1_M2_122100_60540 n1_M2_123180_60540 0.988200
R6834 n1_M2_123180_60540 n1_M2_124260_60540 0.988200
R6835 n1_M2_124260_60540 n1_M2_125340_60540 0.988200
R6836 n1_M2_125340_60540 n1_M2_126420_60540 0.988200
R6837 n1_M2_126420_60540 n1_M2_127500_60540 0.988200
R6838 n1_M2_127500_60540 n1_M2_128580_60540 0.988200
R6839 n1_M2_128580_60540 n1_M2_129660_60540 0.988200
R6840 n1_M2_60_61620 n1_M2_1140_61620 0.988200
R6841 n1_M2_1140_61620 n1_M2_2220_61620 0.988200
R6842 n1_M2_2220_61620 n1_M2_3300_61620 0.988200
R6843 n1_M2_3300_61620 n1_M2_4380_61620 0.988200
R6844 n1_M2_4380_61620 n1_M2_5460_61620 0.988200
R6845 n1_M2_5460_61620 n1_M2_6540_61620 0.988200
R6846 n1_M2_6540_61620 n1_M2_7620_61620 0.988200
R6847 n1_M2_7620_61620 n1_M2_8700_61620 0.988200
R6848 n1_M2_8700_61620 n1_M2_9780_61620 0.988200
R6849 n1_M2_9780_61620 n1_M2_10860_61620 0.988200
R6850 n1_M2_10860_61620 n1_M2_11940_61620 0.988200
R6851 n1_M2_11940_61620 n1_M2_13020_61620 0.988200
R6852 n1_M2_13020_61620 n1_M2_14100_61620 0.988200
R6853 n1_M2_14100_61620 n1_M2_15180_61620 0.988200
R6854 n1_M2_15180_61620 n1_M2_16260_61620 0.988200
R6855 n1_M2_16260_61620 n1_M2_17340_61620 0.988200
R6856 n1_M2_17340_61620 n1_M2_18420_61620 0.988200
R6857 n1_M2_18420_61620 n1_M2_19500_61620 0.988200
R6858 n1_M2_19500_61620 n1_M2_20580_61620 0.988200
R6859 n1_M2_20580_61620 n1_M2_21660_61620 0.988200
R6860 n1_M2_21660_61620 n1_M2_22740_61620 0.988200
R6861 n1_M2_22740_61620 n1_M2_23820_61620 0.988200
R6862 n1_M2_23820_61620 n1_M2_24900_61620 0.988200
R6863 n1_M2_24900_61620 n1_M2_25980_61620 0.988200
R6864 n1_M2_25980_61620 n1_M2_27060_61620 0.988200
R6865 n1_M2_27060_61620 n1_M2_28140_61620 0.988200
R6866 n1_M2_28140_61620 n1_M2_29220_61620 0.988200
R6867 n1_M2_29220_61620 n1_M2_30300_61620 0.988200
R6868 n1_M2_30300_61620 n1_M2_31380_61620 0.988200
R6869 n1_M2_31380_61620 n1_M2_32460_61620 0.988200
R6870 n1_M2_32460_61620 n1_M2_33540_61620 0.988200
R6871 n1_M2_33540_61620 n1_M2_34620_61620 0.988200
R6872 n1_M2_34620_61620 n1_M2_35700_61620 0.988200
R6873 n1_M2_35700_61620 n1_M2_36780_61620 0.988200
R6874 n1_M2_36780_61620 n1_M2_37860_61620 0.988200
R6875 n1_M2_37860_61620 n1_M2_38940_61620 0.988200
R6876 n1_M2_38940_61620 n1_M2_40020_61620 0.988200
R6877 n1_M2_40020_61620 n1_M2_41100_61620 0.988200
R6878 n1_M2_41100_61620 n1_M2_42180_61620 0.988200
R6879 n1_M2_42180_61620 n1_M2_43260_61620 0.988200
R6880 n1_M2_43260_61620 n1_M2_44340_61620 0.988200
R6881 n1_M2_44340_61620 n1_M2_45420_61620 0.988200
R6882 n1_M2_45420_61620 n1_M2_46500_61620 0.988200
R6883 n1_M2_46500_61620 n1_M2_47580_61620 0.988200
R6884 n1_M2_47580_61620 n1_M2_48660_61620 0.988200
R6885 n1_M2_48660_61620 n1_M2_49740_61620 0.988200
R6886 n1_M2_49740_61620 n1_M2_50820_61620 0.988200
R6887 n1_M2_50820_61620 n1_M2_51900_61620 0.988200
R6888 n1_M2_51900_61620 n1_M2_52980_61620 0.988200
R6889 n1_M2_52980_61620 n1_M2_54060_61620 0.988200
R6890 n1_M2_54060_61620 n1_M2_55140_61620 0.988200
R6891 n1_M2_55140_61620 n1_M2_56220_61620 0.988200
R6892 n1_M2_56220_61620 n1_M2_57300_61620 0.988200
R6893 n1_M2_57300_61620 n1_M2_58380_61620 0.988200
R6894 n1_M2_58380_61620 n1_M2_59460_61620 0.988200
R6895 n1_M2_59460_61620 n1_M2_60540_61620 0.988200
R6896 n1_M2_60540_61620 n1_M2_61620_61620 0.988200
R6897 n1_M2_61620_61620 n1_M2_62700_61620 0.988200
R6898 n1_M2_62700_61620 n1_M2_63780_61620 0.988200
R6899 n1_M2_63780_61620 n1_M2_64860_61620 0.988200
R6900 n1_M2_64860_61620 n1_M2_65940_61620 0.988200
R6901 n1_M2_65940_61620 n1_M2_67020_61620 0.988200
R6902 n1_M2_67020_61620 n1_M2_68100_61620 0.988200
R6903 n1_M2_68100_61620 n1_M2_69180_61620 0.988200
R6904 n1_M2_69180_61620 n1_M2_70260_61620 0.988200
R6905 n1_M2_70260_61620 n1_M2_71340_61620 0.988200
R6906 n1_M2_71340_61620 n1_M2_72420_61620 0.988200
R6907 n1_M2_72420_61620 n1_M2_73500_61620 0.988200
R6908 n1_M2_73500_61620 n1_M2_74580_61620 0.988200
R6909 n1_M2_74580_61620 n1_M2_75660_61620 0.988200
R6910 n1_M2_75660_61620 n1_M2_76740_61620 0.988200
R6911 n1_M2_76740_61620 n1_M2_77820_61620 0.988200
R6912 n1_M2_77820_61620 n1_M2_78900_61620 0.988200
R6913 n1_M2_78900_61620 n1_M2_79980_61620 0.988200
R6914 n1_M2_79980_61620 n1_M2_81060_61620 0.988200
R6915 n1_M2_81060_61620 n1_M2_82140_61620 0.988200
R6916 n1_M2_82140_61620 n1_M2_83220_61620 0.988200
R6917 n1_M2_83220_61620 n1_M2_84300_61620 0.988200
R6918 n1_M2_84300_61620 n1_M2_85380_61620 0.988200
R6919 n1_M2_85380_61620 n1_M2_86460_61620 0.988200
R6920 n1_M2_86460_61620 n1_M2_87540_61620 0.988200
R6921 n1_M2_87540_61620 n1_M2_88620_61620 0.988200
R6922 n1_M2_88620_61620 n1_M2_89700_61620 0.988200
R6923 n1_M2_89700_61620 n1_M2_90780_61620 0.988200
R6924 n1_M2_90780_61620 n1_M2_91860_61620 0.988200
R6925 n1_M2_91860_61620 n1_M2_92940_61620 0.988200
R6926 n1_M2_92940_61620 n1_M2_94020_61620 0.988200
R6927 n1_M2_94020_61620 n1_M2_95100_61620 0.988200
R6928 n1_M2_95100_61620 n1_M2_96180_61620 0.988200
R6929 n1_M2_96180_61620 n1_M2_97260_61620 0.988200
R6930 n1_M2_97260_61620 n1_M2_98340_61620 0.988200
R6931 n1_M2_98340_61620 n1_M2_99420_61620 0.988200
R6932 n1_M2_99420_61620 n1_M2_100500_61620 0.988200
R6933 n1_M2_100500_61620 n1_M2_101580_61620 0.988200
R6934 n1_M2_101580_61620 n1_M2_102660_61620 0.988200
R6935 n1_M2_102660_61620 n1_M2_103740_61620 0.988200
R6936 n1_M2_103740_61620 n1_M2_104820_61620 0.988200
R6937 n1_M2_104820_61620 n1_M2_105900_61620 0.988200
R6938 n1_M2_105900_61620 n1_M2_106980_61620 0.988200
R6939 n1_M2_106980_61620 n1_M2_108060_61620 0.988200
R6940 n1_M2_108060_61620 n1_M2_109140_61620 0.988200
R6941 n1_M2_109140_61620 n1_M2_110220_61620 0.988200
R6942 n1_M2_110220_61620 n1_M2_111300_61620 0.988200
R6943 n1_M2_111300_61620 n1_M2_112380_61620 0.988200
R6944 n1_M2_112380_61620 n1_M2_113460_61620 0.988200
R6945 n1_M2_113460_61620 n1_M2_114540_61620 0.988200
R6946 n1_M2_114540_61620 n1_M2_115620_61620 0.988200
R6947 n1_M2_115620_61620 n1_M2_116700_61620 0.988200
R6948 n1_M2_116700_61620 n1_M2_117780_61620 0.988200
R6949 n1_M2_117780_61620 n1_M2_118860_61620 0.988200
R6950 n1_M2_118860_61620 n1_M2_119940_61620 0.988200
R6951 n1_M2_119940_61620 n1_M2_121020_61620 0.988200
R6952 n1_M2_121020_61620 n1_M2_122100_61620 0.988200
R6953 n1_M2_122100_61620 n1_M2_123180_61620 0.988200
R6954 n1_M2_123180_61620 n1_M2_124260_61620 0.988200
R6955 n1_M2_124260_61620 n1_M2_125340_61620 0.988200
R6956 n1_M2_125340_61620 n1_M2_126420_61620 0.988200
R6957 n1_M2_126420_61620 n1_M2_127500_61620 0.988200
R6958 n1_M2_127500_61620 n1_M2_128580_61620 0.988200
R6959 n1_M2_128580_61620 n1_M2_129660_61620 0.988200
R6960 n1_M2_60_62700 n1_M2_1140_62700 0.988200
R6961 n1_M2_1140_62700 n1_M2_2220_62700 0.988200
R6962 n1_M2_2220_62700 n1_M2_3300_62700 0.988200
R6963 n1_M2_3300_62700 n1_M2_4380_62700 0.988200
R6964 n1_M2_4380_62700 n1_M2_5460_62700 0.988200
R6965 n1_M2_5460_62700 n1_M2_6540_62700 0.988200
R6966 n1_M2_6540_62700 n1_M2_7620_62700 0.988200
R6967 n1_M2_7620_62700 n1_M2_8700_62700 0.988200
R6968 n1_M2_8700_62700 n1_M2_9780_62700 0.988200
R6969 n1_M2_9780_62700 n1_M2_10860_62700 0.988200
R6970 n1_M2_10860_62700 n1_M2_11940_62700 0.988200
R6971 n1_M2_11940_62700 n1_M2_13020_62700 0.988200
R6972 n1_M2_13020_62700 n1_M2_14100_62700 0.988200
R6973 n1_M2_14100_62700 n1_M2_15180_62700 0.988200
R6974 n1_M2_15180_62700 n1_M2_16260_62700 0.988200
R6975 n1_M2_16260_62700 n1_M2_17340_62700 0.988200
R6976 n1_M2_17340_62700 n1_M2_18420_62700 0.988200
R6977 n1_M2_18420_62700 n1_M2_19500_62700 0.988200
R6978 n1_M2_19500_62700 n1_M2_20580_62700 0.988200
R6979 n1_M2_20580_62700 n1_M2_21660_62700 0.988200
R6980 n1_M2_21660_62700 n1_M2_22740_62700 0.988200
R6981 n1_M2_22740_62700 n1_M2_23820_62700 0.988200
R6982 n1_M2_23820_62700 n1_M2_24900_62700 0.988200
R6983 n1_M2_24900_62700 n1_M2_25980_62700 0.988200
R6984 n1_M2_25980_62700 n1_M2_27060_62700 0.988200
R6985 n1_M2_27060_62700 n1_M2_28140_62700 0.988200
R6986 n1_M2_28140_62700 n1_M2_29220_62700 0.988200
R6987 n1_M2_29220_62700 n1_M2_30300_62700 0.988200
R6988 n1_M2_30300_62700 n1_M2_31380_62700 0.988200
R6989 n1_M2_31380_62700 n1_M2_32460_62700 0.988200
R6990 n1_M2_32460_62700 n1_M2_33540_62700 0.988200
R6991 n1_M2_33540_62700 n1_M2_34620_62700 0.988200
R6992 n1_M2_34620_62700 n1_M2_35700_62700 0.988200
R6993 n1_M2_35700_62700 n1_M2_36780_62700 0.988200
R6994 n1_M2_36780_62700 n1_M2_37860_62700 0.988200
R6995 n1_M2_37860_62700 n1_M2_38940_62700 0.988200
R6996 n1_M2_38940_62700 n1_M2_40020_62700 0.988200
R6997 n1_M2_40020_62700 n1_M2_41100_62700 0.988200
R6998 n1_M2_41100_62700 n1_M2_42180_62700 0.988200
R6999 n1_M2_42180_62700 n1_M2_43260_62700 0.988200
R7000 n1_M2_43260_62700 n1_M2_44340_62700 0.988200
R7001 n1_M2_44340_62700 n1_M2_45420_62700 0.988200
R7002 n1_M2_45420_62700 n1_M2_46500_62700 0.988200
R7003 n1_M2_46500_62700 n1_M2_47580_62700 0.988200
R7004 n1_M2_47580_62700 n1_M2_48660_62700 0.988200
R7005 n1_M2_48660_62700 n1_M2_49740_62700 0.988200
R7006 n1_M2_49740_62700 n1_M2_50820_62700 0.988200
R7007 n1_M2_50820_62700 n1_M2_51900_62700 0.988200
R7008 n1_M2_51900_62700 n1_M2_52980_62700 0.988200
R7009 n1_M2_52980_62700 n1_M2_54060_62700 0.988200
R7010 n1_M2_54060_62700 n1_M2_55140_62700 0.988200
R7011 n1_M2_55140_62700 n1_M2_56220_62700 0.988200
R7012 n1_M2_56220_62700 n1_M2_57300_62700 0.988200
R7013 n1_M2_57300_62700 n1_M2_58380_62700 0.988200
R7014 n1_M2_58380_62700 n1_M2_59460_62700 0.988200
R7015 n1_M2_59460_62700 n1_M2_60540_62700 0.988200
R7016 n1_M2_60540_62700 n1_M2_61620_62700 0.988200
R7017 n1_M2_61620_62700 n1_M2_62700_62700 0.988200
R7018 n1_M2_62700_62700 n1_M2_63780_62700 0.988200
R7019 n1_M2_63780_62700 n1_M2_64860_62700 0.988200
R7020 n1_M2_64860_62700 n1_M2_65940_62700 0.988200
R7021 n1_M2_65940_62700 n1_M2_67020_62700 0.988200
R7022 n1_M2_67020_62700 n1_M2_68100_62700 0.988200
R7023 n1_M2_68100_62700 n1_M2_69180_62700 0.988200
R7024 n1_M2_69180_62700 n1_M2_70260_62700 0.988200
R7025 n1_M2_70260_62700 n1_M2_71340_62700 0.988200
R7026 n1_M2_71340_62700 n1_M2_72420_62700 0.988200
R7027 n1_M2_72420_62700 n1_M2_73500_62700 0.988200
R7028 n1_M2_73500_62700 n1_M2_74580_62700 0.988200
R7029 n1_M2_74580_62700 n1_M2_75660_62700 0.988200
R7030 n1_M2_75660_62700 n1_M2_76740_62700 0.988200
R7031 n1_M2_76740_62700 n1_M2_77820_62700 0.988200
R7032 n1_M2_77820_62700 n1_M2_78900_62700 0.988200
R7033 n1_M2_78900_62700 n1_M2_79980_62700 0.988200
R7034 n1_M2_79980_62700 n1_M2_81060_62700 0.988200
R7035 n1_M2_81060_62700 n1_M2_82140_62700 0.988200
R7036 n1_M2_82140_62700 n1_M2_83220_62700 0.988200
R7037 n1_M2_83220_62700 n1_M2_84300_62700 0.988200
R7038 n1_M2_84300_62700 n1_M2_85380_62700 0.988200
R7039 n1_M2_85380_62700 n1_M2_86460_62700 0.988200
R7040 n1_M2_86460_62700 n1_M2_87540_62700 0.988200
R7041 n1_M2_87540_62700 n1_M2_88620_62700 0.988200
R7042 n1_M2_88620_62700 n1_M2_89700_62700 0.988200
R7043 n1_M2_89700_62700 n1_M2_90780_62700 0.988200
R7044 n1_M2_90780_62700 n1_M2_91860_62700 0.988200
R7045 n1_M2_91860_62700 n1_M2_92940_62700 0.988200
R7046 n1_M2_92940_62700 n1_M2_94020_62700 0.988200
R7047 n1_M2_94020_62700 n1_M2_95100_62700 0.988200
R7048 n1_M2_95100_62700 n1_M2_96180_62700 0.988200
R7049 n1_M2_96180_62700 n1_M2_97260_62700 0.988200
R7050 n1_M2_97260_62700 n1_M2_98340_62700 0.988200
R7051 n1_M2_98340_62700 n1_M2_99420_62700 0.988200
R7052 n1_M2_99420_62700 n1_M2_100500_62700 0.988200
R7053 n1_M2_100500_62700 n1_M2_101580_62700 0.988200
R7054 n1_M2_101580_62700 n1_M2_102660_62700 0.988200
R7055 n1_M2_102660_62700 n1_M2_103740_62700 0.988200
R7056 n1_M2_103740_62700 n1_M2_104820_62700 0.988200
R7057 n1_M2_104820_62700 n1_M2_105900_62700 0.988200
R7058 n1_M2_105900_62700 n1_M2_106980_62700 0.988200
R7059 n1_M2_106980_62700 n1_M2_108060_62700 0.988200
R7060 n1_M2_108060_62700 n1_M2_109140_62700 0.988200
R7061 n1_M2_109140_62700 n1_M2_110220_62700 0.988200
R7062 n1_M2_110220_62700 n1_M2_111300_62700 0.988200
R7063 n1_M2_111300_62700 n1_M2_112380_62700 0.988200
R7064 n1_M2_112380_62700 n1_M2_113460_62700 0.988200
R7065 n1_M2_113460_62700 n1_M2_114540_62700 0.988200
R7066 n1_M2_114540_62700 n1_M2_115620_62700 0.988200
R7067 n1_M2_115620_62700 n1_M2_116700_62700 0.988200
R7068 n1_M2_116700_62700 n1_M2_117780_62700 0.988200
R7069 n1_M2_117780_62700 n1_M2_118860_62700 0.988200
R7070 n1_M2_118860_62700 n1_M2_119940_62700 0.988200
R7071 n1_M2_119940_62700 n1_M2_121020_62700 0.988200
R7072 n1_M2_121020_62700 n1_M2_122100_62700 0.988200
R7073 n1_M2_122100_62700 n1_M2_123180_62700 0.988200
R7074 n1_M2_123180_62700 n1_M2_124260_62700 0.988200
R7075 n1_M2_124260_62700 n1_M2_125340_62700 0.988200
R7076 n1_M2_125340_62700 n1_M2_126420_62700 0.988200
R7077 n1_M2_126420_62700 n1_M2_127500_62700 0.988200
R7078 n1_M2_127500_62700 n1_M2_128580_62700 0.988200
R7079 n1_M2_128580_62700 n1_M2_129660_62700 0.988200
R7080 n1_M2_60_63780 n1_M2_1140_63780 0.988200
R7081 n1_M2_1140_63780 n1_M2_2220_63780 0.988200
R7082 n1_M2_2220_63780 n1_M2_3300_63780 0.988200
R7083 n1_M2_3300_63780 n1_M2_4380_63780 0.988200
R7084 n1_M2_4380_63780 n1_M2_5460_63780 0.988200
R7085 n1_M2_5460_63780 n1_M2_6540_63780 0.988200
R7086 n1_M2_6540_63780 n1_M2_7620_63780 0.988200
R7087 n1_M2_7620_63780 n1_M2_8700_63780 0.988200
R7088 n1_M2_8700_63780 n1_M2_9780_63780 0.988200
R7089 n1_M2_9780_63780 n1_M2_10860_63780 0.988200
R7090 n1_M2_10860_63780 n1_M2_11940_63780 0.988200
R7091 n1_M2_11940_63780 n1_M2_13020_63780 0.988200
R7092 n1_M2_13020_63780 n1_M2_14100_63780 0.988200
R7093 n1_M2_14100_63780 n1_M2_15180_63780 0.988200
R7094 n1_M2_15180_63780 n1_M2_16260_63780 0.988200
R7095 n1_M2_16260_63780 n1_M2_17340_63780 0.988200
R7096 n1_M2_17340_63780 n1_M2_18420_63780 0.988200
R7097 n1_M2_18420_63780 n1_M2_19500_63780 0.988200
R7098 n1_M2_19500_63780 n1_M2_20580_63780 0.988200
R7099 n1_M2_20580_63780 n1_M2_21660_63780 0.988200
R7100 n1_M2_21660_63780 n1_M2_22740_63780 0.988200
R7101 n1_M2_22740_63780 n1_M2_23820_63780 0.988200
R7102 n1_M2_23820_63780 n1_M2_24900_63780 0.988200
R7103 n1_M2_24900_63780 n1_M2_25980_63780 0.988200
R7104 n1_M2_25980_63780 n1_M2_27060_63780 0.988200
R7105 n1_M2_27060_63780 n1_M2_28140_63780 0.988200
R7106 n1_M2_28140_63780 n1_M2_29220_63780 0.988200
R7107 n1_M2_29220_63780 n1_M2_30300_63780 0.988200
R7108 n1_M2_30300_63780 n1_M2_31380_63780 0.988200
R7109 n1_M2_31380_63780 n1_M2_32460_63780 0.988200
R7110 n1_M2_32460_63780 n1_M2_33540_63780 0.988200
R7111 n1_M2_33540_63780 n1_M2_34620_63780 0.988200
R7112 n1_M2_34620_63780 n1_M2_35700_63780 0.988200
R7113 n1_M2_35700_63780 n1_M2_36780_63780 0.988200
R7114 n1_M2_36780_63780 n1_M2_37860_63780 0.988200
R7115 n1_M2_37860_63780 n1_M2_38940_63780 0.988200
R7116 n1_M2_38940_63780 n1_M2_40020_63780 0.988200
R7117 n1_M2_40020_63780 n1_M2_41100_63780 0.988200
R7118 n1_M2_41100_63780 n1_M2_42180_63780 0.988200
R7119 n1_M2_42180_63780 n1_M2_43260_63780 0.988200
R7120 n1_M2_43260_63780 n1_M2_44340_63780 0.988200
R7121 n1_M2_44340_63780 n1_M2_45420_63780 0.988200
R7122 n1_M2_45420_63780 n1_M2_46500_63780 0.988200
R7123 n1_M2_46500_63780 n1_M2_47580_63780 0.988200
R7124 n1_M2_47580_63780 n1_M2_48660_63780 0.988200
R7125 n1_M2_48660_63780 n1_M2_49740_63780 0.988200
R7126 n1_M2_49740_63780 n1_M2_50820_63780 0.988200
R7127 n1_M2_50820_63780 n1_M2_51900_63780 0.988200
R7128 n1_M2_51900_63780 n1_M2_52980_63780 0.988200
R7129 n1_M2_52980_63780 n1_M2_54060_63780 0.988200
R7130 n1_M2_54060_63780 n1_M2_55140_63780 0.988200
R7131 n1_M2_55140_63780 n1_M2_56220_63780 0.988200
R7132 n1_M2_56220_63780 n1_M2_57300_63780 0.988200
R7133 n1_M2_57300_63780 n1_M2_58380_63780 0.988200
R7134 n1_M2_58380_63780 n1_M2_59460_63780 0.988200
R7135 n1_M2_59460_63780 n1_M2_60540_63780 0.988200
R7136 n1_M2_60540_63780 n1_M2_61620_63780 0.988200
R7137 n1_M2_61620_63780 n1_M2_62700_63780 0.988200
R7138 n1_M2_62700_63780 n1_M2_63780_63780 0.988200
R7139 n1_M2_63780_63780 n1_M2_64860_63780 0.988200
R7140 n1_M2_64860_63780 n1_M2_65940_63780 0.988200
R7141 n1_M2_65940_63780 n1_M2_67020_63780 0.988200
R7142 n1_M2_67020_63780 n1_M2_68100_63780 0.988200
R7143 n1_M2_68100_63780 n1_M2_69180_63780 0.988200
R7144 n1_M2_69180_63780 n1_M2_70260_63780 0.988200
R7145 n1_M2_70260_63780 n1_M2_71340_63780 0.988200
R7146 n1_M2_71340_63780 n1_M2_72420_63780 0.988200
R7147 n1_M2_72420_63780 n1_M2_73500_63780 0.988200
R7148 n1_M2_73500_63780 n1_M2_74580_63780 0.988200
R7149 n1_M2_74580_63780 n1_M2_75660_63780 0.988200
R7150 n1_M2_75660_63780 n1_M2_76740_63780 0.988200
R7151 n1_M2_76740_63780 n1_M2_77820_63780 0.988200
R7152 n1_M2_77820_63780 n1_M2_78900_63780 0.988200
R7153 n1_M2_78900_63780 n1_M2_79980_63780 0.988200
R7154 n1_M2_79980_63780 n1_M2_81060_63780 0.988200
R7155 n1_M2_81060_63780 n1_M2_82140_63780 0.988200
R7156 n1_M2_82140_63780 n1_M2_83220_63780 0.988200
R7157 n1_M2_83220_63780 n1_M2_84300_63780 0.988200
R7158 n1_M2_84300_63780 n1_M2_85380_63780 0.988200
R7159 n1_M2_85380_63780 n1_M2_86460_63780 0.988200
R7160 n1_M2_86460_63780 n1_M2_87540_63780 0.988200
R7161 n1_M2_87540_63780 n1_M2_88620_63780 0.988200
R7162 n1_M2_88620_63780 n1_M2_89700_63780 0.988200
R7163 n1_M2_89700_63780 n1_M2_90780_63780 0.988200
R7164 n1_M2_90780_63780 n1_M2_91860_63780 0.988200
R7165 n1_M2_91860_63780 n1_M2_92940_63780 0.988200
R7166 n1_M2_92940_63780 n1_M2_94020_63780 0.988200
R7167 n1_M2_94020_63780 n1_M2_95100_63780 0.988200
R7168 n1_M2_95100_63780 n1_M2_96180_63780 0.988200
R7169 n1_M2_96180_63780 n1_M2_97260_63780 0.988200
R7170 n1_M2_97260_63780 n1_M2_98340_63780 0.988200
R7171 n1_M2_98340_63780 n1_M2_99420_63780 0.988200
R7172 n1_M2_99420_63780 n1_M2_100500_63780 0.988200
R7173 n1_M2_100500_63780 n1_M2_101580_63780 0.988200
R7174 n1_M2_101580_63780 n1_M2_102660_63780 0.988200
R7175 n1_M2_102660_63780 n1_M2_103740_63780 0.988200
R7176 n1_M2_103740_63780 n1_M2_104820_63780 0.988200
R7177 n1_M2_104820_63780 n1_M2_105900_63780 0.988200
R7178 n1_M2_105900_63780 n1_M2_106980_63780 0.988200
R7179 n1_M2_106980_63780 n1_M2_108060_63780 0.988200
R7180 n1_M2_108060_63780 n1_M2_109140_63780 0.988200
R7181 n1_M2_109140_63780 n1_M2_110220_63780 0.988200
R7182 n1_M2_110220_63780 n1_M2_111300_63780 0.988200
R7183 n1_M2_111300_63780 n1_M2_112380_63780 0.988200
R7184 n1_M2_112380_63780 n1_M2_113460_63780 0.988200
R7185 n1_M2_113460_63780 n1_M2_114540_63780 0.988200
R7186 n1_M2_114540_63780 n1_M2_115620_63780 0.988200
R7187 n1_M2_115620_63780 n1_M2_116700_63780 0.988200
R7188 n1_M2_116700_63780 n1_M2_117780_63780 0.988200
R7189 n1_M2_117780_63780 n1_M2_118860_63780 0.988200
R7190 n1_M2_118860_63780 n1_M2_119940_63780 0.988200
R7191 n1_M2_119940_63780 n1_M2_121020_63780 0.988200
R7192 n1_M2_121020_63780 n1_M2_122100_63780 0.988200
R7193 n1_M2_122100_63780 n1_M2_123180_63780 0.988200
R7194 n1_M2_123180_63780 n1_M2_124260_63780 0.988200
R7195 n1_M2_124260_63780 n1_M2_125340_63780 0.988200
R7196 n1_M2_125340_63780 n1_M2_126420_63780 0.988200
R7197 n1_M2_126420_63780 n1_M2_127500_63780 0.988200
R7198 n1_M2_127500_63780 n1_M2_128580_63780 0.988200
R7199 n1_M2_128580_63780 n1_M2_129660_63780 0.988200
R7200 n1_M2_60_64860 n1_M2_1140_64860 0.988200
R7201 n1_M2_1140_64860 n1_M2_2220_64860 0.988200
R7202 n1_M2_2220_64860 n1_M2_3300_64860 0.988200
R7203 n1_M2_3300_64860 n1_M2_4380_64860 0.988200
R7204 n1_M2_4380_64860 n1_M2_5460_64860 0.988200
R7205 n1_M2_5460_64860 n1_M2_6540_64860 0.988200
R7206 n1_M2_6540_64860 n1_M2_7620_64860 0.988200
R7207 n1_M2_7620_64860 n1_M2_8700_64860 0.988200
R7208 n1_M2_8700_64860 n1_M2_9780_64860 0.988200
R7209 n1_M2_9780_64860 n1_M2_10860_64860 0.988200
R7210 n1_M2_10860_64860 n1_M2_11940_64860 0.988200
R7211 n1_M2_11940_64860 n1_M2_13020_64860 0.988200
R7212 n1_M2_13020_64860 n1_M2_14100_64860 0.988200
R7213 n1_M2_14100_64860 n1_M2_15180_64860 0.988200
R7214 n1_M2_15180_64860 n1_M2_16260_64860 0.988200
R7215 n1_M2_16260_64860 n1_M2_17340_64860 0.988200
R7216 n1_M2_17340_64860 n1_M2_18420_64860 0.988200
R7217 n1_M2_18420_64860 n1_M2_19500_64860 0.988200
R7218 n1_M2_19500_64860 n1_M2_20580_64860 0.988200
R7219 n1_M2_20580_64860 n1_M2_21660_64860 0.988200
R7220 n1_M2_21660_64860 n1_M2_22740_64860 0.988200
R7221 n1_M2_22740_64860 n1_M2_23820_64860 0.988200
R7222 n1_M2_23820_64860 n1_M2_24900_64860 0.988200
R7223 n1_M2_24900_64860 n1_M2_25980_64860 0.988200
R7224 n1_M2_25980_64860 n1_M2_27060_64860 0.988200
R7225 n1_M2_27060_64860 n1_M2_28140_64860 0.988200
R7226 n1_M2_28140_64860 n1_M2_29220_64860 0.988200
R7227 n1_M2_29220_64860 n1_M2_30300_64860 0.988200
R7228 n1_M2_30300_64860 n1_M2_31380_64860 0.988200
R7229 n1_M2_31380_64860 n1_M2_32460_64860 0.988200
R7230 n1_M2_32460_64860 n1_M2_33540_64860 0.988200
R7231 n1_M2_33540_64860 n1_M2_34620_64860 0.988200
R7232 n1_M2_34620_64860 n1_M2_35700_64860 0.988200
R7233 n1_M2_35700_64860 n1_M2_36780_64860 0.988200
R7234 n1_M2_36780_64860 n1_M2_37860_64860 0.988200
R7235 n1_M2_37860_64860 n1_M2_38940_64860 0.988200
R7236 n1_M2_38940_64860 n1_M2_40020_64860 0.988200
R7237 n1_M2_40020_64860 n1_M2_41100_64860 0.988200
R7238 n1_M2_41100_64860 n1_M2_42180_64860 0.988200
R7239 n1_M2_42180_64860 n1_M2_43260_64860 0.988200
R7240 n1_M2_43260_64860 n1_M2_44340_64860 0.988200
R7241 n1_M2_44340_64860 n1_M2_45420_64860 0.988200
R7242 n1_M2_45420_64860 n1_M2_46500_64860 0.988200
R7243 n1_M2_46500_64860 n1_M2_47580_64860 0.988200
R7244 n1_M2_47580_64860 n1_M2_48660_64860 0.988200
R7245 n1_M2_48660_64860 n1_M2_49740_64860 0.988200
R7246 n1_M2_49740_64860 n1_M2_50820_64860 0.988200
R7247 n1_M2_50820_64860 n1_M2_51900_64860 0.988200
R7248 n1_M2_51900_64860 n1_M2_52980_64860 0.988200
R7249 n1_M2_52980_64860 n1_M2_54060_64860 0.988200
R7250 n1_M2_54060_64860 n1_M2_55140_64860 0.988200
R7251 n1_M2_55140_64860 n1_M2_56220_64860 0.988200
R7252 n1_M2_56220_64860 n1_M2_57300_64860 0.988200
R7253 n1_M2_57300_64860 n1_M2_58380_64860 0.988200
R7254 n1_M2_58380_64860 n1_M2_59460_64860 0.988200
R7255 n1_M2_59460_64860 n1_M2_60540_64860 0.988200
R7256 n1_M2_60540_64860 n1_M2_61620_64860 0.988200
R7257 n1_M2_61620_64860 n1_M2_62700_64860 0.988200
R7258 n1_M2_62700_64860 n1_M2_63780_64860 0.988200
R7259 n1_M2_63780_64860 n1_M2_64860_64860 0.988200
R7260 n1_M2_64860_64860 n1_M2_65940_64860 0.988200
R7261 n1_M2_65940_64860 n1_M2_67020_64860 0.988200
R7262 n1_M2_67020_64860 n1_M2_68100_64860 0.988200
R7263 n1_M2_68100_64860 n1_M2_69180_64860 0.988200
R7264 n1_M2_69180_64860 n1_M2_70260_64860 0.988200
R7265 n1_M2_70260_64860 n1_M2_71340_64860 0.988200
R7266 n1_M2_71340_64860 n1_M2_72420_64860 0.988200
R7267 n1_M2_72420_64860 n1_M2_73500_64860 0.988200
R7268 n1_M2_73500_64860 n1_M2_74580_64860 0.988200
R7269 n1_M2_74580_64860 n1_M2_75660_64860 0.988200
R7270 n1_M2_75660_64860 n1_M2_76740_64860 0.988200
R7271 n1_M2_76740_64860 n1_M2_77820_64860 0.988200
R7272 n1_M2_77820_64860 n1_M2_78900_64860 0.988200
R7273 n1_M2_78900_64860 n1_M2_79980_64860 0.988200
R7274 n1_M2_79980_64860 n1_M2_81060_64860 0.988200
R7275 n1_M2_81060_64860 n1_M2_82140_64860 0.988200
R7276 n1_M2_82140_64860 n1_M2_83220_64860 0.988200
R7277 n1_M2_83220_64860 n1_M2_84300_64860 0.988200
R7278 n1_M2_84300_64860 n1_M2_85380_64860 0.988200
R7279 n1_M2_85380_64860 n1_M2_86460_64860 0.988200
R7280 n1_M2_86460_64860 n1_M2_87540_64860 0.988200
R7281 n1_M2_87540_64860 n1_M2_88620_64860 0.988200
R7282 n1_M2_88620_64860 n1_M2_89700_64860 0.988200
R7283 n1_M2_89700_64860 n1_M2_90780_64860 0.988200
R7284 n1_M2_90780_64860 n1_M2_91860_64860 0.988200
R7285 n1_M2_91860_64860 n1_M2_92940_64860 0.988200
R7286 n1_M2_92940_64860 n1_M2_94020_64860 0.988200
R7287 n1_M2_94020_64860 n1_M2_95100_64860 0.988200
R7288 n1_M2_95100_64860 n1_M2_96180_64860 0.988200
R7289 n1_M2_96180_64860 n1_M2_97260_64860 0.988200
R7290 n1_M2_97260_64860 n1_M2_98340_64860 0.988200
R7291 n1_M2_98340_64860 n1_M2_99420_64860 0.988200
R7292 n1_M2_99420_64860 n1_M2_100500_64860 0.988200
R7293 n1_M2_100500_64860 n1_M2_101580_64860 0.988200
R7294 n1_M2_101580_64860 n1_M2_102660_64860 0.988200
R7295 n1_M2_102660_64860 n1_M2_103740_64860 0.988200
R7296 n1_M2_103740_64860 n1_M2_104820_64860 0.988200
R7297 n1_M2_104820_64860 n1_M2_105900_64860 0.988200
R7298 n1_M2_105900_64860 n1_M2_106980_64860 0.988200
R7299 n1_M2_106980_64860 n1_M2_108060_64860 0.988200
R7300 n1_M2_108060_64860 n1_M2_109140_64860 0.988200
R7301 n1_M2_109140_64860 n1_M2_110220_64860 0.988200
R7302 n1_M2_110220_64860 n1_M2_111300_64860 0.988200
R7303 n1_M2_111300_64860 n1_M2_112380_64860 0.988200
R7304 n1_M2_112380_64860 n1_M2_113460_64860 0.988200
R7305 n1_M2_113460_64860 n1_M2_114540_64860 0.988200
R7306 n1_M2_114540_64860 n1_M2_115620_64860 0.988200
R7307 n1_M2_115620_64860 n1_M2_116700_64860 0.988200
R7308 n1_M2_116700_64860 n1_M2_117780_64860 0.988200
R7309 n1_M2_117780_64860 n1_M2_118860_64860 0.988200
R7310 n1_M2_118860_64860 n1_M2_119940_64860 0.988200
R7311 n1_M2_119940_64860 n1_M2_121020_64860 0.988200
R7312 n1_M2_121020_64860 n1_M2_122100_64860 0.988200
R7313 n1_M2_122100_64860 n1_M2_123180_64860 0.988200
R7314 n1_M2_123180_64860 n1_M2_124260_64860 0.988200
R7315 n1_M2_124260_64860 n1_M2_125340_64860 0.988200
R7316 n1_M2_125340_64860 n1_M2_126420_64860 0.988200
R7317 n1_M2_126420_64860 n1_M2_127500_64860 0.988200
R7318 n1_M2_127500_64860 n1_M2_128580_64860 0.988200
R7319 n1_M2_128580_64860 n1_M2_129660_64860 0.988200
R7320 n1_M2_60_65940 n1_M2_1140_65940 0.988200
R7321 n1_M2_1140_65940 n1_M2_2220_65940 0.988200
R7322 n1_M2_2220_65940 n1_M2_3300_65940 0.988200
R7323 n1_M2_3300_65940 n1_M2_4380_65940 0.988200
R7324 n1_M2_4380_65940 n1_M2_5460_65940 0.988200
R7325 n1_M2_5460_65940 n1_M2_6540_65940 0.988200
R7326 n1_M2_6540_65940 n1_M2_7620_65940 0.988200
R7327 n1_M2_7620_65940 n1_M2_8700_65940 0.988200
R7328 n1_M2_8700_65940 n1_M2_9780_65940 0.988200
R7329 n1_M2_9780_65940 n1_M2_10860_65940 0.988200
R7330 n1_M2_10860_65940 n1_M2_11940_65940 0.988200
R7331 n1_M2_11940_65940 n1_M2_13020_65940 0.988200
R7332 n1_M2_13020_65940 n1_M2_14100_65940 0.988200
R7333 n1_M2_14100_65940 n1_M2_15180_65940 0.988200
R7334 n1_M2_15180_65940 n1_M2_16260_65940 0.988200
R7335 n1_M2_16260_65940 n1_M2_17340_65940 0.988200
R7336 n1_M2_17340_65940 n1_M2_18420_65940 0.988200
R7337 n1_M2_18420_65940 n1_M2_19500_65940 0.988200
R7338 n1_M2_19500_65940 n1_M2_20580_65940 0.988200
R7339 n1_M2_20580_65940 n1_M2_21660_65940 0.988200
R7340 n1_M2_21660_65940 n1_M2_22740_65940 0.988200
R7341 n1_M2_22740_65940 n1_M2_23820_65940 0.988200
R7342 n1_M2_23820_65940 n1_M2_24900_65940 0.988200
R7343 n1_M2_24900_65940 n1_M2_25980_65940 0.988200
R7344 n1_M2_25980_65940 n1_M2_27060_65940 0.988200
R7345 n1_M2_27060_65940 n1_M2_28140_65940 0.988200
R7346 n1_M2_28140_65940 n1_M2_29220_65940 0.988200
R7347 n1_M2_29220_65940 n1_M2_30300_65940 0.988200
R7348 n1_M2_30300_65940 n1_M2_31380_65940 0.988200
R7349 n1_M2_31380_65940 n1_M2_32460_65940 0.988200
R7350 n1_M2_32460_65940 n1_M2_33540_65940 0.988200
R7351 n1_M2_33540_65940 n1_M2_34620_65940 0.988200
R7352 n1_M2_34620_65940 n1_M2_35700_65940 0.988200
R7353 n1_M2_35700_65940 n1_M2_36780_65940 0.988200
R7354 n1_M2_36780_65940 n1_M2_37860_65940 0.988200
R7355 n1_M2_37860_65940 n1_M2_38940_65940 0.988200
R7356 n1_M2_38940_65940 n1_M2_40020_65940 0.988200
R7357 n1_M2_40020_65940 n1_M2_41100_65940 0.988200
R7358 n1_M2_41100_65940 n1_M2_42180_65940 0.988200
R7359 n1_M2_42180_65940 n1_M2_43260_65940 0.988200
R7360 n1_M2_43260_65940 n1_M2_44340_65940 0.988200
R7361 n1_M2_44340_65940 n1_M2_45420_65940 0.988200
R7362 n1_M2_45420_65940 n1_M2_46500_65940 0.988200
R7363 n1_M2_46500_65940 n1_M2_47580_65940 0.988200
R7364 n1_M2_47580_65940 n1_M2_48660_65940 0.988200
R7365 n1_M2_48660_65940 n1_M2_49740_65940 0.988200
R7366 n1_M2_49740_65940 n1_M2_50820_65940 0.988200
R7367 n1_M2_50820_65940 n1_M2_51900_65940 0.988200
R7368 n1_M2_51900_65940 n1_M2_52980_65940 0.988200
R7369 n1_M2_52980_65940 n1_M2_54060_65940 0.988200
R7370 n1_M2_54060_65940 n1_M2_55140_65940 0.988200
R7371 n1_M2_55140_65940 n1_M2_56220_65940 0.988200
R7372 n1_M2_56220_65940 n1_M2_57300_65940 0.988200
R7373 n1_M2_57300_65940 n1_M2_58380_65940 0.988200
R7374 n1_M2_58380_65940 n1_M2_59460_65940 0.988200
R7375 n1_M2_59460_65940 n1_M2_60540_65940 0.988200
R7376 n1_M2_60540_65940 n1_M2_61620_65940 0.988200
R7377 n1_M2_61620_65940 n1_M2_62700_65940 0.988200
R7378 n1_M2_62700_65940 n1_M2_63780_65940 0.988200
R7379 n1_M2_63780_65940 n1_M2_64860_65940 0.988200
R7380 n1_M2_64860_65940 n1_M2_65940_65940 0.988200
R7381 n1_M2_65940_65940 n1_M2_67020_65940 0.988200
R7382 n1_M2_67020_65940 n1_M2_68100_65940 0.988200
R7383 n1_M2_68100_65940 n1_M2_69180_65940 0.988200
R7384 n1_M2_69180_65940 n1_M2_70260_65940 0.988200
R7385 n1_M2_70260_65940 n1_M2_71340_65940 0.988200
R7386 n1_M2_71340_65940 n1_M2_72420_65940 0.988200
R7387 n1_M2_72420_65940 n1_M2_73500_65940 0.988200
R7388 n1_M2_73500_65940 n1_M2_74580_65940 0.988200
R7389 n1_M2_74580_65940 n1_M2_75660_65940 0.988200
R7390 n1_M2_75660_65940 n1_M2_76740_65940 0.988200
R7391 n1_M2_76740_65940 n1_M2_77820_65940 0.988200
R7392 n1_M2_77820_65940 n1_M2_78900_65940 0.988200
R7393 n1_M2_78900_65940 n1_M2_79980_65940 0.988200
R7394 n1_M2_79980_65940 n1_M2_81060_65940 0.988200
R7395 n1_M2_81060_65940 n1_M2_82140_65940 0.988200
R7396 n1_M2_82140_65940 n1_M2_83220_65940 0.988200
R7397 n1_M2_83220_65940 n1_M2_84300_65940 0.988200
R7398 n1_M2_84300_65940 n1_M2_85380_65940 0.988200
R7399 n1_M2_85380_65940 n1_M2_86460_65940 0.988200
R7400 n1_M2_86460_65940 n1_M2_87540_65940 0.988200
R7401 n1_M2_87540_65940 n1_M2_88620_65940 0.988200
R7402 n1_M2_88620_65940 n1_M2_89700_65940 0.988200
R7403 n1_M2_89700_65940 n1_M2_90780_65940 0.988200
R7404 n1_M2_90780_65940 n1_M2_91860_65940 0.988200
R7405 n1_M2_91860_65940 n1_M2_92940_65940 0.988200
R7406 n1_M2_92940_65940 n1_M2_94020_65940 0.988200
R7407 n1_M2_94020_65940 n1_M2_95100_65940 0.988200
R7408 n1_M2_95100_65940 n1_M2_96180_65940 0.988200
R7409 n1_M2_96180_65940 n1_M2_97260_65940 0.988200
R7410 n1_M2_97260_65940 n1_M2_98340_65940 0.988200
R7411 n1_M2_98340_65940 n1_M2_99420_65940 0.988200
R7412 n1_M2_99420_65940 n1_M2_100500_65940 0.988200
R7413 n1_M2_100500_65940 n1_M2_101580_65940 0.988200
R7414 n1_M2_101580_65940 n1_M2_102660_65940 0.988200
R7415 n1_M2_102660_65940 n1_M2_103740_65940 0.988200
R7416 n1_M2_103740_65940 n1_M2_104820_65940 0.988200
R7417 n1_M2_104820_65940 n1_M2_105900_65940 0.988200
R7418 n1_M2_105900_65940 n1_M2_106980_65940 0.988200
R7419 n1_M2_106980_65940 n1_M2_108060_65940 0.988200
R7420 n1_M2_108060_65940 n1_M2_109140_65940 0.988200
R7421 n1_M2_109140_65940 n1_M2_110220_65940 0.988200
R7422 n1_M2_110220_65940 n1_M2_111300_65940 0.988200
R7423 n1_M2_111300_65940 n1_M2_112380_65940 0.988200
R7424 n1_M2_112380_65940 n1_M2_113460_65940 0.988200
R7425 n1_M2_113460_65940 n1_M2_114540_65940 0.988200
R7426 n1_M2_114540_65940 n1_M2_115620_65940 0.988200
R7427 n1_M2_115620_65940 n1_M2_116700_65940 0.988200
R7428 n1_M2_116700_65940 n1_M2_117780_65940 0.988200
R7429 n1_M2_117780_65940 n1_M2_118860_65940 0.988200
R7430 n1_M2_118860_65940 n1_M2_119940_65940 0.988200
R7431 n1_M2_119940_65940 n1_M2_121020_65940 0.988200
R7432 n1_M2_121020_65940 n1_M2_122100_65940 0.988200
R7433 n1_M2_122100_65940 n1_M2_123180_65940 0.988200
R7434 n1_M2_123180_65940 n1_M2_124260_65940 0.988200
R7435 n1_M2_124260_65940 n1_M2_125340_65940 0.988200
R7436 n1_M2_125340_65940 n1_M2_126420_65940 0.988200
R7437 n1_M2_126420_65940 n1_M2_127500_65940 0.988200
R7438 n1_M2_127500_65940 n1_M2_128580_65940 0.988200
R7439 n1_M2_128580_65940 n1_M2_129660_65940 0.988200
R7440 n1_M2_60_67020 n1_M2_1140_67020 0.988200
R7441 n1_M2_1140_67020 n1_M2_2220_67020 0.988200
R7442 n1_M2_2220_67020 n1_M2_3300_67020 0.988200
R7443 n1_M2_3300_67020 n1_M2_4380_67020 0.988200
R7444 n1_M2_4380_67020 n1_M2_5460_67020 0.988200
R7445 n1_M2_5460_67020 n1_M2_6540_67020 0.988200
R7446 n1_M2_6540_67020 n1_M2_7620_67020 0.988200
R7447 n1_M2_7620_67020 n1_M2_8700_67020 0.988200
R7448 n1_M2_8700_67020 n1_M2_9780_67020 0.988200
R7449 n1_M2_9780_67020 n1_M2_10860_67020 0.988200
R7450 n1_M2_10860_67020 n1_M2_11940_67020 0.988200
R7451 n1_M2_11940_67020 n1_M2_13020_67020 0.988200
R7452 n1_M2_13020_67020 n1_M2_14100_67020 0.988200
R7453 n1_M2_14100_67020 n1_M2_15180_67020 0.988200
R7454 n1_M2_15180_67020 n1_M2_16260_67020 0.988200
R7455 n1_M2_16260_67020 n1_M2_17340_67020 0.988200
R7456 n1_M2_17340_67020 n1_M2_18420_67020 0.988200
R7457 n1_M2_18420_67020 n1_M2_19500_67020 0.988200
R7458 n1_M2_19500_67020 n1_M2_20580_67020 0.988200
R7459 n1_M2_20580_67020 n1_M2_21660_67020 0.988200
R7460 n1_M2_21660_67020 n1_M2_22740_67020 0.988200
R7461 n1_M2_22740_67020 n1_M2_23820_67020 0.988200
R7462 n1_M2_23820_67020 n1_M2_24900_67020 0.988200
R7463 n1_M2_24900_67020 n1_M2_25980_67020 0.988200
R7464 n1_M2_25980_67020 n1_M2_27060_67020 0.988200
R7465 n1_M2_27060_67020 n1_M2_28140_67020 0.988200
R7466 n1_M2_28140_67020 n1_M2_29220_67020 0.988200
R7467 n1_M2_29220_67020 n1_M2_30300_67020 0.988200
R7468 n1_M2_30300_67020 n1_M2_31380_67020 0.988200
R7469 n1_M2_31380_67020 n1_M2_32460_67020 0.988200
R7470 n1_M2_32460_67020 n1_M2_33540_67020 0.988200
R7471 n1_M2_33540_67020 n1_M2_34620_67020 0.988200
R7472 n1_M2_34620_67020 n1_M2_35700_67020 0.988200
R7473 n1_M2_35700_67020 n1_M2_36780_67020 0.988200
R7474 n1_M2_36780_67020 n1_M2_37860_67020 0.988200
R7475 n1_M2_37860_67020 n1_M2_38940_67020 0.988200
R7476 n1_M2_38940_67020 n1_M2_40020_67020 0.988200
R7477 n1_M2_40020_67020 n1_M2_41100_67020 0.988200
R7478 n1_M2_41100_67020 n1_M2_42180_67020 0.988200
R7479 n1_M2_42180_67020 n1_M2_43260_67020 0.988200
R7480 n1_M2_43260_67020 n1_M2_44340_67020 0.988200
R7481 n1_M2_44340_67020 n1_M2_45420_67020 0.988200
R7482 n1_M2_45420_67020 n1_M2_46500_67020 0.988200
R7483 n1_M2_46500_67020 n1_M2_47580_67020 0.988200
R7484 n1_M2_47580_67020 n1_M2_48660_67020 0.988200
R7485 n1_M2_48660_67020 n1_M2_49740_67020 0.988200
R7486 n1_M2_49740_67020 n1_M2_50820_67020 0.988200
R7487 n1_M2_50820_67020 n1_M2_51900_67020 0.988200
R7488 n1_M2_51900_67020 n1_M2_52980_67020 0.988200
R7489 n1_M2_52980_67020 n1_M2_54060_67020 0.988200
R7490 n1_M2_54060_67020 n1_M2_55140_67020 0.988200
R7491 n1_M2_55140_67020 n1_M2_56220_67020 0.988200
R7492 n1_M2_56220_67020 n1_M2_57300_67020 0.988200
R7493 n1_M2_57300_67020 n1_M2_58380_67020 0.988200
R7494 n1_M2_58380_67020 n1_M2_59460_67020 0.988200
R7495 n1_M2_59460_67020 n1_M2_60540_67020 0.988200
R7496 n1_M2_60540_67020 n1_M2_61620_67020 0.988200
R7497 n1_M2_61620_67020 n1_M2_62700_67020 0.988200
R7498 n1_M2_62700_67020 n1_M2_63780_67020 0.988200
R7499 n1_M2_63780_67020 n1_M2_64860_67020 0.988200
R7500 n1_M2_64860_67020 n1_M2_65940_67020 0.988200
R7501 n1_M2_65940_67020 n1_M2_67020_67020 0.988200
R7502 n1_M2_67020_67020 n1_M2_68100_67020 0.988200
R7503 n1_M2_68100_67020 n1_M2_69180_67020 0.988200
R7504 n1_M2_69180_67020 n1_M2_70260_67020 0.988200
R7505 n1_M2_70260_67020 n1_M2_71340_67020 0.988200
R7506 n1_M2_71340_67020 n1_M2_72420_67020 0.988200
R7507 n1_M2_72420_67020 n1_M2_73500_67020 0.988200
R7508 n1_M2_73500_67020 n1_M2_74580_67020 0.988200
R7509 n1_M2_74580_67020 n1_M2_75660_67020 0.988200
R7510 n1_M2_75660_67020 n1_M2_76740_67020 0.988200
R7511 n1_M2_76740_67020 n1_M2_77820_67020 0.988200
R7512 n1_M2_77820_67020 n1_M2_78900_67020 0.988200
R7513 n1_M2_78900_67020 n1_M2_79980_67020 0.988200
R7514 n1_M2_79980_67020 n1_M2_81060_67020 0.988200
R7515 n1_M2_81060_67020 n1_M2_82140_67020 0.988200
R7516 n1_M2_82140_67020 n1_M2_83220_67020 0.988200
R7517 n1_M2_83220_67020 n1_M2_84300_67020 0.988200
R7518 n1_M2_84300_67020 n1_M2_85380_67020 0.988200
R7519 n1_M2_85380_67020 n1_M2_86460_67020 0.988200
R7520 n1_M2_86460_67020 n1_M2_87540_67020 0.988200
R7521 n1_M2_87540_67020 n1_M2_88620_67020 0.988200
R7522 n1_M2_88620_67020 n1_M2_89700_67020 0.988200
R7523 n1_M2_89700_67020 n1_M2_90780_67020 0.988200
R7524 n1_M2_90780_67020 n1_M2_91860_67020 0.988200
R7525 n1_M2_91860_67020 n1_M2_92940_67020 0.988200
R7526 n1_M2_92940_67020 n1_M2_94020_67020 0.988200
R7527 n1_M2_94020_67020 n1_M2_95100_67020 0.988200
R7528 n1_M2_95100_67020 n1_M2_96180_67020 0.988200
R7529 n1_M2_96180_67020 n1_M2_97260_67020 0.988200
R7530 n1_M2_97260_67020 n1_M2_98340_67020 0.988200
R7531 n1_M2_98340_67020 n1_M2_99420_67020 0.988200
R7532 n1_M2_99420_67020 n1_M2_100500_67020 0.988200
R7533 n1_M2_100500_67020 n1_M2_101580_67020 0.988200
R7534 n1_M2_101580_67020 n1_M2_102660_67020 0.988200
R7535 n1_M2_102660_67020 n1_M2_103740_67020 0.988200
R7536 n1_M2_103740_67020 n1_M2_104820_67020 0.988200
R7537 n1_M2_104820_67020 n1_M2_105900_67020 0.988200
R7538 n1_M2_105900_67020 n1_M2_106980_67020 0.988200
R7539 n1_M2_106980_67020 n1_M2_108060_67020 0.988200
R7540 n1_M2_108060_67020 n1_M2_109140_67020 0.988200
R7541 n1_M2_109140_67020 n1_M2_110220_67020 0.988200
R7542 n1_M2_110220_67020 n1_M2_111300_67020 0.988200
R7543 n1_M2_111300_67020 n1_M2_112380_67020 0.988200
R7544 n1_M2_112380_67020 n1_M2_113460_67020 0.988200
R7545 n1_M2_113460_67020 n1_M2_114540_67020 0.988200
R7546 n1_M2_114540_67020 n1_M2_115620_67020 0.988200
R7547 n1_M2_115620_67020 n1_M2_116700_67020 0.988200
R7548 n1_M2_116700_67020 n1_M2_117780_67020 0.988200
R7549 n1_M2_117780_67020 n1_M2_118860_67020 0.988200
R7550 n1_M2_118860_67020 n1_M2_119940_67020 0.988200
R7551 n1_M2_119940_67020 n1_M2_121020_67020 0.988200
R7552 n1_M2_121020_67020 n1_M2_122100_67020 0.988200
R7553 n1_M2_122100_67020 n1_M2_123180_67020 0.988200
R7554 n1_M2_123180_67020 n1_M2_124260_67020 0.988200
R7555 n1_M2_124260_67020 n1_M2_125340_67020 0.988200
R7556 n1_M2_125340_67020 n1_M2_126420_67020 0.988200
R7557 n1_M2_126420_67020 n1_M2_127500_67020 0.988200
R7558 n1_M2_127500_67020 n1_M2_128580_67020 0.988200
R7559 n1_M2_128580_67020 n1_M2_129660_67020 0.988200
R7560 n1_M2_60_68100 n1_M2_1140_68100 0.988200
R7561 n1_M2_1140_68100 n1_M2_2220_68100 0.988200
R7562 n1_M2_2220_68100 n1_M2_3300_68100 0.988200
R7563 n1_M2_3300_68100 n1_M2_4380_68100 0.988200
R7564 n1_M2_4380_68100 n1_M2_5460_68100 0.988200
R7565 n1_M2_5460_68100 n1_M2_6540_68100 0.988200
R7566 n1_M2_6540_68100 n1_M2_7620_68100 0.988200
R7567 n1_M2_7620_68100 n1_M2_8700_68100 0.988200
R7568 n1_M2_8700_68100 n1_M2_9780_68100 0.988200
R7569 n1_M2_9780_68100 n1_M2_10860_68100 0.988200
R7570 n1_M2_10860_68100 n1_M2_11940_68100 0.988200
R7571 n1_M2_11940_68100 n1_M2_13020_68100 0.988200
R7572 n1_M2_13020_68100 n1_M2_14100_68100 0.988200
R7573 n1_M2_14100_68100 n1_M2_15180_68100 0.988200
R7574 n1_M2_15180_68100 n1_M2_16260_68100 0.988200
R7575 n1_M2_16260_68100 n1_M2_17340_68100 0.988200
R7576 n1_M2_17340_68100 n1_M2_18420_68100 0.988200
R7577 n1_M2_18420_68100 n1_M2_19500_68100 0.988200
R7578 n1_M2_19500_68100 n1_M2_20580_68100 0.988200
R7579 n1_M2_20580_68100 n1_M2_21660_68100 0.988200
R7580 n1_M2_21660_68100 n1_M2_22740_68100 0.988200
R7581 n1_M2_22740_68100 n1_M2_23820_68100 0.988200
R7582 n1_M2_23820_68100 n1_M2_24900_68100 0.988200
R7583 n1_M2_24900_68100 n1_M2_25980_68100 0.988200
R7584 n1_M2_25980_68100 n1_M2_27060_68100 0.988200
R7585 n1_M2_27060_68100 n1_M2_28140_68100 0.988200
R7586 n1_M2_28140_68100 n1_M2_29220_68100 0.988200
R7587 n1_M2_29220_68100 n1_M2_30300_68100 0.988200
R7588 n1_M2_30300_68100 n1_M2_31380_68100 0.988200
R7589 n1_M2_31380_68100 n1_M2_32460_68100 0.988200
R7590 n1_M2_32460_68100 n1_M2_33540_68100 0.988200
R7591 n1_M2_33540_68100 n1_M2_34620_68100 0.988200
R7592 n1_M2_34620_68100 n1_M2_35700_68100 0.988200
R7593 n1_M2_35700_68100 n1_M2_36780_68100 0.988200
R7594 n1_M2_36780_68100 n1_M2_37860_68100 0.988200
R7595 n1_M2_37860_68100 n1_M2_38940_68100 0.988200
R7596 n1_M2_38940_68100 n1_M2_40020_68100 0.988200
R7597 n1_M2_40020_68100 n1_M2_41100_68100 0.988200
R7598 n1_M2_41100_68100 n1_M2_42180_68100 0.988200
R7599 n1_M2_42180_68100 n1_M2_43260_68100 0.988200
R7600 n1_M2_43260_68100 n1_M2_44340_68100 0.988200
R7601 n1_M2_44340_68100 n1_M2_45420_68100 0.988200
R7602 n1_M2_45420_68100 n1_M2_46500_68100 0.988200
R7603 n1_M2_46500_68100 n1_M2_47580_68100 0.988200
R7604 n1_M2_47580_68100 n1_M2_48660_68100 0.988200
R7605 n1_M2_48660_68100 n1_M2_49740_68100 0.988200
R7606 n1_M2_49740_68100 n1_M2_50820_68100 0.988200
R7607 n1_M2_50820_68100 n1_M2_51900_68100 0.988200
R7608 n1_M2_51900_68100 n1_M2_52980_68100 0.988200
R7609 n1_M2_52980_68100 n1_M2_54060_68100 0.988200
R7610 n1_M2_54060_68100 n1_M2_55140_68100 0.988200
R7611 n1_M2_55140_68100 n1_M2_56220_68100 0.988200
R7612 n1_M2_56220_68100 n1_M2_57300_68100 0.988200
R7613 n1_M2_57300_68100 n1_M2_58380_68100 0.988200
R7614 n1_M2_58380_68100 n1_M2_59460_68100 0.988200
R7615 n1_M2_59460_68100 n1_M2_60540_68100 0.988200
R7616 n1_M2_60540_68100 n1_M2_61620_68100 0.988200
R7617 n1_M2_61620_68100 n1_M2_62700_68100 0.988200
R7618 n1_M2_62700_68100 n1_M2_63780_68100 0.988200
R7619 n1_M2_63780_68100 n1_M2_64860_68100 0.988200
R7620 n1_M2_64860_68100 n1_M2_65940_68100 0.988200
R7621 n1_M2_65940_68100 n1_M2_67020_68100 0.988200
R7622 n1_M2_67020_68100 n1_M2_68100_68100 0.988200
R7623 n1_M2_68100_68100 n1_M2_69180_68100 0.988200
R7624 n1_M2_69180_68100 n1_M2_70260_68100 0.988200
R7625 n1_M2_70260_68100 n1_M2_71340_68100 0.988200
R7626 n1_M2_71340_68100 n1_M2_72420_68100 0.988200
R7627 n1_M2_72420_68100 n1_M2_73500_68100 0.988200
R7628 n1_M2_73500_68100 n1_M2_74580_68100 0.988200
R7629 n1_M2_74580_68100 n1_M2_75660_68100 0.988200
R7630 n1_M2_75660_68100 n1_M2_76740_68100 0.988200
R7631 n1_M2_76740_68100 n1_M2_77820_68100 0.988200
R7632 n1_M2_77820_68100 n1_M2_78900_68100 0.988200
R7633 n1_M2_78900_68100 n1_M2_79980_68100 0.988200
R7634 n1_M2_79980_68100 n1_M2_81060_68100 0.988200
R7635 n1_M2_81060_68100 n1_M2_82140_68100 0.988200
R7636 n1_M2_82140_68100 n1_M2_83220_68100 0.988200
R7637 n1_M2_83220_68100 n1_M2_84300_68100 0.988200
R7638 n1_M2_84300_68100 n1_M2_85380_68100 0.988200
R7639 n1_M2_85380_68100 n1_M2_86460_68100 0.988200
R7640 n1_M2_86460_68100 n1_M2_87540_68100 0.988200
R7641 n1_M2_87540_68100 n1_M2_88620_68100 0.988200
R7642 n1_M2_88620_68100 n1_M2_89700_68100 0.988200
R7643 n1_M2_89700_68100 n1_M2_90780_68100 0.988200
R7644 n1_M2_90780_68100 n1_M2_91860_68100 0.988200
R7645 n1_M2_91860_68100 n1_M2_92940_68100 0.988200
R7646 n1_M2_92940_68100 n1_M2_94020_68100 0.988200
R7647 n1_M2_94020_68100 n1_M2_95100_68100 0.988200
R7648 n1_M2_95100_68100 n1_M2_96180_68100 0.988200
R7649 n1_M2_96180_68100 n1_M2_97260_68100 0.988200
R7650 n1_M2_97260_68100 n1_M2_98340_68100 0.988200
R7651 n1_M2_98340_68100 n1_M2_99420_68100 0.988200
R7652 n1_M2_99420_68100 n1_M2_100500_68100 0.988200
R7653 n1_M2_100500_68100 n1_M2_101580_68100 0.988200
R7654 n1_M2_101580_68100 n1_M2_102660_68100 0.988200
R7655 n1_M2_102660_68100 n1_M2_103740_68100 0.988200
R7656 n1_M2_103740_68100 n1_M2_104820_68100 0.988200
R7657 n1_M2_104820_68100 n1_M2_105900_68100 0.988200
R7658 n1_M2_105900_68100 n1_M2_106980_68100 0.988200
R7659 n1_M2_106980_68100 n1_M2_108060_68100 0.988200
R7660 n1_M2_108060_68100 n1_M2_109140_68100 0.988200
R7661 n1_M2_109140_68100 n1_M2_110220_68100 0.988200
R7662 n1_M2_110220_68100 n1_M2_111300_68100 0.988200
R7663 n1_M2_111300_68100 n1_M2_112380_68100 0.988200
R7664 n1_M2_112380_68100 n1_M2_113460_68100 0.988200
R7665 n1_M2_113460_68100 n1_M2_114540_68100 0.988200
R7666 n1_M2_114540_68100 n1_M2_115620_68100 0.988200
R7667 n1_M2_115620_68100 n1_M2_116700_68100 0.988200
R7668 n1_M2_116700_68100 n1_M2_117780_68100 0.988200
R7669 n1_M2_117780_68100 n1_M2_118860_68100 0.988200
R7670 n1_M2_118860_68100 n1_M2_119940_68100 0.988200
R7671 n1_M2_119940_68100 n1_M2_121020_68100 0.988200
R7672 n1_M2_121020_68100 n1_M2_122100_68100 0.988200
R7673 n1_M2_122100_68100 n1_M2_123180_68100 0.988200
R7674 n1_M2_123180_68100 n1_M2_124260_68100 0.988200
R7675 n1_M2_124260_68100 n1_M2_125340_68100 0.988200
R7676 n1_M2_125340_68100 n1_M2_126420_68100 0.988200
R7677 n1_M2_126420_68100 n1_M2_127500_68100 0.988200
R7678 n1_M2_127500_68100 n1_M2_128580_68100 0.988200
R7679 n1_M2_128580_68100 n1_M2_129660_68100 0.988200
R7680 n1_M2_60_69180 n1_M2_1140_69180 0.988200
R7681 n1_M2_1140_69180 n1_M2_2220_69180 0.988200
R7682 n1_M2_2220_69180 n1_M2_3300_69180 0.988200
R7683 n1_M2_3300_69180 n1_M2_4380_69180 0.988200
R7684 n1_M2_4380_69180 n1_M2_5460_69180 0.988200
R7685 n1_M2_5460_69180 n1_M2_6540_69180 0.988200
R7686 n1_M2_6540_69180 n1_M2_7620_69180 0.988200
R7687 n1_M2_7620_69180 n1_M2_8700_69180 0.988200
R7688 n1_M2_8700_69180 n1_M2_9780_69180 0.988200
R7689 n1_M2_9780_69180 n1_M2_10860_69180 0.988200
R7690 n1_M2_10860_69180 n1_M2_11940_69180 0.988200
R7691 n1_M2_11940_69180 n1_M2_13020_69180 0.988200
R7692 n1_M2_13020_69180 n1_M2_14100_69180 0.988200
R7693 n1_M2_14100_69180 n1_M2_15180_69180 0.988200
R7694 n1_M2_15180_69180 n1_M2_16260_69180 0.988200
R7695 n1_M2_16260_69180 n1_M2_17340_69180 0.988200
R7696 n1_M2_17340_69180 n1_M2_18420_69180 0.988200
R7697 n1_M2_18420_69180 n1_M2_19500_69180 0.988200
R7698 n1_M2_19500_69180 n1_M2_20580_69180 0.988200
R7699 n1_M2_20580_69180 n1_M2_21660_69180 0.988200
R7700 n1_M2_21660_69180 n1_M2_22740_69180 0.988200
R7701 n1_M2_22740_69180 n1_M2_23820_69180 0.988200
R7702 n1_M2_23820_69180 n1_M2_24900_69180 0.988200
R7703 n1_M2_24900_69180 n1_M2_25980_69180 0.988200
R7704 n1_M2_25980_69180 n1_M2_27060_69180 0.988200
R7705 n1_M2_27060_69180 n1_M2_28140_69180 0.988200
R7706 n1_M2_28140_69180 n1_M2_29220_69180 0.988200
R7707 n1_M2_29220_69180 n1_M2_30300_69180 0.988200
R7708 n1_M2_30300_69180 n1_M2_31380_69180 0.988200
R7709 n1_M2_31380_69180 n1_M2_32460_69180 0.988200
R7710 n1_M2_32460_69180 n1_M2_33540_69180 0.988200
R7711 n1_M2_33540_69180 n1_M2_34620_69180 0.988200
R7712 n1_M2_34620_69180 n1_M2_35700_69180 0.988200
R7713 n1_M2_35700_69180 n1_M2_36780_69180 0.988200
R7714 n1_M2_36780_69180 n1_M2_37860_69180 0.988200
R7715 n1_M2_37860_69180 n1_M2_38940_69180 0.988200
R7716 n1_M2_38940_69180 n1_M2_40020_69180 0.988200
R7717 n1_M2_40020_69180 n1_M2_41100_69180 0.988200
R7718 n1_M2_41100_69180 n1_M2_42180_69180 0.988200
R7719 n1_M2_42180_69180 n1_M2_43260_69180 0.988200
R7720 n1_M2_43260_69180 n1_M2_44340_69180 0.988200
R7721 n1_M2_44340_69180 n1_M2_45420_69180 0.988200
R7722 n1_M2_45420_69180 n1_M2_46500_69180 0.988200
R7723 n1_M2_46500_69180 n1_M2_47580_69180 0.988200
R7724 n1_M2_47580_69180 n1_M2_48660_69180 0.988200
R7725 n1_M2_48660_69180 n1_M2_49740_69180 0.988200
R7726 n1_M2_49740_69180 n1_M2_50820_69180 0.988200
R7727 n1_M2_50820_69180 n1_M2_51900_69180 0.988200
R7728 n1_M2_51900_69180 n1_M2_52980_69180 0.988200
R7729 n1_M2_52980_69180 n1_M2_54060_69180 0.988200
R7730 n1_M2_54060_69180 n1_M2_55140_69180 0.988200
R7731 n1_M2_55140_69180 n1_M2_56220_69180 0.988200
R7732 n1_M2_56220_69180 n1_M2_57300_69180 0.988200
R7733 n1_M2_57300_69180 n1_M2_58380_69180 0.988200
R7734 n1_M2_58380_69180 n1_M2_59460_69180 0.988200
R7735 n1_M2_59460_69180 n1_M2_60540_69180 0.988200
R7736 n1_M2_60540_69180 n1_M2_61620_69180 0.988200
R7737 n1_M2_61620_69180 n1_M2_62700_69180 0.988200
R7738 n1_M2_62700_69180 n1_M2_63780_69180 0.988200
R7739 n1_M2_63780_69180 n1_M2_64860_69180 0.988200
R7740 n1_M2_64860_69180 n1_M2_65940_69180 0.988200
R7741 n1_M2_65940_69180 n1_M2_67020_69180 0.988200
R7742 n1_M2_67020_69180 n1_M2_68100_69180 0.988200
R7743 n1_M2_68100_69180 n1_M2_69180_69180 0.988200
R7744 n1_M2_69180_69180 n1_M2_70260_69180 0.988200
R7745 n1_M2_70260_69180 n1_M2_71340_69180 0.988200
R7746 n1_M2_71340_69180 n1_M2_72420_69180 0.988200
R7747 n1_M2_72420_69180 n1_M2_73500_69180 0.988200
R7748 n1_M2_73500_69180 n1_M2_74580_69180 0.988200
R7749 n1_M2_74580_69180 n1_M2_75660_69180 0.988200
R7750 n1_M2_75660_69180 n1_M2_76740_69180 0.988200
R7751 n1_M2_76740_69180 n1_M2_77820_69180 0.988200
R7752 n1_M2_77820_69180 n1_M2_78900_69180 0.988200
R7753 n1_M2_78900_69180 n1_M2_79980_69180 0.988200
R7754 n1_M2_79980_69180 n1_M2_81060_69180 0.988200
R7755 n1_M2_81060_69180 n1_M2_82140_69180 0.988200
R7756 n1_M2_82140_69180 n1_M2_83220_69180 0.988200
R7757 n1_M2_83220_69180 n1_M2_84300_69180 0.988200
R7758 n1_M2_84300_69180 n1_M2_85380_69180 0.988200
R7759 n1_M2_85380_69180 n1_M2_86460_69180 0.988200
R7760 n1_M2_86460_69180 n1_M2_87540_69180 0.988200
R7761 n1_M2_87540_69180 n1_M2_88620_69180 0.988200
R7762 n1_M2_88620_69180 n1_M2_89700_69180 0.988200
R7763 n1_M2_89700_69180 n1_M2_90780_69180 0.988200
R7764 n1_M2_90780_69180 n1_M2_91860_69180 0.988200
R7765 n1_M2_91860_69180 n1_M2_92940_69180 0.988200
R7766 n1_M2_92940_69180 n1_M2_94020_69180 0.988200
R7767 n1_M2_94020_69180 n1_M2_95100_69180 0.988200
R7768 n1_M2_95100_69180 n1_M2_96180_69180 0.988200
R7769 n1_M2_96180_69180 n1_M2_97260_69180 0.988200
R7770 n1_M2_97260_69180 n1_M2_98340_69180 0.988200
R7771 n1_M2_98340_69180 n1_M2_99420_69180 0.988200
R7772 n1_M2_99420_69180 n1_M2_100500_69180 0.988200
R7773 n1_M2_100500_69180 n1_M2_101580_69180 0.988200
R7774 n1_M2_101580_69180 n1_M2_102660_69180 0.988200
R7775 n1_M2_102660_69180 n1_M2_103740_69180 0.988200
R7776 n1_M2_103740_69180 n1_M2_104820_69180 0.988200
R7777 n1_M2_104820_69180 n1_M2_105900_69180 0.988200
R7778 n1_M2_105900_69180 n1_M2_106980_69180 0.988200
R7779 n1_M2_106980_69180 n1_M2_108060_69180 0.988200
R7780 n1_M2_108060_69180 n1_M2_109140_69180 0.988200
R7781 n1_M2_109140_69180 n1_M2_110220_69180 0.988200
R7782 n1_M2_110220_69180 n1_M2_111300_69180 0.988200
R7783 n1_M2_111300_69180 n1_M2_112380_69180 0.988200
R7784 n1_M2_112380_69180 n1_M2_113460_69180 0.988200
R7785 n1_M2_113460_69180 n1_M2_114540_69180 0.988200
R7786 n1_M2_114540_69180 n1_M2_115620_69180 0.988200
R7787 n1_M2_115620_69180 n1_M2_116700_69180 0.988200
R7788 n1_M2_116700_69180 n1_M2_117780_69180 0.988200
R7789 n1_M2_117780_69180 n1_M2_118860_69180 0.988200
R7790 n1_M2_118860_69180 n1_M2_119940_69180 0.988200
R7791 n1_M2_119940_69180 n1_M2_121020_69180 0.988200
R7792 n1_M2_121020_69180 n1_M2_122100_69180 0.988200
R7793 n1_M2_122100_69180 n1_M2_123180_69180 0.988200
R7794 n1_M2_123180_69180 n1_M2_124260_69180 0.988200
R7795 n1_M2_124260_69180 n1_M2_125340_69180 0.988200
R7796 n1_M2_125340_69180 n1_M2_126420_69180 0.988200
R7797 n1_M2_126420_69180 n1_M2_127500_69180 0.988200
R7798 n1_M2_127500_69180 n1_M2_128580_69180 0.988200
R7799 n1_M2_128580_69180 n1_M2_129660_69180 0.988200
R7800 n1_M2_60_70260 n1_M2_1140_70260 0.988200
R7801 n1_M2_1140_70260 n1_M2_2220_70260 0.988200
R7802 n1_M2_2220_70260 n1_M2_3300_70260 0.988200
R7803 n1_M2_3300_70260 n1_M2_4380_70260 0.988200
R7804 n1_M2_4380_70260 n1_M2_5460_70260 0.988200
R7805 n1_M2_5460_70260 n1_M2_6540_70260 0.988200
R7806 n1_M2_6540_70260 n1_M2_7620_70260 0.988200
R7807 n1_M2_7620_70260 n1_M2_8700_70260 0.988200
R7808 n1_M2_8700_70260 n1_M2_9780_70260 0.988200
R7809 n1_M2_9780_70260 n1_M2_10860_70260 0.988200
R7810 n1_M2_10860_70260 n1_M2_11940_70260 0.988200
R7811 n1_M2_11940_70260 n1_M2_13020_70260 0.988200
R7812 n1_M2_13020_70260 n1_M2_14100_70260 0.988200
R7813 n1_M2_14100_70260 n1_M2_15180_70260 0.988200
R7814 n1_M2_15180_70260 n1_M2_16260_70260 0.988200
R7815 n1_M2_16260_70260 n1_M2_17340_70260 0.988200
R7816 n1_M2_17340_70260 n1_M2_18420_70260 0.988200
R7817 n1_M2_18420_70260 n1_M2_19500_70260 0.988200
R7818 n1_M2_19500_70260 n1_M2_20580_70260 0.988200
R7819 n1_M2_20580_70260 n1_M2_21660_70260 0.988200
R7820 n1_M2_21660_70260 n1_M2_22740_70260 0.988200
R7821 n1_M2_22740_70260 n1_M2_23820_70260 0.988200
R7822 n1_M2_23820_70260 n1_M2_24900_70260 0.988200
R7823 n1_M2_24900_70260 n1_M2_25980_70260 0.988200
R7824 n1_M2_25980_70260 n1_M2_27060_70260 0.988200
R7825 n1_M2_27060_70260 n1_M2_28140_70260 0.988200
R7826 n1_M2_28140_70260 n1_M2_29220_70260 0.988200
R7827 n1_M2_29220_70260 n1_M2_30300_70260 0.988200
R7828 n1_M2_30300_70260 n1_M2_31380_70260 0.988200
R7829 n1_M2_31380_70260 n1_M2_32460_70260 0.988200
R7830 n1_M2_32460_70260 n1_M2_33540_70260 0.988200
R7831 n1_M2_33540_70260 n1_M2_34620_70260 0.988200
R7832 n1_M2_34620_70260 n1_M2_35700_70260 0.988200
R7833 n1_M2_35700_70260 n1_M2_36780_70260 0.988200
R7834 n1_M2_36780_70260 n1_M2_37860_70260 0.988200
R7835 n1_M2_37860_70260 n1_M2_38940_70260 0.988200
R7836 n1_M2_38940_70260 n1_M2_40020_70260 0.988200
R7837 n1_M2_40020_70260 n1_M2_41100_70260 0.988200
R7838 n1_M2_41100_70260 n1_M2_42180_70260 0.988200
R7839 n1_M2_42180_70260 n1_M2_43260_70260 0.988200
R7840 n1_M2_43260_70260 n1_M2_44340_70260 0.988200
R7841 n1_M2_44340_70260 n1_M2_45420_70260 0.988200
R7842 n1_M2_45420_70260 n1_M2_46500_70260 0.988200
R7843 n1_M2_46500_70260 n1_M2_47580_70260 0.988200
R7844 n1_M2_47580_70260 n1_M2_48660_70260 0.988200
R7845 n1_M2_48660_70260 n1_M2_49740_70260 0.988200
R7846 n1_M2_49740_70260 n1_M2_50820_70260 0.988200
R7847 n1_M2_50820_70260 n1_M2_51900_70260 0.988200
R7848 n1_M2_51900_70260 n1_M2_52980_70260 0.988200
R7849 n1_M2_52980_70260 n1_M2_54060_70260 0.988200
R7850 n1_M2_54060_70260 n1_M2_55140_70260 0.988200
R7851 n1_M2_55140_70260 n1_M2_56220_70260 0.988200
R7852 n1_M2_56220_70260 n1_M2_57300_70260 0.988200
R7853 n1_M2_57300_70260 n1_M2_58380_70260 0.988200
R7854 n1_M2_58380_70260 n1_M2_59460_70260 0.988200
R7855 n1_M2_59460_70260 n1_M2_60540_70260 0.988200
R7856 n1_M2_60540_70260 n1_M2_61620_70260 0.988200
R7857 n1_M2_61620_70260 n1_M2_62700_70260 0.988200
R7858 n1_M2_62700_70260 n1_M2_63780_70260 0.988200
R7859 n1_M2_63780_70260 n1_M2_64860_70260 0.988200
R7860 n1_M2_64860_70260 n1_M2_65940_70260 0.988200
R7861 n1_M2_65940_70260 n1_M2_67020_70260 0.988200
R7862 n1_M2_67020_70260 n1_M2_68100_70260 0.988200
R7863 n1_M2_68100_70260 n1_M2_69180_70260 0.988200
R7864 n1_M2_69180_70260 n1_M2_70260_70260 0.988200
R7865 n1_M2_70260_70260 n1_M2_71340_70260 0.988200
R7866 n1_M2_71340_70260 n1_M2_72420_70260 0.988200
R7867 n1_M2_72420_70260 n1_M2_73500_70260 0.988200
R7868 n1_M2_73500_70260 n1_M2_74580_70260 0.988200
R7869 n1_M2_74580_70260 n1_M2_75660_70260 0.988200
R7870 n1_M2_75660_70260 n1_M2_76740_70260 0.988200
R7871 n1_M2_76740_70260 n1_M2_77820_70260 0.988200
R7872 n1_M2_77820_70260 n1_M2_78900_70260 0.988200
R7873 n1_M2_78900_70260 n1_M2_79980_70260 0.988200
R7874 n1_M2_79980_70260 n1_M2_81060_70260 0.988200
R7875 n1_M2_81060_70260 n1_M2_82140_70260 0.988200
R7876 n1_M2_82140_70260 n1_M2_83220_70260 0.988200
R7877 n1_M2_83220_70260 n1_M2_84300_70260 0.988200
R7878 n1_M2_84300_70260 n1_M2_85380_70260 0.988200
R7879 n1_M2_85380_70260 n1_M2_86460_70260 0.988200
R7880 n1_M2_86460_70260 n1_M2_87540_70260 0.988200
R7881 n1_M2_87540_70260 n1_M2_88620_70260 0.988200
R7882 n1_M2_88620_70260 n1_M2_89700_70260 0.988200
R7883 n1_M2_89700_70260 n1_M2_90780_70260 0.988200
R7884 n1_M2_90780_70260 n1_M2_91860_70260 0.988200
R7885 n1_M2_91860_70260 n1_M2_92940_70260 0.988200
R7886 n1_M2_92940_70260 n1_M2_94020_70260 0.988200
R7887 n1_M2_94020_70260 n1_M2_95100_70260 0.988200
R7888 n1_M2_95100_70260 n1_M2_96180_70260 0.988200
R7889 n1_M2_96180_70260 n1_M2_97260_70260 0.988200
R7890 n1_M2_97260_70260 n1_M2_98340_70260 0.988200
R7891 n1_M2_98340_70260 n1_M2_99420_70260 0.988200
R7892 n1_M2_99420_70260 n1_M2_100500_70260 0.988200
R7893 n1_M2_100500_70260 n1_M2_101580_70260 0.988200
R7894 n1_M2_101580_70260 n1_M2_102660_70260 0.988200
R7895 n1_M2_102660_70260 n1_M2_103740_70260 0.988200
R7896 n1_M2_103740_70260 n1_M2_104820_70260 0.988200
R7897 n1_M2_104820_70260 n1_M2_105900_70260 0.988200
R7898 n1_M2_105900_70260 n1_M2_106980_70260 0.988200
R7899 n1_M2_106980_70260 n1_M2_108060_70260 0.988200
R7900 n1_M2_108060_70260 n1_M2_109140_70260 0.988200
R7901 n1_M2_109140_70260 n1_M2_110220_70260 0.988200
R7902 n1_M2_110220_70260 n1_M2_111300_70260 0.988200
R7903 n1_M2_111300_70260 n1_M2_112380_70260 0.988200
R7904 n1_M2_112380_70260 n1_M2_113460_70260 0.988200
R7905 n1_M2_113460_70260 n1_M2_114540_70260 0.988200
R7906 n1_M2_114540_70260 n1_M2_115620_70260 0.988200
R7907 n1_M2_115620_70260 n1_M2_116700_70260 0.988200
R7908 n1_M2_116700_70260 n1_M2_117780_70260 0.988200
R7909 n1_M2_117780_70260 n1_M2_118860_70260 0.988200
R7910 n1_M2_118860_70260 n1_M2_119940_70260 0.988200
R7911 n1_M2_119940_70260 n1_M2_121020_70260 0.988200
R7912 n1_M2_121020_70260 n1_M2_122100_70260 0.988200
R7913 n1_M2_122100_70260 n1_M2_123180_70260 0.988200
R7914 n1_M2_123180_70260 n1_M2_124260_70260 0.988200
R7915 n1_M2_124260_70260 n1_M2_125340_70260 0.988200
R7916 n1_M2_125340_70260 n1_M2_126420_70260 0.988200
R7917 n1_M2_126420_70260 n1_M2_127500_70260 0.988200
R7918 n1_M2_127500_70260 n1_M2_128580_70260 0.988200
R7919 n1_M2_128580_70260 n1_M2_129660_70260 0.988200
R7920 n1_M2_60_71340 n1_M2_1140_71340 0.988200
R7921 n1_M2_1140_71340 n1_M2_2220_71340 0.988200
R7922 n1_M2_2220_71340 n1_M2_3300_71340 0.988200
R7923 n1_M2_3300_71340 n1_M2_4380_71340 0.988200
R7924 n1_M2_4380_71340 n1_M2_5460_71340 0.988200
R7925 n1_M2_5460_71340 n1_M2_6540_71340 0.988200
R7926 n1_M2_6540_71340 n1_M2_7620_71340 0.988200
R7927 n1_M2_7620_71340 n1_M2_8700_71340 0.988200
R7928 n1_M2_8700_71340 n1_M2_9780_71340 0.988200
R7929 n1_M2_9780_71340 n1_M2_10860_71340 0.988200
R7930 n1_M2_10860_71340 n1_M2_11940_71340 0.988200
R7931 n1_M2_11940_71340 n1_M2_13020_71340 0.988200
R7932 n1_M2_13020_71340 n1_M2_14100_71340 0.988200
R7933 n1_M2_14100_71340 n1_M2_15180_71340 0.988200
R7934 n1_M2_15180_71340 n1_M2_16260_71340 0.988200
R7935 n1_M2_16260_71340 n1_M2_17340_71340 0.988200
R7936 n1_M2_17340_71340 n1_M2_18420_71340 0.988200
R7937 n1_M2_18420_71340 n1_M2_19500_71340 0.988200
R7938 n1_M2_19500_71340 n1_M2_20580_71340 0.988200
R7939 n1_M2_20580_71340 n1_M2_21660_71340 0.988200
R7940 n1_M2_21660_71340 n1_M2_22740_71340 0.988200
R7941 n1_M2_22740_71340 n1_M2_23820_71340 0.988200
R7942 n1_M2_23820_71340 n1_M2_24900_71340 0.988200
R7943 n1_M2_24900_71340 n1_M2_25980_71340 0.988200
R7944 n1_M2_25980_71340 n1_M2_27060_71340 0.988200
R7945 n1_M2_27060_71340 n1_M2_28140_71340 0.988200
R7946 n1_M2_28140_71340 n1_M2_29220_71340 0.988200
R7947 n1_M2_29220_71340 n1_M2_30300_71340 0.988200
R7948 n1_M2_30300_71340 n1_M2_31380_71340 0.988200
R7949 n1_M2_31380_71340 n1_M2_32460_71340 0.988200
R7950 n1_M2_32460_71340 n1_M2_33540_71340 0.988200
R7951 n1_M2_33540_71340 n1_M2_34620_71340 0.988200
R7952 n1_M2_34620_71340 n1_M2_35700_71340 0.988200
R7953 n1_M2_35700_71340 n1_M2_36780_71340 0.988200
R7954 n1_M2_36780_71340 n1_M2_37860_71340 0.988200
R7955 n1_M2_37860_71340 n1_M2_38940_71340 0.988200
R7956 n1_M2_38940_71340 n1_M2_40020_71340 0.988200
R7957 n1_M2_40020_71340 n1_M2_41100_71340 0.988200
R7958 n1_M2_41100_71340 n1_M2_42180_71340 0.988200
R7959 n1_M2_42180_71340 n1_M2_43260_71340 0.988200
R7960 n1_M2_43260_71340 n1_M2_44340_71340 0.988200
R7961 n1_M2_44340_71340 n1_M2_45420_71340 0.988200
R7962 n1_M2_45420_71340 n1_M2_46500_71340 0.988200
R7963 n1_M2_46500_71340 n1_M2_47580_71340 0.988200
R7964 n1_M2_47580_71340 n1_M2_48660_71340 0.988200
R7965 n1_M2_48660_71340 n1_M2_49740_71340 0.988200
R7966 n1_M2_49740_71340 n1_M2_50820_71340 0.988200
R7967 n1_M2_50820_71340 n1_M2_51900_71340 0.988200
R7968 n1_M2_51900_71340 n1_M2_52980_71340 0.988200
R7969 n1_M2_52980_71340 n1_M2_54060_71340 0.988200
R7970 n1_M2_54060_71340 n1_M2_55140_71340 0.988200
R7971 n1_M2_55140_71340 n1_M2_56220_71340 0.988200
R7972 n1_M2_56220_71340 n1_M2_57300_71340 0.988200
R7973 n1_M2_57300_71340 n1_M2_58380_71340 0.988200
R7974 n1_M2_58380_71340 n1_M2_59460_71340 0.988200
R7975 n1_M2_59460_71340 n1_M2_60540_71340 0.988200
R7976 n1_M2_60540_71340 n1_M2_61620_71340 0.988200
R7977 n1_M2_61620_71340 n1_M2_62700_71340 0.988200
R7978 n1_M2_62700_71340 n1_M2_63780_71340 0.988200
R7979 n1_M2_63780_71340 n1_M2_64860_71340 0.988200
R7980 n1_M2_64860_71340 n1_M2_65940_71340 0.988200
R7981 n1_M2_65940_71340 n1_M2_67020_71340 0.988200
R7982 n1_M2_67020_71340 n1_M2_68100_71340 0.988200
R7983 n1_M2_68100_71340 n1_M2_69180_71340 0.988200
R7984 n1_M2_69180_71340 n1_M2_70260_71340 0.988200
R7985 n1_M2_70260_71340 n1_M2_71340_71340 0.988200
R7986 n1_M2_71340_71340 n1_M2_72420_71340 0.988200
R7987 n1_M2_72420_71340 n1_M2_73500_71340 0.988200
R7988 n1_M2_73500_71340 n1_M2_74580_71340 0.988200
R7989 n1_M2_74580_71340 n1_M2_75660_71340 0.988200
R7990 n1_M2_75660_71340 n1_M2_76740_71340 0.988200
R7991 n1_M2_76740_71340 n1_M2_77820_71340 0.988200
R7992 n1_M2_77820_71340 n1_M2_78900_71340 0.988200
R7993 n1_M2_78900_71340 n1_M2_79980_71340 0.988200
R7994 n1_M2_79980_71340 n1_M2_81060_71340 0.988200
R7995 n1_M2_81060_71340 n1_M2_82140_71340 0.988200
R7996 n1_M2_82140_71340 n1_M2_83220_71340 0.988200
R7997 n1_M2_83220_71340 n1_M2_84300_71340 0.988200
R7998 n1_M2_84300_71340 n1_M2_85380_71340 0.988200
R7999 n1_M2_85380_71340 n1_M2_86460_71340 0.988200
R8000 n1_M2_86460_71340 n1_M2_87540_71340 0.988200
R8001 n1_M2_87540_71340 n1_M2_88620_71340 0.988200
R8002 n1_M2_88620_71340 n1_M2_89700_71340 0.988200
R8003 n1_M2_89700_71340 n1_M2_90780_71340 0.988200
R8004 n1_M2_90780_71340 n1_M2_91860_71340 0.988200
R8005 n1_M2_91860_71340 n1_M2_92940_71340 0.988200
R8006 n1_M2_92940_71340 n1_M2_94020_71340 0.988200
R8007 n1_M2_94020_71340 n1_M2_95100_71340 0.988200
R8008 n1_M2_95100_71340 n1_M2_96180_71340 0.988200
R8009 n1_M2_96180_71340 n1_M2_97260_71340 0.988200
R8010 n1_M2_97260_71340 n1_M2_98340_71340 0.988200
R8011 n1_M2_98340_71340 n1_M2_99420_71340 0.988200
R8012 n1_M2_99420_71340 n1_M2_100500_71340 0.988200
R8013 n1_M2_100500_71340 n1_M2_101580_71340 0.988200
R8014 n1_M2_101580_71340 n1_M2_102660_71340 0.988200
R8015 n1_M2_102660_71340 n1_M2_103740_71340 0.988200
R8016 n1_M2_103740_71340 n1_M2_104820_71340 0.988200
R8017 n1_M2_104820_71340 n1_M2_105900_71340 0.988200
R8018 n1_M2_105900_71340 n1_M2_106980_71340 0.988200
R8019 n1_M2_106980_71340 n1_M2_108060_71340 0.988200
R8020 n1_M2_108060_71340 n1_M2_109140_71340 0.988200
R8021 n1_M2_109140_71340 n1_M2_110220_71340 0.988200
R8022 n1_M2_110220_71340 n1_M2_111300_71340 0.988200
R8023 n1_M2_111300_71340 n1_M2_112380_71340 0.988200
R8024 n1_M2_112380_71340 n1_M2_113460_71340 0.988200
R8025 n1_M2_113460_71340 n1_M2_114540_71340 0.988200
R8026 n1_M2_114540_71340 n1_M2_115620_71340 0.988200
R8027 n1_M2_115620_71340 n1_M2_116700_71340 0.988200
R8028 n1_M2_116700_71340 n1_M2_117780_71340 0.988200
R8029 n1_M2_117780_71340 n1_M2_118860_71340 0.988200
R8030 n1_M2_118860_71340 n1_M2_119940_71340 0.988200
R8031 n1_M2_119940_71340 n1_M2_121020_71340 0.988200
R8032 n1_M2_121020_71340 n1_M2_122100_71340 0.988200
R8033 n1_M2_122100_71340 n1_M2_123180_71340 0.988200
R8034 n1_M2_123180_71340 n1_M2_124260_71340 0.988200
R8035 n1_M2_124260_71340 n1_M2_125340_71340 0.988200
R8036 n1_M2_125340_71340 n1_M2_126420_71340 0.988200
R8037 n1_M2_126420_71340 n1_M2_127500_71340 0.988200
R8038 n1_M2_127500_71340 n1_M2_128580_71340 0.988200
R8039 n1_M2_128580_71340 n1_M2_129660_71340 0.988200
R8040 n1_M2_60_72420 n1_M2_1140_72420 0.988200
R8041 n1_M2_1140_72420 n1_M2_2220_72420 0.988200
R8042 n1_M2_2220_72420 n1_M2_3300_72420 0.988200
R8043 n1_M2_3300_72420 n1_M2_4380_72420 0.988200
R8044 n1_M2_4380_72420 n1_M2_5460_72420 0.988200
R8045 n1_M2_5460_72420 n1_M2_6540_72420 0.988200
R8046 n1_M2_6540_72420 n1_M2_7620_72420 0.988200
R8047 n1_M2_7620_72420 n1_M2_8700_72420 0.988200
R8048 n1_M2_8700_72420 n1_M2_9780_72420 0.988200
R8049 n1_M2_9780_72420 n1_M2_10860_72420 0.988200
R8050 n1_M2_10860_72420 n1_M2_11940_72420 0.988200
R8051 n1_M2_11940_72420 n1_M2_13020_72420 0.988200
R8052 n1_M2_13020_72420 n1_M2_14100_72420 0.988200
R8053 n1_M2_14100_72420 n1_M2_15180_72420 0.988200
R8054 n1_M2_15180_72420 n1_M2_16260_72420 0.988200
R8055 n1_M2_16260_72420 n1_M2_17340_72420 0.988200
R8056 n1_M2_17340_72420 n1_M2_18420_72420 0.988200
R8057 n1_M2_18420_72420 n1_M2_19500_72420 0.988200
R8058 n1_M2_19500_72420 n1_M2_20580_72420 0.988200
R8059 n1_M2_20580_72420 n1_M2_21660_72420 0.988200
R8060 n1_M2_21660_72420 n1_M2_22740_72420 0.988200
R8061 n1_M2_22740_72420 n1_M2_23820_72420 0.988200
R8062 n1_M2_23820_72420 n1_M2_24900_72420 0.988200
R8063 n1_M2_24900_72420 n1_M2_25980_72420 0.988200
R8064 n1_M2_25980_72420 n1_M2_27060_72420 0.988200
R8065 n1_M2_27060_72420 n1_M2_28140_72420 0.988200
R8066 n1_M2_28140_72420 n1_M2_29220_72420 0.988200
R8067 n1_M2_29220_72420 n1_M2_30300_72420 0.988200
R8068 n1_M2_30300_72420 n1_M2_31380_72420 0.988200
R8069 n1_M2_31380_72420 n1_M2_32460_72420 0.988200
R8070 n1_M2_32460_72420 n1_M2_33540_72420 0.988200
R8071 n1_M2_33540_72420 n1_M2_34620_72420 0.988200
R8072 n1_M2_34620_72420 n1_M2_35700_72420 0.988200
R8073 n1_M2_35700_72420 n1_M2_36780_72420 0.988200
R8074 n1_M2_36780_72420 n1_M2_37860_72420 0.988200
R8075 n1_M2_37860_72420 n1_M2_38940_72420 0.988200
R8076 n1_M2_38940_72420 n1_M2_40020_72420 0.988200
R8077 n1_M2_40020_72420 n1_M2_41100_72420 0.988200
R8078 n1_M2_41100_72420 n1_M2_42180_72420 0.988200
R8079 n1_M2_42180_72420 n1_M2_43260_72420 0.988200
R8080 n1_M2_43260_72420 n1_M2_44340_72420 0.988200
R8081 n1_M2_44340_72420 n1_M2_45420_72420 0.988200
R8082 n1_M2_45420_72420 n1_M2_46500_72420 0.988200
R8083 n1_M2_46500_72420 n1_M2_47580_72420 0.988200
R8084 n1_M2_47580_72420 n1_M2_48660_72420 0.988200
R8085 n1_M2_48660_72420 n1_M2_49740_72420 0.988200
R8086 n1_M2_49740_72420 n1_M2_50820_72420 0.988200
R8087 n1_M2_50820_72420 n1_M2_51900_72420 0.988200
R8088 n1_M2_51900_72420 n1_M2_52980_72420 0.988200
R8089 n1_M2_52980_72420 n1_M2_54060_72420 0.988200
R8090 n1_M2_54060_72420 n1_M2_55140_72420 0.988200
R8091 n1_M2_55140_72420 n1_M2_56220_72420 0.988200
R8092 n1_M2_56220_72420 n1_M2_57300_72420 0.988200
R8093 n1_M2_57300_72420 n1_M2_58380_72420 0.988200
R8094 n1_M2_58380_72420 n1_M2_59460_72420 0.988200
R8095 n1_M2_59460_72420 n1_M2_60540_72420 0.988200
R8096 n1_M2_60540_72420 n1_M2_61620_72420 0.988200
R8097 n1_M2_61620_72420 n1_M2_62700_72420 0.988200
R8098 n1_M2_62700_72420 n1_M2_63780_72420 0.988200
R8099 n1_M2_63780_72420 n1_M2_64860_72420 0.988200
R8100 n1_M2_64860_72420 n1_M2_65940_72420 0.988200
R8101 n1_M2_65940_72420 n1_M2_67020_72420 0.988200
R8102 n1_M2_67020_72420 n1_M2_68100_72420 0.988200
R8103 n1_M2_68100_72420 n1_M2_69180_72420 0.988200
R8104 n1_M2_69180_72420 n1_M2_70260_72420 0.988200
R8105 n1_M2_70260_72420 n1_M2_71340_72420 0.988200
R8106 n1_M2_71340_72420 n1_M2_72420_72420 0.988200
R8107 n1_M2_72420_72420 n1_M2_73500_72420 0.988200
R8108 n1_M2_73500_72420 n1_M2_74580_72420 0.988200
R8109 n1_M2_74580_72420 n1_M2_75660_72420 0.988200
R8110 n1_M2_75660_72420 n1_M2_76740_72420 0.988200
R8111 n1_M2_76740_72420 n1_M2_77820_72420 0.988200
R8112 n1_M2_77820_72420 n1_M2_78900_72420 0.988200
R8113 n1_M2_78900_72420 n1_M2_79980_72420 0.988200
R8114 n1_M2_79980_72420 n1_M2_81060_72420 0.988200
R8115 n1_M2_81060_72420 n1_M2_82140_72420 0.988200
R8116 n1_M2_82140_72420 n1_M2_83220_72420 0.988200
R8117 n1_M2_83220_72420 n1_M2_84300_72420 0.988200
R8118 n1_M2_84300_72420 n1_M2_85380_72420 0.988200
R8119 n1_M2_85380_72420 n1_M2_86460_72420 0.988200
R8120 n1_M2_86460_72420 n1_M2_87540_72420 0.988200
R8121 n1_M2_87540_72420 n1_M2_88620_72420 0.988200
R8122 n1_M2_88620_72420 n1_M2_89700_72420 0.988200
R8123 n1_M2_89700_72420 n1_M2_90780_72420 0.988200
R8124 n1_M2_90780_72420 n1_M2_91860_72420 0.988200
R8125 n1_M2_91860_72420 n1_M2_92940_72420 0.988200
R8126 n1_M2_92940_72420 n1_M2_94020_72420 0.988200
R8127 n1_M2_94020_72420 n1_M2_95100_72420 0.988200
R8128 n1_M2_95100_72420 n1_M2_96180_72420 0.988200
R8129 n1_M2_96180_72420 n1_M2_97260_72420 0.988200
R8130 n1_M2_97260_72420 n1_M2_98340_72420 0.988200
R8131 n1_M2_98340_72420 n1_M2_99420_72420 0.988200
R8132 n1_M2_99420_72420 n1_M2_100500_72420 0.988200
R8133 n1_M2_100500_72420 n1_M2_101580_72420 0.988200
R8134 n1_M2_101580_72420 n1_M2_102660_72420 0.988200
R8135 n1_M2_102660_72420 n1_M2_103740_72420 0.988200
R8136 n1_M2_103740_72420 n1_M2_104820_72420 0.988200
R8137 n1_M2_104820_72420 n1_M2_105900_72420 0.988200
R8138 n1_M2_105900_72420 n1_M2_106980_72420 0.988200
R8139 n1_M2_106980_72420 n1_M2_108060_72420 0.988200
R8140 n1_M2_108060_72420 n1_M2_109140_72420 0.988200
R8141 n1_M2_109140_72420 n1_M2_110220_72420 0.988200
R8142 n1_M2_110220_72420 n1_M2_111300_72420 0.988200
R8143 n1_M2_111300_72420 n1_M2_112380_72420 0.988200
R8144 n1_M2_112380_72420 n1_M2_113460_72420 0.988200
R8145 n1_M2_113460_72420 n1_M2_114540_72420 0.988200
R8146 n1_M2_114540_72420 n1_M2_115620_72420 0.988200
R8147 n1_M2_115620_72420 n1_M2_116700_72420 0.988200
R8148 n1_M2_116700_72420 n1_M2_117780_72420 0.988200
R8149 n1_M2_117780_72420 n1_M2_118860_72420 0.988200
R8150 n1_M2_118860_72420 n1_M2_119940_72420 0.988200
R8151 n1_M2_119940_72420 n1_M2_121020_72420 0.988200
R8152 n1_M2_121020_72420 n1_M2_122100_72420 0.988200
R8153 n1_M2_122100_72420 n1_M2_123180_72420 0.988200
R8154 n1_M2_123180_72420 n1_M2_124260_72420 0.988200
R8155 n1_M2_124260_72420 n1_M2_125340_72420 0.988200
R8156 n1_M2_125340_72420 n1_M2_126420_72420 0.988200
R8157 n1_M2_126420_72420 n1_M2_127500_72420 0.988200
R8158 n1_M2_127500_72420 n1_M2_128580_72420 0.988200
R8159 n1_M2_128580_72420 n1_M2_129660_72420 0.988200
R8160 n1_M2_60_73500 n1_M2_1140_73500 0.988200
R8161 n1_M2_1140_73500 n1_M2_2220_73500 0.988200
R8162 n1_M2_2220_73500 n1_M2_3300_73500 0.988200
R8163 n1_M2_3300_73500 n1_M2_4380_73500 0.988200
R8164 n1_M2_4380_73500 n1_M2_5460_73500 0.988200
R8165 n1_M2_5460_73500 n1_M2_6540_73500 0.988200
R8166 n1_M2_6540_73500 n1_M2_7620_73500 0.988200
R8167 n1_M2_7620_73500 n1_M2_8700_73500 0.988200
R8168 n1_M2_8700_73500 n1_M2_9780_73500 0.988200
R8169 n1_M2_9780_73500 n1_M2_10860_73500 0.988200
R8170 n1_M2_10860_73500 n1_M2_11940_73500 0.988200
R8171 n1_M2_11940_73500 n1_M2_13020_73500 0.988200
R8172 n1_M2_13020_73500 n1_M2_14100_73500 0.988200
R8173 n1_M2_14100_73500 n1_M2_15180_73500 0.988200
R8174 n1_M2_15180_73500 n1_M2_16260_73500 0.988200
R8175 n1_M2_16260_73500 n1_M2_17340_73500 0.988200
R8176 n1_M2_17340_73500 n1_M2_18420_73500 0.988200
R8177 n1_M2_18420_73500 n1_M2_19500_73500 0.988200
R8178 n1_M2_19500_73500 n1_M2_20580_73500 0.988200
R8179 n1_M2_20580_73500 n1_M2_21660_73500 0.988200
R8180 n1_M2_21660_73500 n1_M2_22740_73500 0.988200
R8181 n1_M2_22740_73500 n1_M2_23820_73500 0.988200
R8182 n1_M2_23820_73500 n1_M2_24900_73500 0.988200
R8183 n1_M2_24900_73500 n1_M2_25980_73500 0.988200
R8184 n1_M2_25980_73500 n1_M2_27060_73500 0.988200
R8185 n1_M2_27060_73500 n1_M2_28140_73500 0.988200
R8186 n1_M2_28140_73500 n1_M2_29220_73500 0.988200
R8187 n1_M2_29220_73500 n1_M2_30300_73500 0.988200
R8188 n1_M2_30300_73500 n1_M2_31380_73500 0.988200
R8189 n1_M2_31380_73500 n1_M2_32460_73500 0.988200
R8190 n1_M2_32460_73500 n1_M2_33540_73500 0.988200
R8191 n1_M2_33540_73500 n1_M2_34620_73500 0.988200
R8192 n1_M2_34620_73500 n1_M2_35700_73500 0.988200
R8193 n1_M2_35700_73500 n1_M2_36780_73500 0.988200
R8194 n1_M2_36780_73500 n1_M2_37860_73500 0.988200
R8195 n1_M2_37860_73500 n1_M2_38940_73500 0.988200
R8196 n1_M2_38940_73500 n1_M2_40020_73500 0.988200
R8197 n1_M2_40020_73500 n1_M2_41100_73500 0.988200
R8198 n1_M2_41100_73500 n1_M2_42180_73500 0.988200
R8199 n1_M2_42180_73500 n1_M2_43260_73500 0.988200
R8200 n1_M2_43260_73500 n1_M2_44340_73500 0.988200
R8201 n1_M2_44340_73500 n1_M2_45420_73500 0.988200
R8202 n1_M2_45420_73500 n1_M2_46500_73500 0.988200
R8203 n1_M2_46500_73500 n1_M2_47580_73500 0.988200
R8204 n1_M2_47580_73500 n1_M2_48660_73500 0.988200
R8205 n1_M2_48660_73500 n1_M2_49740_73500 0.988200
R8206 n1_M2_49740_73500 n1_M2_50820_73500 0.988200
R8207 n1_M2_50820_73500 n1_M2_51900_73500 0.988200
R8208 n1_M2_51900_73500 n1_M2_52980_73500 0.988200
R8209 n1_M2_52980_73500 n1_M2_54060_73500 0.988200
R8210 n1_M2_54060_73500 n1_M2_55140_73500 0.988200
R8211 n1_M2_55140_73500 n1_M2_56220_73500 0.988200
R8212 n1_M2_56220_73500 n1_M2_57300_73500 0.988200
R8213 n1_M2_57300_73500 n1_M2_58380_73500 0.988200
R8214 n1_M2_58380_73500 n1_M2_59460_73500 0.988200
R8215 n1_M2_59460_73500 n1_M2_60540_73500 0.988200
R8216 n1_M2_60540_73500 n1_M2_61620_73500 0.988200
R8217 n1_M2_61620_73500 n1_M2_62700_73500 0.988200
R8218 n1_M2_62700_73500 n1_M2_63780_73500 0.988200
R8219 n1_M2_63780_73500 n1_M2_64860_73500 0.988200
R8220 n1_M2_64860_73500 n1_M2_65940_73500 0.988200
R8221 n1_M2_65940_73500 n1_M2_67020_73500 0.988200
R8222 n1_M2_67020_73500 n1_M2_68100_73500 0.988200
R8223 n1_M2_68100_73500 n1_M2_69180_73500 0.988200
R8224 n1_M2_69180_73500 n1_M2_70260_73500 0.988200
R8225 n1_M2_70260_73500 n1_M2_71340_73500 0.988200
R8226 n1_M2_71340_73500 n1_M2_72420_73500 0.988200
R8227 n1_M2_72420_73500 n1_M2_73500_73500 0.988200
R8228 n1_M2_73500_73500 n1_M2_74580_73500 0.988200
R8229 n1_M2_74580_73500 n1_M2_75660_73500 0.988200
R8230 n1_M2_75660_73500 n1_M2_76740_73500 0.988200
R8231 n1_M2_76740_73500 n1_M2_77820_73500 0.988200
R8232 n1_M2_77820_73500 n1_M2_78900_73500 0.988200
R8233 n1_M2_78900_73500 n1_M2_79980_73500 0.988200
R8234 n1_M2_79980_73500 n1_M2_81060_73500 0.988200
R8235 n1_M2_81060_73500 n1_M2_82140_73500 0.988200
R8236 n1_M2_82140_73500 n1_M2_83220_73500 0.988200
R8237 n1_M2_83220_73500 n1_M2_84300_73500 0.988200
R8238 n1_M2_84300_73500 n1_M2_85380_73500 0.988200
R8239 n1_M2_85380_73500 n1_M2_86460_73500 0.988200
R8240 n1_M2_86460_73500 n1_M2_87540_73500 0.988200
R8241 n1_M2_87540_73500 n1_M2_88620_73500 0.988200
R8242 n1_M2_88620_73500 n1_M2_89700_73500 0.988200
R8243 n1_M2_89700_73500 n1_M2_90780_73500 0.988200
R8244 n1_M2_90780_73500 n1_M2_91860_73500 0.988200
R8245 n1_M2_91860_73500 n1_M2_92940_73500 0.988200
R8246 n1_M2_92940_73500 n1_M2_94020_73500 0.988200
R8247 n1_M2_94020_73500 n1_M2_95100_73500 0.988200
R8248 n1_M2_95100_73500 n1_M2_96180_73500 0.988200
R8249 n1_M2_96180_73500 n1_M2_97260_73500 0.988200
R8250 n1_M2_97260_73500 n1_M2_98340_73500 0.988200
R8251 n1_M2_98340_73500 n1_M2_99420_73500 0.988200
R8252 n1_M2_99420_73500 n1_M2_100500_73500 0.988200
R8253 n1_M2_100500_73500 n1_M2_101580_73500 0.988200
R8254 n1_M2_101580_73500 n1_M2_102660_73500 0.988200
R8255 n1_M2_102660_73500 n1_M2_103740_73500 0.988200
R8256 n1_M2_103740_73500 n1_M2_104820_73500 0.988200
R8257 n1_M2_104820_73500 n1_M2_105900_73500 0.988200
R8258 n1_M2_105900_73500 n1_M2_106980_73500 0.988200
R8259 n1_M2_106980_73500 n1_M2_108060_73500 0.988200
R8260 n1_M2_108060_73500 n1_M2_109140_73500 0.988200
R8261 n1_M2_109140_73500 n1_M2_110220_73500 0.988200
R8262 n1_M2_110220_73500 n1_M2_111300_73500 0.988200
R8263 n1_M2_111300_73500 n1_M2_112380_73500 0.988200
R8264 n1_M2_112380_73500 n1_M2_113460_73500 0.988200
R8265 n1_M2_113460_73500 n1_M2_114540_73500 0.988200
R8266 n1_M2_114540_73500 n1_M2_115620_73500 0.988200
R8267 n1_M2_115620_73500 n1_M2_116700_73500 0.988200
R8268 n1_M2_116700_73500 n1_M2_117780_73500 0.988200
R8269 n1_M2_117780_73500 n1_M2_118860_73500 0.988200
R8270 n1_M2_118860_73500 n1_M2_119940_73500 0.988200
R8271 n1_M2_119940_73500 n1_M2_121020_73500 0.988200
R8272 n1_M2_121020_73500 n1_M2_122100_73500 0.988200
R8273 n1_M2_122100_73500 n1_M2_123180_73500 0.988200
R8274 n1_M2_123180_73500 n1_M2_124260_73500 0.988200
R8275 n1_M2_124260_73500 n1_M2_125340_73500 0.988200
R8276 n1_M2_125340_73500 n1_M2_126420_73500 0.988200
R8277 n1_M2_126420_73500 n1_M2_127500_73500 0.988200
R8278 n1_M2_127500_73500 n1_M2_128580_73500 0.988200
R8279 n1_M2_128580_73500 n1_M2_129660_73500 0.988200
R8280 n1_M2_60_74580 n1_M2_1140_74580 0.988200
R8281 n1_M2_1140_74580 n1_M2_2220_74580 0.988200
R8282 n1_M2_2220_74580 n1_M2_3300_74580 0.988200
R8283 n1_M2_3300_74580 n1_M2_4380_74580 0.988200
R8284 n1_M2_4380_74580 n1_M2_5460_74580 0.988200
R8285 n1_M2_5460_74580 n1_M2_6540_74580 0.988200
R8286 n1_M2_6540_74580 n1_M2_7620_74580 0.988200
R8287 n1_M2_7620_74580 n1_M2_8700_74580 0.988200
R8288 n1_M2_8700_74580 n1_M2_9780_74580 0.988200
R8289 n1_M2_9780_74580 n1_M2_10860_74580 0.988200
R8290 n1_M2_10860_74580 n1_M2_11940_74580 0.988200
R8291 n1_M2_11940_74580 n1_M2_13020_74580 0.988200
R8292 n1_M2_13020_74580 n1_M2_14100_74580 0.988200
R8293 n1_M2_14100_74580 n1_M2_15180_74580 0.988200
R8294 n1_M2_15180_74580 n1_M2_16260_74580 0.988200
R8295 n1_M2_16260_74580 n1_M2_17340_74580 0.988200
R8296 n1_M2_17340_74580 n1_M2_18420_74580 0.988200
R8297 n1_M2_18420_74580 n1_M2_19500_74580 0.988200
R8298 n1_M2_19500_74580 n1_M2_20580_74580 0.988200
R8299 n1_M2_20580_74580 n1_M2_21660_74580 0.988200
R8300 n1_M2_21660_74580 n1_M2_22740_74580 0.988200
R8301 n1_M2_22740_74580 n1_M2_23820_74580 0.988200
R8302 n1_M2_23820_74580 n1_M2_24900_74580 0.988200
R8303 n1_M2_24900_74580 n1_M2_25980_74580 0.988200
R8304 n1_M2_25980_74580 n1_M2_27060_74580 0.988200
R8305 n1_M2_27060_74580 n1_M2_28140_74580 0.988200
R8306 n1_M2_28140_74580 n1_M2_29220_74580 0.988200
R8307 n1_M2_29220_74580 n1_M2_30300_74580 0.988200
R8308 n1_M2_30300_74580 n1_M2_31380_74580 0.988200
R8309 n1_M2_31380_74580 n1_M2_32460_74580 0.988200
R8310 n1_M2_32460_74580 n1_M2_33540_74580 0.988200
R8311 n1_M2_33540_74580 n1_M2_34620_74580 0.988200
R8312 n1_M2_34620_74580 n1_M2_35700_74580 0.988200
R8313 n1_M2_35700_74580 n1_M2_36780_74580 0.988200
R8314 n1_M2_36780_74580 n1_M2_37860_74580 0.988200
R8315 n1_M2_37860_74580 n1_M2_38940_74580 0.988200
R8316 n1_M2_38940_74580 n1_M2_40020_74580 0.988200
R8317 n1_M2_40020_74580 n1_M2_41100_74580 0.988200
R8318 n1_M2_41100_74580 n1_M2_42180_74580 0.988200
R8319 n1_M2_42180_74580 n1_M2_43260_74580 0.988200
R8320 n1_M2_43260_74580 n1_M2_44340_74580 0.988200
R8321 n1_M2_44340_74580 n1_M2_45420_74580 0.988200
R8322 n1_M2_45420_74580 n1_M2_46500_74580 0.988200
R8323 n1_M2_46500_74580 n1_M2_47580_74580 0.988200
R8324 n1_M2_47580_74580 n1_M2_48660_74580 0.988200
R8325 n1_M2_48660_74580 n1_M2_49740_74580 0.988200
R8326 n1_M2_49740_74580 n1_M2_50820_74580 0.988200
R8327 n1_M2_50820_74580 n1_M2_51900_74580 0.988200
R8328 n1_M2_51900_74580 n1_M2_52980_74580 0.988200
R8329 n1_M2_52980_74580 n1_M2_54060_74580 0.988200
R8330 n1_M2_54060_74580 n1_M2_55140_74580 0.988200
R8331 n1_M2_55140_74580 n1_M2_56220_74580 0.988200
R8332 n1_M2_56220_74580 n1_M2_57300_74580 0.988200
R8333 n1_M2_57300_74580 n1_M2_58380_74580 0.988200
R8334 n1_M2_58380_74580 n1_M2_59460_74580 0.988200
R8335 n1_M2_59460_74580 n1_M2_60540_74580 0.988200
R8336 n1_M2_60540_74580 n1_M2_61620_74580 0.988200
R8337 n1_M2_61620_74580 n1_M2_62700_74580 0.988200
R8338 n1_M2_62700_74580 n1_M2_63780_74580 0.988200
R8339 n1_M2_63780_74580 n1_M2_64860_74580 0.988200
R8340 n1_M2_64860_74580 n1_M2_65940_74580 0.988200
R8341 n1_M2_65940_74580 n1_M2_67020_74580 0.988200
R8342 n1_M2_67020_74580 n1_M2_68100_74580 0.988200
R8343 n1_M2_68100_74580 n1_M2_69180_74580 0.988200
R8344 n1_M2_69180_74580 n1_M2_70260_74580 0.988200
R8345 n1_M2_70260_74580 n1_M2_71340_74580 0.988200
R8346 n1_M2_71340_74580 n1_M2_72420_74580 0.988200
R8347 n1_M2_72420_74580 n1_M2_73500_74580 0.988200
R8348 n1_M2_73500_74580 n1_M2_74580_74580 0.988200
R8349 n1_M2_74580_74580 n1_M2_75660_74580 0.988200
R8350 n1_M2_75660_74580 n1_M2_76740_74580 0.988200
R8351 n1_M2_76740_74580 n1_M2_77820_74580 0.988200
R8352 n1_M2_77820_74580 n1_M2_78900_74580 0.988200
R8353 n1_M2_78900_74580 n1_M2_79980_74580 0.988200
R8354 n1_M2_79980_74580 n1_M2_81060_74580 0.988200
R8355 n1_M2_81060_74580 n1_M2_82140_74580 0.988200
R8356 n1_M2_82140_74580 n1_M2_83220_74580 0.988200
R8357 n1_M2_83220_74580 n1_M2_84300_74580 0.988200
R8358 n1_M2_84300_74580 n1_M2_85380_74580 0.988200
R8359 n1_M2_85380_74580 n1_M2_86460_74580 0.988200
R8360 n1_M2_86460_74580 n1_M2_87540_74580 0.988200
R8361 n1_M2_87540_74580 n1_M2_88620_74580 0.988200
R8362 n1_M2_88620_74580 n1_M2_89700_74580 0.988200
R8363 n1_M2_89700_74580 n1_M2_90780_74580 0.988200
R8364 n1_M2_90780_74580 n1_M2_91860_74580 0.988200
R8365 n1_M2_91860_74580 n1_M2_92940_74580 0.988200
R8366 n1_M2_92940_74580 n1_M2_94020_74580 0.988200
R8367 n1_M2_94020_74580 n1_M2_95100_74580 0.988200
R8368 n1_M2_95100_74580 n1_M2_96180_74580 0.988200
R8369 n1_M2_96180_74580 n1_M2_97260_74580 0.988200
R8370 n1_M2_97260_74580 n1_M2_98340_74580 0.988200
R8371 n1_M2_98340_74580 n1_M2_99420_74580 0.988200
R8372 n1_M2_99420_74580 n1_M2_100500_74580 0.988200
R8373 n1_M2_100500_74580 n1_M2_101580_74580 0.988200
R8374 n1_M2_101580_74580 n1_M2_102660_74580 0.988200
R8375 n1_M2_102660_74580 n1_M2_103740_74580 0.988200
R8376 n1_M2_103740_74580 n1_M2_104820_74580 0.988200
R8377 n1_M2_104820_74580 n1_M2_105900_74580 0.988200
R8378 n1_M2_105900_74580 n1_M2_106980_74580 0.988200
R8379 n1_M2_106980_74580 n1_M2_108060_74580 0.988200
R8380 n1_M2_108060_74580 n1_M2_109140_74580 0.988200
R8381 n1_M2_109140_74580 n1_M2_110220_74580 0.988200
R8382 n1_M2_110220_74580 n1_M2_111300_74580 0.988200
R8383 n1_M2_111300_74580 n1_M2_112380_74580 0.988200
R8384 n1_M2_112380_74580 n1_M2_113460_74580 0.988200
R8385 n1_M2_113460_74580 n1_M2_114540_74580 0.988200
R8386 n1_M2_114540_74580 n1_M2_115620_74580 0.988200
R8387 n1_M2_115620_74580 n1_M2_116700_74580 0.988200
R8388 n1_M2_116700_74580 n1_M2_117780_74580 0.988200
R8389 n1_M2_117780_74580 n1_M2_118860_74580 0.988200
R8390 n1_M2_118860_74580 n1_M2_119940_74580 0.988200
R8391 n1_M2_119940_74580 n1_M2_121020_74580 0.988200
R8392 n1_M2_121020_74580 n1_M2_122100_74580 0.988200
R8393 n1_M2_122100_74580 n1_M2_123180_74580 0.988200
R8394 n1_M2_123180_74580 n1_M2_124260_74580 0.988200
R8395 n1_M2_124260_74580 n1_M2_125340_74580 0.988200
R8396 n1_M2_125340_74580 n1_M2_126420_74580 0.988200
R8397 n1_M2_126420_74580 n1_M2_127500_74580 0.988200
R8398 n1_M2_127500_74580 n1_M2_128580_74580 0.988200
R8399 n1_M2_128580_74580 n1_M2_129660_74580 0.988200
R8400 n1_M2_60_75660 n1_M2_1140_75660 0.988200
R8401 n1_M2_1140_75660 n1_M2_2220_75660 0.988200
R8402 n1_M2_2220_75660 n1_M2_3300_75660 0.988200
R8403 n1_M2_3300_75660 n1_M2_4380_75660 0.988200
R8404 n1_M2_4380_75660 n1_M2_5460_75660 0.988200
R8405 n1_M2_5460_75660 n1_M2_6540_75660 0.988200
R8406 n1_M2_6540_75660 n1_M2_7620_75660 0.988200
R8407 n1_M2_7620_75660 n1_M2_8700_75660 0.988200
R8408 n1_M2_8700_75660 n1_M2_9780_75660 0.988200
R8409 n1_M2_9780_75660 n1_M2_10860_75660 0.988200
R8410 n1_M2_10860_75660 n1_M2_11940_75660 0.988200
R8411 n1_M2_11940_75660 n1_M2_13020_75660 0.988200
R8412 n1_M2_13020_75660 n1_M2_14100_75660 0.988200
R8413 n1_M2_14100_75660 n1_M2_15180_75660 0.988200
R8414 n1_M2_15180_75660 n1_M2_16260_75660 0.988200
R8415 n1_M2_16260_75660 n1_M2_17340_75660 0.988200
R8416 n1_M2_17340_75660 n1_M2_18420_75660 0.988200
R8417 n1_M2_18420_75660 n1_M2_19500_75660 0.988200
R8418 n1_M2_19500_75660 n1_M2_20580_75660 0.988200
R8419 n1_M2_20580_75660 n1_M2_21660_75660 0.988200
R8420 n1_M2_21660_75660 n1_M2_22740_75660 0.988200
R8421 n1_M2_22740_75660 n1_M2_23820_75660 0.988200
R8422 n1_M2_23820_75660 n1_M2_24900_75660 0.988200
R8423 n1_M2_24900_75660 n1_M2_25980_75660 0.988200
R8424 n1_M2_25980_75660 n1_M2_27060_75660 0.988200
R8425 n1_M2_27060_75660 n1_M2_28140_75660 0.988200
R8426 n1_M2_28140_75660 n1_M2_29220_75660 0.988200
R8427 n1_M2_29220_75660 n1_M2_30300_75660 0.988200
R8428 n1_M2_30300_75660 n1_M2_31380_75660 0.988200
R8429 n1_M2_31380_75660 n1_M2_32460_75660 0.988200
R8430 n1_M2_32460_75660 n1_M2_33540_75660 0.988200
R8431 n1_M2_33540_75660 n1_M2_34620_75660 0.988200
R8432 n1_M2_34620_75660 n1_M2_35700_75660 0.988200
R8433 n1_M2_35700_75660 n1_M2_36780_75660 0.988200
R8434 n1_M2_36780_75660 n1_M2_37860_75660 0.988200
R8435 n1_M2_37860_75660 n1_M2_38940_75660 0.988200
R8436 n1_M2_38940_75660 n1_M2_40020_75660 0.988200
R8437 n1_M2_40020_75660 n1_M2_41100_75660 0.988200
R8438 n1_M2_41100_75660 n1_M2_42180_75660 0.988200
R8439 n1_M2_42180_75660 n1_M2_43260_75660 0.988200
R8440 n1_M2_43260_75660 n1_M2_44340_75660 0.988200
R8441 n1_M2_44340_75660 n1_M2_45420_75660 0.988200
R8442 n1_M2_45420_75660 n1_M2_46500_75660 0.988200
R8443 n1_M2_46500_75660 n1_M2_47580_75660 0.988200
R8444 n1_M2_47580_75660 n1_M2_48660_75660 0.988200
R8445 n1_M2_48660_75660 n1_M2_49740_75660 0.988200
R8446 n1_M2_49740_75660 n1_M2_50820_75660 0.988200
R8447 n1_M2_50820_75660 n1_M2_51900_75660 0.988200
R8448 n1_M2_51900_75660 n1_M2_52980_75660 0.988200
R8449 n1_M2_52980_75660 n1_M2_54060_75660 0.988200
R8450 n1_M2_54060_75660 n1_M2_55140_75660 0.988200
R8451 n1_M2_55140_75660 n1_M2_56220_75660 0.988200
R8452 n1_M2_56220_75660 n1_M2_57300_75660 0.988200
R8453 n1_M2_57300_75660 n1_M2_58380_75660 0.988200
R8454 n1_M2_58380_75660 n1_M2_59460_75660 0.988200
R8455 n1_M2_59460_75660 n1_M2_60540_75660 0.988200
R8456 n1_M2_60540_75660 n1_M2_61620_75660 0.988200
R8457 n1_M2_61620_75660 n1_M2_62700_75660 0.988200
R8458 n1_M2_62700_75660 n1_M2_63780_75660 0.988200
R8459 n1_M2_63780_75660 n1_M2_64860_75660 0.988200
R8460 n1_M2_64860_75660 n1_M2_65940_75660 0.988200
R8461 n1_M2_65940_75660 n1_M2_67020_75660 0.988200
R8462 n1_M2_67020_75660 n1_M2_68100_75660 0.988200
R8463 n1_M2_68100_75660 n1_M2_69180_75660 0.988200
R8464 n1_M2_69180_75660 n1_M2_70260_75660 0.988200
R8465 n1_M2_70260_75660 n1_M2_71340_75660 0.988200
R8466 n1_M2_71340_75660 n1_M2_72420_75660 0.988200
R8467 n1_M2_72420_75660 n1_M2_73500_75660 0.988200
R8468 n1_M2_73500_75660 n1_M2_74580_75660 0.988200
R8469 n1_M2_74580_75660 n1_M2_75660_75660 0.988200
R8470 n1_M2_75660_75660 n1_M2_76740_75660 0.988200
R8471 n1_M2_76740_75660 n1_M2_77820_75660 0.988200
R8472 n1_M2_77820_75660 n1_M2_78900_75660 0.988200
R8473 n1_M2_78900_75660 n1_M2_79980_75660 0.988200
R8474 n1_M2_79980_75660 n1_M2_81060_75660 0.988200
R8475 n1_M2_81060_75660 n1_M2_82140_75660 0.988200
R8476 n1_M2_82140_75660 n1_M2_83220_75660 0.988200
R8477 n1_M2_83220_75660 n1_M2_84300_75660 0.988200
R8478 n1_M2_84300_75660 n1_M2_85380_75660 0.988200
R8479 n1_M2_85380_75660 n1_M2_86460_75660 0.988200
R8480 n1_M2_86460_75660 n1_M2_87540_75660 0.988200
R8481 n1_M2_87540_75660 n1_M2_88620_75660 0.988200
R8482 n1_M2_88620_75660 n1_M2_89700_75660 0.988200
R8483 n1_M2_89700_75660 n1_M2_90780_75660 0.988200
R8484 n1_M2_90780_75660 n1_M2_91860_75660 0.988200
R8485 n1_M2_91860_75660 n1_M2_92940_75660 0.988200
R8486 n1_M2_92940_75660 n1_M2_94020_75660 0.988200
R8487 n1_M2_94020_75660 n1_M2_95100_75660 0.988200
R8488 n1_M2_95100_75660 n1_M2_96180_75660 0.988200
R8489 n1_M2_96180_75660 n1_M2_97260_75660 0.988200
R8490 n1_M2_97260_75660 n1_M2_98340_75660 0.988200
R8491 n1_M2_98340_75660 n1_M2_99420_75660 0.988200
R8492 n1_M2_99420_75660 n1_M2_100500_75660 0.988200
R8493 n1_M2_100500_75660 n1_M2_101580_75660 0.988200
R8494 n1_M2_101580_75660 n1_M2_102660_75660 0.988200
R8495 n1_M2_102660_75660 n1_M2_103740_75660 0.988200
R8496 n1_M2_103740_75660 n1_M2_104820_75660 0.988200
R8497 n1_M2_104820_75660 n1_M2_105900_75660 0.988200
R8498 n1_M2_105900_75660 n1_M2_106980_75660 0.988200
R8499 n1_M2_106980_75660 n1_M2_108060_75660 0.988200
R8500 n1_M2_108060_75660 n1_M2_109140_75660 0.988200
R8501 n1_M2_109140_75660 n1_M2_110220_75660 0.988200
R8502 n1_M2_110220_75660 n1_M2_111300_75660 0.988200
R8503 n1_M2_111300_75660 n1_M2_112380_75660 0.988200
R8504 n1_M2_112380_75660 n1_M2_113460_75660 0.988200
R8505 n1_M2_113460_75660 n1_M2_114540_75660 0.988200
R8506 n1_M2_114540_75660 n1_M2_115620_75660 0.988200
R8507 n1_M2_115620_75660 n1_M2_116700_75660 0.988200
R8508 n1_M2_116700_75660 n1_M2_117780_75660 0.988200
R8509 n1_M2_117780_75660 n1_M2_118860_75660 0.988200
R8510 n1_M2_118860_75660 n1_M2_119940_75660 0.988200
R8511 n1_M2_119940_75660 n1_M2_121020_75660 0.988200
R8512 n1_M2_121020_75660 n1_M2_122100_75660 0.988200
R8513 n1_M2_122100_75660 n1_M2_123180_75660 0.988200
R8514 n1_M2_123180_75660 n1_M2_124260_75660 0.988200
R8515 n1_M2_124260_75660 n1_M2_125340_75660 0.988200
R8516 n1_M2_125340_75660 n1_M2_126420_75660 0.988200
R8517 n1_M2_126420_75660 n1_M2_127500_75660 0.988200
R8518 n1_M2_127500_75660 n1_M2_128580_75660 0.988200
R8519 n1_M2_128580_75660 n1_M2_129660_75660 0.988200
R8520 n1_M2_60_76740 n1_M2_1140_76740 0.988200
R8521 n1_M2_1140_76740 n1_M2_2220_76740 0.988200
R8522 n1_M2_2220_76740 n1_M2_3300_76740 0.988200
R8523 n1_M2_3300_76740 n1_M2_4380_76740 0.988200
R8524 n1_M2_4380_76740 n1_M2_5460_76740 0.988200
R8525 n1_M2_5460_76740 n1_M2_6540_76740 0.988200
R8526 n1_M2_6540_76740 n1_M2_7620_76740 0.988200
R8527 n1_M2_7620_76740 n1_M2_8700_76740 0.988200
R8528 n1_M2_8700_76740 n1_M2_9780_76740 0.988200
R8529 n1_M2_9780_76740 n1_M2_10860_76740 0.988200
R8530 n1_M2_10860_76740 n1_M2_11940_76740 0.988200
R8531 n1_M2_11940_76740 n1_M2_13020_76740 0.988200
R8532 n1_M2_13020_76740 n1_M2_14100_76740 0.988200
R8533 n1_M2_14100_76740 n1_M2_15180_76740 0.988200
R8534 n1_M2_15180_76740 n1_M2_16260_76740 0.988200
R8535 n1_M2_16260_76740 n1_M2_17340_76740 0.988200
R8536 n1_M2_17340_76740 n1_M2_18420_76740 0.988200
R8537 n1_M2_18420_76740 n1_M2_19500_76740 0.988200
R8538 n1_M2_19500_76740 n1_M2_20580_76740 0.988200
R8539 n1_M2_20580_76740 n1_M2_21660_76740 0.988200
R8540 n1_M2_21660_76740 n1_M2_22740_76740 0.988200
R8541 n1_M2_22740_76740 n1_M2_23820_76740 0.988200
R8542 n1_M2_23820_76740 n1_M2_24900_76740 0.988200
R8543 n1_M2_24900_76740 n1_M2_25980_76740 0.988200
R8544 n1_M2_25980_76740 n1_M2_27060_76740 0.988200
R8545 n1_M2_27060_76740 n1_M2_28140_76740 0.988200
R8546 n1_M2_28140_76740 n1_M2_29220_76740 0.988200
R8547 n1_M2_29220_76740 n1_M2_30300_76740 0.988200
R8548 n1_M2_30300_76740 n1_M2_31380_76740 0.988200
R8549 n1_M2_31380_76740 n1_M2_32460_76740 0.988200
R8550 n1_M2_32460_76740 n1_M2_33540_76740 0.988200
R8551 n1_M2_33540_76740 n1_M2_34620_76740 0.988200
R8552 n1_M2_34620_76740 n1_M2_35700_76740 0.988200
R8553 n1_M2_35700_76740 n1_M2_36780_76740 0.988200
R8554 n1_M2_36780_76740 n1_M2_37860_76740 0.988200
R8555 n1_M2_37860_76740 n1_M2_38940_76740 0.988200
R8556 n1_M2_38940_76740 n1_M2_40020_76740 0.988200
R8557 n1_M2_40020_76740 n1_M2_41100_76740 0.988200
R8558 n1_M2_41100_76740 n1_M2_42180_76740 0.988200
R8559 n1_M2_42180_76740 n1_M2_43260_76740 0.988200
R8560 n1_M2_43260_76740 n1_M2_44340_76740 0.988200
R8561 n1_M2_44340_76740 n1_M2_45420_76740 0.988200
R8562 n1_M2_45420_76740 n1_M2_46500_76740 0.988200
R8563 n1_M2_46500_76740 n1_M2_47580_76740 0.988200
R8564 n1_M2_47580_76740 n1_M2_48660_76740 0.988200
R8565 n1_M2_48660_76740 n1_M2_49740_76740 0.988200
R8566 n1_M2_49740_76740 n1_M2_50820_76740 0.988200
R8567 n1_M2_50820_76740 n1_M2_51900_76740 0.988200
R8568 n1_M2_51900_76740 n1_M2_52980_76740 0.988200
R8569 n1_M2_52980_76740 n1_M2_54060_76740 0.988200
R8570 n1_M2_54060_76740 n1_M2_55140_76740 0.988200
R8571 n1_M2_55140_76740 n1_M2_56220_76740 0.988200
R8572 n1_M2_56220_76740 n1_M2_57300_76740 0.988200
R8573 n1_M2_57300_76740 n1_M2_58380_76740 0.988200
R8574 n1_M2_58380_76740 n1_M2_59460_76740 0.988200
R8575 n1_M2_59460_76740 n1_M2_60540_76740 0.988200
R8576 n1_M2_60540_76740 n1_M2_61620_76740 0.988200
R8577 n1_M2_61620_76740 n1_M2_62700_76740 0.988200
R8578 n1_M2_62700_76740 n1_M2_63780_76740 0.988200
R8579 n1_M2_63780_76740 n1_M2_64860_76740 0.988200
R8580 n1_M2_64860_76740 n1_M2_65940_76740 0.988200
R8581 n1_M2_65940_76740 n1_M2_67020_76740 0.988200
R8582 n1_M2_67020_76740 n1_M2_68100_76740 0.988200
R8583 n1_M2_68100_76740 n1_M2_69180_76740 0.988200
R8584 n1_M2_69180_76740 n1_M2_70260_76740 0.988200
R8585 n1_M2_70260_76740 n1_M2_71340_76740 0.988200
R8586 n1_M2_71340_76740 n1_M2_72420_76740 0.988200
R8587 n1_M2_72420_76740 n1_M2_73500_76740 0.988200
R8588 n1_M2_73500_76740 n1_M2_74580_76740 0.988200
R8589 n1_M2_74580_76740 n1_M2_75660_76740 0.988200
R8590 n1_M2_75660_76740 n1_M2_76740_76740 0.988200
R8591 n1_M2_76740_76740 n1_M2_77820_76740 0.988200
R8592 n1_M2_77820_76740 n1_M2_78900_76740 0.988200
R8593 n1_M2_78900_76740 n1_M2_79980_76740 0.988200
R8594 n1_M2_79980_76740 n1_M2_81060_76740 0.988200
R8595 n1_M2_81060_76740 n1_M2_82140_76740 0.988200
R8596 n1_M2_82140_76740 n1_M2_83220_76740 0.988200
R8597 n1_M2_83220_76740 n1_M2_84300_76740 0.988200
R8598 n1_M2_84300_76740 n1_M2_85380_76740 0.988200
R8599 n1_M2_85380_76740 n1_M2_86460_76740 0.988200
R8600 n1_M2_86460_76740 n1_M2_87540_76740 0.988200
R8601 n1_M2_87540_76740 n1_M2_88620_76740 0.988200
R8602 n1_M2_88620_76740 n1_M2_89700_76740 0.988200
R8603 n1_M2_89700_76740 n1_M2_90780_76740 0.988200
R8604 n1_M2_90780_76740 n1_M2_91860_76740 0.988200
R8605 n1_M2_91860_76740 n1_M2_92940_76740 0.988200
R8606 n1_M2_92940_76740 n1_M2_94020_76740 0.988200
R8607 n1_M2_94020_76740 n1_M2_95100_76740 0.988200
R8608 n1_M2_95100_76740 n1_M2_96180_76740 0.988200
R8609 n1_M2_96180_76740 n1_M2_97260_76740 0.988200
R8610 n1_M2_97260_76740 n1_M2_98340_76740 0.988200
R8611 n1_M2_98340_76740 n1_M2_99420_76740 0.988200
R8612 n1_M2_99420_76740 n1_M2_100500_76740 0.988200
R8613 n1_M2_100500_76740 n1_M2_101580_76740 0.988200
R8614 n1_M2_101580_76740 n1_M2_102660_76740 0.988200
R8615 n1_M2_102660_76740 n1_M2_103740_76740 0.988200
R8616 n1_M2_103740_76740 n1_M2_104820_76740 0.988200
R8617 n1_M2_104820_76740 n1_M2_105900_76740 0.988200
R8618 n1_M2_105900_76740 n1_M2_106980_76740 0.988200
R8619 n1_M2_106980_76740 n1_M2_108060_76740 0.988200
R8620 n1_M2_108060_76740 n1_M2_109140_76740 0.988200
R8621 n1_M2_109140_76740 n1_M2_110220_76740 0.988200
R8622 n1_M2_110220_76740 n1_M2_111300_76740 0.988200
R8623 n1_M2_111300_76740 n1_M2_112380_76740 0.988200
R8624 n1_M2_112380_76740 n1_M2_113460_76740 0.988200
R8625 n1_M2_113460_76740 n1_M2_114540_76740 0.988200
R8626 n1_M2_114540_76740 n1_M2_115620_76740 0.988200
R8627 n1_M2_115620_76740 n1_M2_116700_76740 0.988200
R8628 n1_M2_116700_76740 n1_M2_117780_76740 0.988200
R8629 n1_M2_117780_76740 n1_M2_118860_76740 0.988200
R8630 n1_M2_118860_76740 n1_M2_119940_76740 0.988200
R8631 n1_M2_119940_76740 n1_M2_121020_76740 0.988200
R8632 n1_M2_121020_76740 n1_M2_122100_76740 0.988200
R8633 n1_M2_122100_76740 n1_M2_123180_76740 0.988200
R8634 n1_M2_123180_76740 n1_M2_124260_76740 0.988200
R8635 n1_M2_124260_76740 n1_M2_125340_76740 0.988200
R8636 n1_M2_125340_76740 n1_M2_126420_76740 0.988200
R8637 n1_M2_126420_76740 n1_M2_127500_76740 0.988200
R8638 n1_M2_127500_76740 n1_M2_128580_76740 0.988200
R8639 n1_M2_128580_76740 n1_M2_129660_76740 0.988200
R8640 n1_M2_60_77820 n1_M2_1140_77820 0.988200
R8641 n1_M2_1140_77820 n1_M2_2220_77820 0.988200
R8642 n1_M2_2220_77820 n1_M2_3300_77820 0.988200
R8643 n1_M2_3300_77820 n1_M2_4380_77820 0.988200
R8644 n1_M2_4380_77820 n1_M2_5460_77820 0.988200
R8645 n1_M2_5460_77820 n1_M2_6540_77820 0.988200
R8646 n1_M2_6540_77820 n1_M2_7620_77820 0.988200
R8647 n1_M2_7620_77820 n1_M2_8700_77820 0.988200
R8648 n1_M2_8700_77820 n1_M2_9780_77820 0.988200
R8649 n1_M2_9780_77820 n1_M2_10860_77820 0.988200
R8650 n1_M2_10860_77820 n1_M2_11940_77820 0.988200
R8651 n1_M2_11940_77820 n1_M2_13020_77820 0.988200
R8652 n1_M2_13020_77820 n1_M2_14100_77820 0.988200
R8653 n1_M2_14100_77820 n1_M2_15180_77820 0.988200
R8654 n1_M2_15180_77820 n1_M2_16260_77820 0.988200
R8655 n1_M2_16260_77820 n1_M2_17340_77820 0.988200
R8656 n1_M2_17340_77820 n1_M2_18420_77820 0.988200
R8657 n1_M2_18420_77820 n1_M2_19500_77820 0.988200
R8658 n1_M2_19500_77820 n1_M2_20580_77820 0.988200
R8659 n1_M2_20580_77820 n1_M2_21660_77820 0.988200
R8660 n1_M2_21660_77820 n1_M2_22740_77820 0.988200
R8661 n1_M2_22740_77820 n1_M2_23820_77820 0.988200
R8662 n1_M2_23820_77820 n1_M2_24900_77820 0.988200
R8663 n1_M2_24900_77820 n1_M2_25980_77820 0.988200
R8664 n1_M2_25980_77820 n1_M2_27060_77820 0.988200
R8665 n1_M2_27060_77820 n1_M2_28140_77820 0.988200
R8666 n1_M2_28140_77820 n1_M2_29220_77820 0.988200
R8667 n1_M2_29220_77820 n1_M2_30300_77820 0.988200
R8668 n1_M2_30300_77820 n1_M2_31380_77820 0.988200
R8669 n1_M2_31380_77820 n1_M2_32460_77820 0.988200
R8670 n1_M2_32460_77820 n1_M2_33540_77820 0.988200
R8671 n1_M2_33540_77820 n1_M2_34620_77820 0.988200
R8672 n1_M2_34620_77820 n1_M2_35700_77820 0.988200
R8673 n1_M2_35700_77820 n1_M2_36780_77820 0.988200
R8674 n1_M2_36780_77820 n1_M2_37860_77820 0.988200
R8675 n1_M2_37860_77820 n1_M2_38940_77820 0.988200
R8676 n1_M2_38940_77820 n1_M2_40020_77820 0.988200
R8677 n1_M2_40020_77820 n1_M2_41100_77820 0.988200
R8678 n1_M2_41100_77820 n1_M2_42180_77820 0.988200
R8679 n1_M2_42180_77820 n1_M2_43260_77820 0.988200
R8680 n1_M2_43260_77820 n1_M2_44340_77820 0.988200
R8681 n1_M2_44340_77820 n1_M2_45420_77820 0.988200
R8682 n1_M2_45420_77820 n1_M2_46500_77820 0.988200
R8683 n1_M2_46500_77820 n1_M2_47580_77820 0.988200
R8684 n1_M2_47580_77820 n1_M2_48660_77820 0.988200
R8685 n1_M2_48660_77820 n1_M2_49740_77820 0.988200
R8686 n1_M2_49740_77820 n1_M2_50820_77820 0.988200
R8687 n1_M2_50820_77820 n1_M2_51900_77820 0.988200
R8688 n1_M2_51900_77820 n1_M2_52980_77820 0.988200
R8689 n1_M2_52980_77820 n1_M2_54060_77820 0.988200
R8690 n1_M2_54060_77820 n1_M2_55140_77820 0.988200
R8691 n1_M2_55140_77820 n1_M2_56220_77820 0.988200
R8692 n1_M2_56220_77820 n1_M2_57300_77820 0.988200
R8693 n1_M2_57300_77820 n1_M2_58380_77820 0.988200
R8694 n1_M2_58380_77820 n1_M2_59460_77820 0.988200
R8695 n1_M2_59460_77820 n1_M2_60540_77820 0.988200
R8696 n1_M2_60540_77820 n1_M2_61620_77820 0.988200
R8697 n1_M2_61620_77820 n1_M2_62700_77820 0.988200
R8698 n1_M2_62700_77820 n1_M2_63780_77820 0.988200
R8699 n1_M2_63780_77820 n1_M2_64860_77820 0.988200
R8700 n1_M2_64860_77820 n1_M2_65940_77820 0.988200
R8701 n1_M2_65940_77820 n1_M2_67020_77820 0.988200
R8702 n1_M2_67020_77820 n1_M2_68100_77820 0.988200
R8703 n1_M2_68100_77820 n1_M2_69180_77820 0.988200
R8704 n1_M2_69180_77820 n1_M2_70260_77820 0.988200
R8705 n1_M2_70260_77820 n1_M2_71340_77820 0.988200
R8706 n1_M2_71340_77820 n1_M2_72420_77820 0.988200
R8707 n1_M2_72420_77820 n1_M2_73500_77820 0.988200
R8708 n1_M2_73500_77820 n1_M2_74580_77820 0.988200
R8709 n1_M2_74580_77820 n1_M2_75660_77820 0.988200
R8710 n1_M2_75660_77820 n1_M2_76740_77820 0.988200
R8711 n1_M2_76740_77820 n1_M2_77820_77820 0.988200
R8712 n1_M2_77820_77820 n1_M2_78900_77820 0.988200
R8713 n1_M2_78900_77820 n1_M2_79980_77820 0.988200
R8714 n1_M2_79980_77820 n1_M2_81060_77820 0.988200
R8715 n1_M2_81060_77820 n1_M2_82140_77820 0.988200
R8716 n1_M2_82140_77820 n1_M2_83220_77820 0.988200
R8717 n1_M2_83220_77820 n1_M2_84300_77820 0.988200
R8718 n1_M2_84300_77820 n1_M2_85380_77820 0.988200
R8719 n1_M2_85380_77820 n1_M2_86460_77820 0.988200
R8720 n1_M2_86460_77820 n1_M2_87540_77820 0.988200
R8721 n1_M2_87540_77820 n1_M2_88620_77820 0.988200
R8722 n1_M2_88620_77820 n1_M2_89700_77820 0.988200
R8723 n1_M2_89700_77820 n1_M2_90780_77820 0.988200
R8724 n1_M2_90780_77820 n1_M2_91860_77820 0.988200
R8725 n1_M2_91860_77820 n1_M2_92940_77820 0.988200
R8726 n1_M2_92940_77820 n1_M2_94020_77820 0.988200
R8727 n1_M2_94020_77820 n1_M2_95100_77820 0.988200
R8728 n1_M2_95100_77820 n1_M2_96180_77820 0.988200
R8729 n1_M2_96180_77820 n1_M2_97260_77820 0.988200
R8730 n1_M2_97260_77820 n1_M2_98340_77820 0.988200
R8731 n1_M2_98340_77820 n1_M2_99420_77820 0.988200
R8732 n1_M2_99420_77820 n1_M2_100500_77820 0.988200
R8733 n1_M2_100500_77820 n1_M2_101580_77820 0.988200
R8734 n1_M2_101580_77820 n1_M2_102660_77820 0.988200
R8735 n1_M2_102660_77820 n1_M2_103740_77820 0.988200
R8736 n1_M2_103740_77820 n1_M2_104820_77820 0.988200
R8737 n1_M2_104820_77820 n1_M2_105900_77820 0.988200
R8738 n1_M2_105900_77820 n1_M2_106980_77820 0.988200
R8739 n1_M2_106980_77820 n1_M2_108060_77820 0.988200
R8740 n1_M2_108060_77820 n1_M2_109140_77820 0.988200
R8741 n1_M2_109140_77820 n1_M2_110220_77820 0.988200
R8742 n1_M2_110220_77820 n1_M2_111300_77820 0.988200
R8743 n1_M2_111300_77820 n1_M2_112380_77820 0.988200
R8744 n1_M2_112380_77820 n1_M2_113460_77820 0.988200
R8745 n1_M2_113460_77820 n1_M2_114540_77820 0.988200
R8746 n1_M2_114540_77820 n1_M2_115620_77820 0.988200
R8747 n1_M2_115620_77820 n1_M2_116700_77820 0.988200
R8748 n1_M2_116700_77820 n1_M2_117780_77820 0.988200
R8749 n1_M2_117780_77820 n1_M2_118860_77820 0.988200
R8750 n1_M2_118860_77820 n1_M2_119940_77820 0.988200
R8751 n1_M2_119940_77820 n1_M2_121020_77820 0.988200
R8752 n1_M2_121020_77820 n1_M2_122100_77820 0.988200
R8753 n1_M2_122100_77820 n1_M2_123180_77820 0.988200
R8754 n1_M2_123180_77820 n1_M2_124260_77820 0.988200
R8755 n1_M2_124260_77820 n1_M2_125340_77820 0.988200
R8756 n1_M2_125340_77820 n1_M2_126420_77820 0.988200
R8757 n1_M2_126420_77820 n1_M2_127500_77820 0.988200
R8758 n1_M2_127500_77820 n1_M2_128580_77820 0.988200
R8759 n1_M2_128580_77820 n1_M2_129660_77820 0.988200
R8760 n1_M2_60_78900 n1_M2_1140_78900 0.988200
R8761 n1_M2_1140_78900 n1_M2_2220_78900 0.988200
R8762 n1_M2_2220_78900 n1_M2_3300_78900 0.988200
R8763 n1_M2_3300_78900 n1_M2_4380_78900 0.988200
R8764 n1_M2_4380_78900 n1_M2_5460_78900 0.988200
R8765 n1_M2_5460_78900 n1_M2_6540_78900 0.988200
R8766 n1_M2_6540_78900 n1_M2_7620_78900 0.988200
R8767 n1_M2_7620_78900 n1_M2_8700_78900 0.988200
R8768 n1_M2_8700_78900 n1_M2_9780_78900 0.988200
R8769 n1_M2_9780_78900 n1_M2_10860_78900 0.988200
R8770 n1_M2_10860_78900 n1_M2_11940_78900 0.988200
R8771 n1_M2_11940_78900 n1_M2_13020_78900 0.988200
R8772 n1_M2_13020_78900 n1_M2_14100_78900 0.988200
R8773 n1_M2_14100_78900 n1_M2_15180_78900 0.988200
R8774 n1_M2_15180_78900 n1_M2_16260_78900 0.988200
R8775 n1_M2_16260_78900 n1_M2_17340_78900 0.988200
R8776 n1_M2_17340_78900 n1_M2_18420_78900 0.988200
R8777 n1_M2_18420_78900 n1_M2_19500_78900 0.988200
R8778 n1_M2_19500_78900 n1_M2_20580_78900 0.988200
R8779 n1_M2_20580_78900 n1_M2_21660_78900 0.988200
R8780 n1_M2_21660_78900 n1_M2_22740_78900 0.988200
R8781 n1_M2_22740_78900 n1_M2_23820_78900 0.988200
R8782 n1_M2_23820_78900 n1_M2_24900_78900 0.988200
R8783 n1_M2_24900_78900 n1_M2_25980_78900 0.988200
R8784 n1_M2_25980_78900 n1_M2_27060_78900 0.988200
R8785 n1_M2_27060_78900 n1_M2_28140_78900 0.988200
R8786 n1_M2_28140_78900 n1_M2_29220_78900 0.988200
R8787 n1_M2_29220_78900 n1_M2_30300_78900 0.988200
R8788 n1_M2_30300_78900 n1_M2_31380_78900 0.988200
R8789 n1_M2_31380_78900 n1_M2_32460_78900 0.988200
R8790 n1_M2_32460_78900 n1_M2_33540_78900 0.988200
R8791 n1_M2_33540_78900 n1_M2_34620_78900 0.988200
R8792 n1_M2_34620_78900 n1_M2_35700_78900 0.988200
R8793 n1_M2_35700_78900 n1_M2_36780_78900 0.988200
R8794 n1_M2_36780_78900 n1_M2_37860_78900 0.988200
R8795 n1_M2_37860_78900 n1_M2_38940_78900 0.988200
R8796 n1_M2_38940_78900 n1_M2_40020_78900 0.988200
R8797 n1_M2_40020_78900 n1_M2_41100_78900 0.988200
R8798 n1_M2_41100_78900 n1_M2_42180_78900 0.988200
R8799 n1_M2_42180_78900 n1_M2_43260_78900 0.988200
R8800 n1_M2_43260_78900 n1_M2_44340_78900 0.988200
R8801 n1_M2_44340_78900 n1_M2_45420_78900 0.988200
R8802 n1_M2_45420_78900 n1_M2_46500_78900 0.988200
R8803 n1_M2_46500_78900 n1_M2_47580_78900 0.988200
R8804 n1_M2_47580_78900 n1_M2_48660_78900 0.988200
R8805 n1_M2_48660_78900 n1_M2_49740_78900 0.988200
R8806 n1_M2_49740_78900 n1_M2_50820_78900 0.988200
R8807 n1_M2_50820_78900 n1_M2_51900_78900 0.988200
R8808 n1_M2_51900_78900 n1_M2_52980_78900 0.988200
R8809 n1_M2_52980_78900 n1_M2_54060_78900 0.988200
R8810 n1_M2_54060_78900 n1_M2_55140_78900 0.988200
R8811 n1_M2_55140_78900 n1_M2_56220_78900 0.988200
R8812 n1_M2_56220_78900 n1_M2_57300_78900 0.988200
R8813 n1_M2_57300_78900 n1_M2_58380_78900 0.988200
R8814 n1_M2_58380_78900 n1_M2_59460_78900 0.988200
R8815 n1_M2_59460_78900 n1_M2_60540_78900 0.988200
R8816 n1_M2_60540_78900 n1_M2_61620_78900 0.988200
R8817 n1_M2_61620_78900 n1_M2_62700_78900 0.988200
R8818 n1_M2_62700_78900 n1_M2_63780_78900 0.988200
R8819 n1_M2_63780_78900 n1_M2_64860_78900 0.988200
R8820 n1_M2_64860_78900 n1_M2_65940_78900 0.988200
R8821 n1_M2_65940_78900 n1_M2_67020_78900 0.988200
R8822 n1_M2_67020_78900 n1_M2_68100_78900 0.988200
R8823 n1_M2_68100_78900 n1_M2_69180_78900 0.988200
R8824 n1_M2_69180_78900 n1_M2_70260_78900 0.988200
R8825 n1_M2_70260_78900 n1_M2_71340_78900 0.988200
R8826 n1_M2_71340_78900 n1_M2_72420_78900 0.988200
R8827 n1_M2_72420_78900 n1_M2_73500_78900 0.988200
R8828 n1_M2_73500_78900 n1_M2_74580_78900 0.988200
R8829 n1_M2_74580_78900 n1_M2_75660_78900 0.988200
R8830 n1_M2_75660_78900 n1_M2_76740_78900 0.988200
R8831 n1_M2_76740_78900 n1_M2_77820_78900 0.988200
R8832 n1_M2_77820_78900 n1_M2_78900_78900 0.988200
R8833 n1_M2_78900_78900 n1_M2_79980_78900 0.988200
R8834 n1_M2_79980_78900 n1_M2_81060_78900 0.988200
R8835 n1_M2_81060_78900 n1_M2_82140_78900 0.988200
R8836 n1_M2_82140_78900 n1_M2_83220_78900 0.988200
R8837 n1_M2_83220_78900 n1_M2_84300_78900 0.988200
R8838 n1_M2_84300_78900 n1_M2_85380_78900 0.988200
R8839 n1_M2_85380_78900 n1_M2_86460_78900 0.988200
R8840 n1_M2_86460_78900 n1_M2_87540_78900 0.988200
R8841 n1_M2_87540_78900 n1_M2_88620_78900 0.988200
R8842 n1_M2_88620_78900 n1_M2_89700_78900 0.988200
R8843 n1_M2_89700_78900 n1_M2_90780_78900 0.988200
R8844 n1_M2_90780_78900 n1_M2_91860_78900 0.988200
R8845 n1_M2_91860_78900 n1_M2_92940_78900 0.988200
R8846 n1_M2_92940_78900 n1_M2_94020_78900 0.988200
R8847 n1_M2_94020_78900 n1_M2_95100_78900 0.988200
R8848 n1_M2_95100_78900 n1_M2_96180_78900 0.988200
R8849 n1_M2_96180_78900 n1_M2_97260_78900 0.988200
R8850 n1_M2_97260_78900 n1_M2_98340_78900 0.988200
R8851 n1_M2_98340_78900 n1_M2_99420_78900 0.988200
R8852 n1_M2_99420_78900 n1_M2_100500_78900 0.988200
R8853 n1_M2_100500_78900 n1_M2_101580_78900 0.988200
R8854 n1_M2_101580_78900 n1_M2_102660_78900 0.988200
R8855 n1_M2_102660_78900 n1_M2_103740_78900 0.988200
R8856 n1_M2_103740_78900 n1_M2_104820_78900 0.988200
R8857 n1_M2_104820_78900 n1_M2_105900_78900 0.988200
R8858 n1_M2_105900_78900 n1_M2_106980_78900 0.988200
R8859 n1_M2_106980_78900 n1_M2_108060_78900 0.988200
R8860 n1_M2_108060_78900 n1_M2_109140_78900 0.988200
R8861 n1_M2_109140_78900 n1_M2_110220_78900 0.988200
R8862 n1_M2_110220_78900 n1_M2_111300_78900 0.988200
R8863 n1_M2_111300_78900 n1_M2_112380_78900 0.988200
R8864 n1_M2_112380_78900 n1_M2_113460_78900 0.988200
R8865 n1_M2_113460_78900 n1_M2_114540_78900 0.988200
R8866 n1_M2_114540_78900 n1_M2_115620_78900 0.988200
R8867 n1_M2_115620_78900 n1_M2_116700_78900 0.988200
R8868 n1_M2_116700_78900 n1_M2_117780_78900 0.988200
R8869 n1_M2_117780_78900 n1_M2_118860_78900 0.988200
R8870 n1_M2_118860_78900 n1_M2_119940_78900 0.988200
R8871 n1_M2_119940_78900 n1_M2_121020_78900 0.988200
R8872 n1_M2_121020_78900 n1_M2_122100_78900 0.988200
R8873 n1_M2_122100_78900 n1_M2_123180_78900 0.988200
R8874 n1_M2_123180_78900 n1_M2_124260_78900 0.988200
R8875 n1_M2_124260_78900 n1_M2_125340_78900 0.988200
R8876 n1_M2_125340_78900 n1_M2_126420_78900 0.988200
R8877 n1_M2_126420_78900 n1_M2_127500_78900 0.988200
R8878 n1_M2_127500_78900 n1_M2_128580_78900 0.988200
R8879 n1_M2_128580_78900 n1_M2_129660_78900 0.988200
R8880 n1_M2_60_79980 n1_M2_1140_79980 0.988200
R8881 n1_M2_1140_79980 n1_M2_2220_79980 0.988200
R8882 n1_M2_2220_79980 n1_M2_3300_79980 0.988200
R8883 n1_M2_3300_79980 n1_M2_4380_79980 0.988200
R8884 n1_M2_4380_79980 n1_M2_5460_79980 0.988200
R8885 n1_M2_5460_79980 n1_M2_6540_79980 0.988200
R8886 n1_M2_6540_79980 n1_M2_7620_79980 0.988200
R8887 n1_M2_7620_79980 n1_M2_8700_79980 0.988200
R8888 n1_M2_8700_79980 n1_M2_9780_79980 0.988200
R8889 n1_M2_9780_79980 n1_M2_10860_79980 0.988200
R8890 n1_M2_10860_79980 n1_M2_11940_79980 0.988200
R8891 n1_M2_11940_79980 n1_M2_13020_79980 0.988200
R8892 n1_M2_13020_79980 n1_M2_14100_79980 0.988200
R8893 n1_M2_14100_79980 n1_M2_15180_79980 0.988200
R8894 n1_M2_15180_79980 n1_M2_16260_79980 0.988200
R8895 n1_M2_16260_79980 n1_M2_17340_79980 0.988200
R8896 n1_M2_17340_79980 n1_M2_18420_79980 0.988200
R8897 n1_M2_18420_79980 n1_M2_19500_79980 0.988200
R8898 n1_M2_19500_79980 n1_M2_20580_79980 0.988200
R8899 n1_M2_20580_79980 n1_M2_21660_79980 0.988200
R8900 n1_M2_21660_79980 n1_M2_22740_79980 0.988200
R8901 n1_M2_22740_79980 n1_M2_23820_79980 0.988200
R8902 n1_M2_23820_79980 n1_M2_24900_79980 0.988200
R8903 n1_M2_24900_79980 n1_M2_25980_79980 0.988200
R8904 n1_M2_25980_79980 n1_M2_27060_79980 0.988200
R8905 n1_M2_27060_79980 n1_M2_28140_79980 0.988200
R8906 n1_M2_28140_79980 n1_M2_29220_79980 0.988200
R8907 n1_M2_29220_79980 n1_M2_30300_79980 0.988200
R8908 n1_M2_30300_79980 n1_M2_31380_79980 0.988200
R8909 n1_M2_31380_79980 n1_M2_32460_79980 0.988200
R8910 n1_M2_32460_79980 n1_M2_33540_79980 0.988200
R8911 n1_M2_33540_79980 n1_M2_34620_79980 0.988200
R8912 n1_M2_34620_79980 n1_M2_35700_79980 0.988200
R8913 n1_M2_35700_79980 n1_M2_36780_79980 0.988200
R8914 n1_M2_36780_79980 n1_M2_37860_79980 0.988200
R8915 n1_M2_37860_79980 n1_M2_38940_79980 0.988200
R8916 n1_M2_38940_79980 n1_M2_40020_79980 0.988200
R8917 n1_M2_40020_79980 n1_M2_41100_79980 0.988200
R8918 n1_M2_41100_79980 n1_M2_42180_79980 0.988200
R8919 n1_M2_42180_79980 n1_M2_43260_79980 0.988200
R8920 n1_M2_43260_79980 n1_M2_44340_79980 0.988200
R8921 n1_M2_44340_79980 n1_M2_45420_79980 0.988200
R8922 n1_M2_45420_79980 n1_M2_46500_79980 0.988200
R8923 n1_M2_46500_79980 n1_M2_47580_79980 0.988200
R8924 n1_M2_47580_79980 n1_M2_48660_79980 0.988200
R8925 n1_M2_48660_79980 n1_M2_49740_79980 0.988200
R8926 n1_M2_49740_79980 n1_M2_50820_79980 0.988200
R8927 n1_M2_50820_79980 n1_M2_51900_79980 0.988200
R8928 n1_M2_51900_79980 n1_M2_52980_79980 0.988200
R8929 n1_M2_52980_79980 n1_M2_54060_79980 0.988200
R8930 n1_M2_54060_79980 n1_M2_55140_79980 0.988200
R8931 n1_M2_55140_79980 n1_M2_56220_79980 0.988200
R8932 n1_M2_56220_79980 n1_M2_57300_79980 0.988200
R8933 n1_M2_57300_79980 n1_M2_58380_79980 0.988200
R8934 n1_M2_58380_79980 n1_M2_59460_79980 0.988200
R8935 n1_M2_59460_79980 n1_M2_60540_79980 0.988200
R8936 n1_M2_60540_79980 n1_M2_61620_79980 0.988200
R8937 n1_M2_61620_79980 n1_M2_62700_79980 0.988200
R8938 n1_M2_62700_79980 n1_M2_63780_79980 0.988200
R8939 n1_M2_63780_79980 n1_M2_64860_79980 0.988200
R8940 n1_M2_64860_79980 n1_M2_65940_79980 0.988200
R8941 n1_M2_65940_79980 n1_M2_67020_79980 0.988200
R8942 n1_M2_67020_79980 n1_M2_68100_79980 0.988200
R8943 n1_M2_68100_79980 n1_M2_69180_79980 0.988200
R8944 n1_M2_69180_79980 n1_M2_70260_79980 0.988200
R8945 n1_M2_70260_79980 n1_M2_71340_79980 0.988200
R8946 n1_M2_71340_79980 n1_M2_72420_79980 0.988200
R8947 n1_M2_72420_79980 n1_M2_73500_79980 0.988200
R8948 n1_M2_73500_79980 n1_M2_74580_79980 0.988200
R8949 n1_M2_74580_79980 n1_M2_75660_79980 0.988200
R8950 n1_M2_75660_79980 n1_M2_76740_79980 0.988200
R8951 n1_M2_76740_79980 n1_M2_77820_79980 0.988200
R8952 n1_M2_77820_79980 n1_M2_78900_79980 0.988200
R8953 n1_M2_78900_79980 n1_M2_79980_79980 0.988200
R8954 n1_M2_79980_79980 n1_M2_81060_79980 0.988200
R8955 n1_M2_81060_79980 n1_M2_82140_79980 0.988200
R8956 n1_M2_82140_79980 n1_M2_83220_79980 0.988200
R8957 n1_M2_83220_79980 n1_M2_84300_79980 0.988200
R8958 n1_M2_84300_79980 n1_M2_85380_79980 0.988200
R8959 n1_M2_85380_79980 n1_M2_86460_79980 0.988200
R8960 n1_M2_86460_79980 n1_M2_87540_79980 0.988200
R8961 n1_M2_87540_79980 n1_M2_88620_79980 0.988200
R8962 n1_M2_88620_79980 n1_M2_89700_79980 0.988200
R8963 n1_M2_89700_79980 n1_M2_90780_79980 0.988200
R8964 n1_M2_90780_79980 n1_M2_91860_79980 0.988200
R8965 n1_M2_91860_79980 n1_M2_92940_79980 0.988200
R8966 n1_M2_92940_79980 n1_M2_94020_79980 0.988200
R8967 n1_M2_94020_79980 n1_M2_95100_79980 0.988200
R8968 n1_M2_95100_79980 n1_M2_96180_79980 0.988200
R8969 n1_M2_96180_79980 n1_M2_97260_79980 0.988200
R8970 n1_M2_97260_79980 n1_M2_98340_79980 0.988200
R8971 n1_M2_98340_79980 n1_M2_99420_79980 0.988200
R8972 n1_M2_99420_79980 n1_M2_100500_79980 0.988200
R8973 n1_M2_100500_79980 n1_M2_101580_79980 0.988200
R8974 n1_M2_101580_79980 n1_M2_102660_79980 0.988200
R8975 n1_M2_102660_79980 n1_M2_103740_79980 0.988200
R8976 n1_M2_103740_79980 n1_M2_104820_79980 0.988200
R8977 n1_M2_104820_79980 n1_M2_105900_79980 0.988200
R8978 n1_M2_105900_79980 n1_M2_106980_79980 0.988200
R8979 n1_M2_106980_79980 n1_M2_108060_79980 0.988200
R8980 n1_M2_108060_79980 n1_M2_109140_79980 0.988200
R8981 n1_M2_109140_79980 n1_M2_110220_79980 0.988200
R8982 n1_M2_110220_79980 n1_M2_111300_79980 0.988200
R8983 n1_M2_111300_79980 n1_M2_112380_79980 0.988200
R8984 n1_M2_112380_79980 n1_M2_113460_79980 0.988200
R8985 n1_M2_113460_79980 n1_M2_114540_79980 0.988200
R8986 n1_M2_114540_79980 n1_M2_115620_79980 0.988200
R8987 n1_M2_115620_79980 n1_M2_116700_79980 0.988200
R8988 n1_M2_116700_79980 n1_M2_117780_79980 0.988200
R8989 n1_M2_117780_79980 n1_M2_118860_79980 0.988200
R8990 n1_M2_118860_79980 n1_M2_119940_79980 0.988200
R8991 n1_M2_119940_79980 n1_M2_121020_79980 0.988200
R8992 n1_M2_121020_79980 n1_M2_122100_79980 0.988200
R8993 n1_M2_122100_79980 n1_M2_123180_79980 0.988200
R8994 n1_M2_123180_79980 n1_M2_124260_79980 0.988200
R8995 n1_M2_124260_79980 n1_M2_125340_79980 0.988200
R8996 n1_M2_125340_79980 n1_M2_126420_79980 0.988200
R8997 n1_M2_126420_79980 n1_M2_127500_79980 0.988200
R8998 n1_M2_127500_79980 n1_M2_128580_79980 0.988200
R8999 n1_M2_128580_79980 n1_M2_129660_79980 0.988200
R9000 n1_M2_60_81060 n1_M2_1140_81060 0.988200
R9001 n1_M2_1140_81060 n1_M2_2220_81060 0.988200
R9002 n1_M2_2220_81060 n1_M2_3300_81060 0.988200
R9003 n1_M2_3300_81060 n1_M2_4380_81060 0.988200
R9004 n1_M2_4380_81060 n1_M2_5460_81060 0.988200
R9005 n1_M2_5460_81060 n1_M2_6540_81060 0.988200
R9006 n1_M2_6540_81060 n1_M2_7620_81060 0.988200
R9007 n1_M2_7620_81060 n1_M2_8700_81060 0.988200
R9008 n1_M2_8700_81060 n1_M2_9780_81060 0.988200
R9009 n1_M2_9780_81060 n1_M2_10860_81060 0.988200
R9010 n1_M2_10860_81060 n1_M2_11940_81060 0.988200
R9011 n1_M2_11940_81060 n1_M2_13020_81060 0.988200
R9012 n1_M2_13020_81060 n1_M2_14100_81060 0.988200
R9013 n1_M2_14100_81060 n1_M2_15180_81060 0.988200
R9014 n1_M2_15180_81060 n1_M2_16260_81060 0.988200
R9015 n1_M2_16260_81060 n1_M2_17340_81060 0.988200
R9016 n1_M2_17340_81060 n1_M2_18420_81060 0.988200
R9017 n1_M2_18420_81060 n1_M2_19500_81060 0.988200
R9018 n1_M2_19500_81060 n1_M2_20580_81060 0.988200
R9019 n1_M2_20580_81060 n1_M2_21660_81060 0.988200
R9020 n1_M2_21660_81060 n1_M2_22740_81060 0.988200
R9021 n1_M2_22740_81060 n1_M2_23820_81060 0.988200
R9022 n1_M2_23820_81060 n1_M2_24900_81060 0.988200
R9023 n1_M2_24900_81060 n1_M2_25980_81060 0.988200
R9024 n1_M2_25980_81060 n1_M2_27060_81060 0.988200
R9025 n1_M2_27060_81060 n1_M2_28140_81060 0.988200
R9026 n1_M2_28140_81060 n1_M2_29220_81060 0.988200
R9027 n1_M2_29220_81060 n1_M2_30300_81060 0.988200
R9028 n1_M2_30300_81060 n1_M2_31380_81060 0.988200
R9029 n1_M2_31380_81060 n1_M2_32460_81060 0.988200
R9030 n1_M2_32460_81060 n1_M2_33540_81060 0.988200
R9031 n1_M2_33540_81060 n1_M2_34620_81060 0.988200
R9032 n1_M2_34620_81060 n1_M2_35700_81060 0.988200
R9033 n1_M2_35700_81060 n1_M2_36780_81060 0.988200
R9034 n1_M2_36780_81060 n1_M2_37860_81060 0.988200
R9035 n1_M2_37860_81060 n1_M2_38940_81060 0.988200
R9036 n1_M2_38940_81060 n1_M2_40020_81060 0.988200
R9037 n1_M2_40020_81060 n1_M2_41100_81060 0.988200
R9038 n1_M2_41100_81060 n1_M2_42180_81060 0.988200
R9039 n1_M2_42180_81060 n1_M2_43260_81060 0.988200
R9040 n1_M2_43260_81060 n1_M2_44340_81060 0.988200
R9041 n1_M2_44340_81060 n1_M2_45420_81060 0.988200
R9042 n1_M2_45420_81060 n1_M2_46500_81060 0.988200
R9043 n1_M2_46500_81060 n1_M2_47580_81060 0.988200
R9044 n1_M2_47580_81060 n1_M2_48660_81060 0.988200
R9045 n1_M2_48660_81060 n1_M2_49740_81060 0.988200
R9046 n1_M2_49740_81060 n1_M2_50820_81060 0.988200
R9047 n1_M2_50820_81060 n1_M2_51900_81060 0.988200
R9048 n1_M2_51900_81060 n1_M2_52980_81060 0.988200
R9049 n1_M2_52980_81060 n1_M2_54060_81060 0.988200
R9050 n1_M2_54060_81060 n1_M2_55140_81060 0.988200
R9051 n1_M2_55140_81060 n1_M2_56220_81060 0.988200
R9052 n1_M2_56220_81060 n1_M2_57300_81060 0.988200
R9053 n1_M2_57300_81060 n1_M2_58380_81060 0.988200
R9054 n1_M2_58380_81060 n1_M2_59460_81060 0.988200
R9055 n1_M2_59460_81060 n1_M2_60540_81060 0.988200
R9056 n1_M2_60540_81060 n1_M2_61620_81060 0.988200
R9057 n1_M2_61620_81060 n1_M2_62700_81060 0.988200
R9058 n1_M2_62700_81060 n1_M2_63780_81060 0.988200
R9059 n1_M2_63780_81060 n1_M2_64860_81060 0.988200
R9060 n1_M2_64860_81060 n1_M2_65940_81060 0.988200
R9061 n1_M2_65940_81060 n1_M2_67020_81060 0.988200
R9062 n1_M2_67020_81060 n1_M2_68100_81060 0.988200
R9063 n1_M2_68100_81060 n1_M2_69180_81060 0.988200
R9064 n1_M2_69180_81060 n1_M2_70260_81060 0.988200
R9065 n1_M2_70260_81060 n1_M2_71340_81060 0.988200
R9066 n1_M2_71340_81060 n1_M2_72420_81060 0.988200
R9067 n1_M2_72420_81060 n1_M2_73500_81060 0.988200
R9068 n1_M2_73500_81060 n1_M2_74580_81060 0.988200
R9069 n1_M2_74580_81060 n1_M2_75660_81060 0.988200
R9070 n1_M2_75660_81060 n1_M2_76740_81060 0.988200
R9071 n1_M2_76740_81060 n1_M2_77820_81060 0.988200
R9072 n1_M2_77820_81060 n1_M2_78900_81060 0.988200
R9073 n1_M2_78900_81060 n1_M2_79980_81060 0.988200
R9074 n1_M2_79980_81060 n1_M2_81060_81060 0.988200
R9075 n1_M2_81060_81060 n1_M2_82140_81060 0.988200
R9076 n1_M2_82140_81060 n1_M2_83220_81060 0.988200
R9077 n1_M2_83220_81060 n1_M2_84300_81060 0.988200
R9078 n1_M2_84300_81060 n1_M2_85380_81060 0.988200
R9079 n1_M2_85380_81060 n1_M2_86460_81060 0.988200
R9080 n1_M2_86460_81060 n1_M2_87540_81060 0.988200
R9081 n1_M2_87540_81060 n1_M2_88620_81060 0.988200
R9082 n1_M2_88620_81060 n1_M2_89700_81060 0.988200
R9083 n1_M2_89700_81060 n1_M2_90780_81060 0.988200
R9084 n1_M2_90780_81060 n1_M2_91860_81060 0.988200
R9085 n1_M2_91860_81060 n1_M2_92940_81060 0.988200
R9086 n1_M2_92940_81060 n1_M2_94020_81060 0.988200
R9087 n1_M2_94020_81060 n1_M2_95100_81060 0.988200
R9088 n1_M2_95100_81060 n1_M2_96180_81060 0.988200
R9089 n1_M2_96180_81060 n1_M2_97260_81060 0.988200
R9090 n1_M2_97260_81060 n1_M2_98340_81060 0.988200
R9091 n1_M2_98340_81060 n1_M2_99420_81060 0.988200
R9092 n1_M2_99420_81060 n1_M2_100500_81060 0.988200
R9093 n1_M2_100500_81060 n1_M2_101580_81060 0.988200
R9094 n1_M2_101580_81060 n1_M2_102660_81060 0.988200
R9095 n1_M2_102660_81060 n1_M2_103740_81060 0.988200
R9096 n1_M2_103740_81060 n1_M2_104820_81060 0.988200
R9097 n1_M2_104820_81060 n1_M2_105900_81060 0.988200
R9098 n1_M2_105900_81060 n1_M2_106980_81060 0.988200
R9099 n1_M2_106980_81060 n1_M2_108060_81060 0.988200
R9100 n1_M2_108060_81060 n1_M2_109140_81060 0.988200
R9101 n1_M2_109140_81060 n1_M2_110220_81060 0.988200
R9102 n1_M2_110220_81060 n1_M2_111300_81060 0.988200
R9103 n1_M2_111300_81060 n1_M2_112380_81060 0.988200
R9104 n1_M2_112380_81060 n1_M2_113460_81060 0.988200
R9105 n1_M2_113460_81060 n1_M2_114540_81060 0.988200
R9106 n1_M2_114540_81060 n1_M2_115620_81060 0.988200
R9107 n1_M2_115620_81060 n1_M2_116700_81060 0.988200
R9108 n1_M2_116700_81060 n1_M2_117780_81060 0.988200
R9109 n1_M2_117780_81060 n1_M2_118860_81060 0.988200
R9110 n1_M2_118860_81060 n1_M2_119940_81060 0.988200
R9111 n1_M2_119940_81060 n1_M2_121020_81060 0.988200
R9112 n1_M2_121020_81060 n1_M2_122100_81060 0.988200
R9113 n1_M2_122100_81060 n1_M2_123180_81060 0.988200
R9114 n1_M2_123180_81060 n1_M2_124260_81060 0.988200
R9115 n1_M2_124260_81060 n1_M2_125340_81060 0.988200
R9116 n1_M2_125340_81060 n1_M2_126420_81060 0.988200
R9117 n1_M2_126420_81060 n1_M2_127500_81060 0.988200
R9118 n1_M2_127500_81060 n1_M2_128580_81060 0.988200
R9119 n1_M2_128580_81060 n1_M2_129660_81060 0.988200
R9120 n1_M2_60_82140 n1_M2_1140_82140 0.988200
R9121 n1_M2_1140_82140 n1_M2_2220_82140 0.988200
R9122 n1_M2_2220_82140 n1_M2_3300_82140 0.988200
R9123 n1_M2_3300_82140 n1_M2_4380_82140 0.988200
R9124 n1_M2_4380_82140 n1_M2_5460_82140 0.988200
R9125 n1_M2_5460_82140 n1_M2_6540_82140 0.988200
R9126 n1_M2_6540_82140 n1_M2_7620_82140 0.988200
R9127 n1_M2_7620_82140 n1_M2_8700_82140 0.988200
R9128 n1_M2_8700_82140 n1_M2_9780_82140 0.988200
R9129 n1_M2_9780_82140 n1_M2_10860_82140 0.988200
R9130 n1_M2_10860_82140 n1_M2_11940_82140 0.988200
R9131 n1_M2_11940_82140 n1_M2_13020_82140 0.988200
R9132 n1_M2_13020_82140 n1_M2_14100_82140 0.988200
R9133 n1_M2_14100_82140 n1_M2_15180_82140 0.988200
R9134 n1_M2_15180_82140 n1_M2_16260_82140 0.988200
R9135 n1_M2_16260_82140 n1_M2_17340_82140 0.988200
R9136 n1_M2_17340_82140 n1_M2_18420_82140 0.988200
R9137 n1_M2_18420_82140 n1_M2_19500_82140 0.988200
R9138 n1_M2_19500_82140 n1_M2_20580_82140 0.988200
R9139 n1_M2_20580_82140 n1_M2_21660_82140 0.988200
R9140 n1_M2_21660_82140 n1_M2_22740_82140 0.988200
R9141 n1_M2_22740_82140 n1_M2_23820_82140 0.988200
R9142 n1_M2_23820_82140 n1_M2_24900_82140 0.988200
R9143 n1_M2_24900_82140 n1_M2_25980_82140 0.988200
R9144 n1_M2_25980_82140 n1_M2_27060_82140 0.988200
R9145 n1_M2_27060_82140 n1_M2_28140_82140 0.988200
R9146 n1_M2_28140_82140 n1_M2_29220_82140 0.988200
R9147 n1_M2_29220_82140 n1_M2_30300_82140 0.988200
R9148 n1_M2_30300_82140 n1_M2_31380_82140 0.988200
R9149 n1_M2_31380_82140 n1_M2_32460_82140 0.988200
R9150 n1_M2_32460_82140 n1_M2_33540_82140 0.988200
R9151 n1_M2_33540_82140 n1_M2_34620_82140 0.988200
R9152 n1_M2_34620_82140 n1_M2_35700_82140 0.988200
R9153 n1_M2_35700_82140 n1_M2_36780_82140 0.988200
R9154 n1_M2_36780_82140 n1_M2_37860_82140 0.988200
R9155 n1_M2_37860_82140 n1_M2_38940_82140 0.988200
R9156 n1_M2_38940_82140 n1_M2_40020_82140 0.988200
R9157 n1_M2_40020_82140 n1_M2_41100_82140 0.988200
R9158 n1_M2_41100_82140 n1_M2_42180_82140 0.988200
R9159 n1_M2_42180_82140 n1_M2_43260_82140 0.988200
R9160 n1_M2_43260_82140 n1_M2_44340_82140 0.988200
R9161 n1_M2_44340_82140 n1_M2_45420_82140 0.988200
R9162 n1_M2_45420_82140 n1_M2_46500_82140 0.988200
R9163 n1_M2_46500_82140 n1_M2_47580_82140 0.988200
R9164 n1_M2_47580_82140 n1_M2_48660_82140 0.988200
R9165 n1_M2_48660_82140 n1_M2_49740_82140 0.988200
R9166 n1_M2_49740_82140 n1_M2_50820_82140 0.988200
R9167 n1_M2_50820_82140 n1_M2_51900_82140 0.988200
R9168 n1_M2_51900_82140 n1_M2_52980_82140 0.988200
R9169 n1_M2_52980_82140 n1_M2_54060_82140 0.988200
R9170 n1_M2_54060_82140 n1_M2_55140_82140 0.988200
R9171 n1_M2_55140_82140 n1_M2_56220_82140 0.988200
R9172 n1_M2_56220_82140 n1_M2_57300_82140 0.988200
R9173 n1_M2_57300_82140 n1_M2_58380_82140 0.988200
R9174 n1_M2_58380_82140 n1_M2_59460_82140 0.988200
R9175 n1_M2_59460_82140 n1_M2_60540_82140 0.988200
R9176 n1_M2_60540_82140 n1_M2_61620_82140 0.988200
R9177 n1_M2_61620_82140 n1_M2_62700_82140 0.988200
R9178 n1_M2_62700_82140 n1_M2_63780_82140 0.988200
R9179 n1_M2_63780_82140 n1_M2_64860_82140 0.988200
R9180 n1_M2_64860_82140 n1_M2_65940_82140 0.988200
R9181 n1_M2_65940_82140 n1_M2_67020_82140 0.988200
R9182 n1_M2_67020_82140 n1_M2_68100_82140 0.988200
R9183 n1_M2_68100_82140 n1_M2_69180_82140 0.988200
R9184 n1_M2_69180_82140 n1_M2_70260_82140 0.988200
R9185 n1_M2_70260_82140 n1_M2_71340_82140 0.988200
R9186 n1_M2_71340_82140 n1_M2_72420_82140 0.988200
R9187 n1_M2_72420_82140 n1_M2_73500_82140 0.988200
R9188 n1_M2_73500_82140 n1_M2_74580_82140 0.988200
R9189 n1_M2_74580_82140 n1_M2_75660_82140 0.988200
R9190 n1_M2_75660_82140 n1_M2_76740_82140 0.988200
R9191 n1_M2_76740_82140 n1_M2_77820_82140 0.988200
R9192 n1_M2_77820_82140 n1_M2_78900_82140 0.988200
R9193 n1_M2_78900_82140 n1_M2_79980_82140 0.988200
R9194 n1_M2_79980_82140 n1_M2_81060_82140 0.988200
R9195 n1_M2_81060_82140 n1_M2_82140_82140 0.988200
R9196 n1_M2_82140_82140 n1_M2_83220_82140 0.988200
R9197 n1_M2_83220_82140 n1_M2_84300_82140 0.988200
R9198 n1_M2_84300_82140 n1_M2_85380_82140 0.988200
R9199 n1_M2_85380_82140 n1_M2_86460_82140 0.988200
R9200 n1_M2_86460_82140 n1_M2_87540_82140 0.988200
R9201 n1_M2_87540_82140 n1_M2_88620_82140 0.988200
R9202 n1_M2_88620_82140 n1_M2_89700_82140 0.988200
R9203 n1_M2_89700_82140 n1_M2_90780_82140 0.988200
R9204 n1_M2_90780_82140 n1_M2_91860_82140 0.988200
R9205 n1_M2_91860_82140 n1_M2_92940_82140 0.988200
R9206 n1_M2_92940_82140 n1_M2_94020_82140 0.988200
R9207 n1_M2_94020_82140 n1_M2_95100_82140 0.988200
R9208 n1_M2_95100_82140 n1_M2_96180_82140 0.988200
R9209 n1_M2_96180_82140 n1_M2_97260_82140 0.988200
R9210 n1_M2_97260_82140 n1_M2_98340_82140 0.988200
R9211 n1_M2_98340_82140 n1_M2_99420_82140 0.988200
R9212 n1_M2_99420_82140 n1_M2_100500_82140 0.988200
R9213 n1_M2_100500_82140 n1_M2_101580_82140 0.988200
R9214 n1_M2_101580_82140 n1_M2_102660_82140 0.988200
R9215 n1_M2_102660_82140 n1_M2_103740_82140 0.988200
R9216 n1_M2_103740_82140 n1_M2_104820_82140 0.988200
R9217 n1_M2_104820_82140 n1_M2_105900_82140 0.988200
R9218 n1_M2_105900_82140 n1_M2_106980_82140 0.988200
R9219 n1_M2_106980_82140 n1_M2_108060_82140 0.988200
R9220 n1_M2_108060_82140 n1_M2_109140_82140 0.988200
R9221 n1_M2_109140_82140 n1_M2_110220_82140 0.988200
R9222 n1_M2_110220_82140 n1_M2_111300_82140 0.988200
R9223 n1_M2_111300_82140 n1_M2_112380_82140 0.988200
R9224 n1_M2_112380_82140 n1_M2_113460_82140 0.988200
R9225 n1_M2_113460_82140 n1_M2_114540_82140 0.988200
R9226 n1_M2_114540_82140 n1_M2_115620_82140 0.988200
R9227 n1_M2_115620_82140 n1_M2_116700_82140 0.988200
R9228 n1_M2_116700_82140 n1_M2_117780_82140 0.988200
R9229 n1_M2_117780_82140 n1_M2_118860_82140 0.988200
R9230 n1_M2_118860_82140 n1_M2_119940_82140 0.988200
R9231 n1_M2_119940_82140 n1_M2_121020_82140 0.988200
R9232 n1_M2_121020_82140 n1_M2_122100_82140 0.988200
R9233 n1_M2_122100_82140 n1_M2_123180_82140 0.988200
R9234 n1_M2_123180_82140 n1_M2_124260_82140 0.988200
R9235 n1_M2_124260_82140 n1_M2_125340_82140 0.988200
R9236 n1_M2_125340_82140 n1_M2_126420_82140 0.988200
R9237 n1_M2_126420_82140 n1_M2_127500_82140 0.988200
R9238 n1_M2_127500_82140 n1_M2_128580_82140 0.988200
R9239 n1_M2_128580_82140 n1_M2_129660_82140 0.988200
R9240 n1_M2_60_83220 n1_M2_1140_83220 0.988200
R9241 n1_M2_1140_83220 n1_M2_2220_83220 0.988200
R9242 n1_M2_2220_83220 n1_M2_3300_83220 0.988200
R9243 n1_M2_3300_83220 n1_M2_4380_83220 0.988200
R9244 n1_M2_4380_83220 n1_M2_5460_83220 0.988200
R9245 n1_M2_5460_83220 n1_M2_6540_83220 0.988200
R9246 n1_M2_6540_83220 n1_M2_7620_83220 0.988200
R9247 n1_M2_7620_83220 n1_M2_8700_83220 0.988200
R9248 n1_M2_8700_83220 n1_M2_9780_83220 0.988200
R9249 n1_M2_9780_83220 n1_M2_10860_83220 0.988200
R9250 n1_M2_10860_83220 n1_M2_11940_83220 0.988200
R9251 n1_M2_11940_83220 n1_M2_13020_83220 0.988200
R9252 n1_M2_13020_83220 n1_M2_14100_83220 0.988200
R9253 n1_M2_14100_83220 n1_M2_15180_83220 0.988200
R9254 n1_M2_15180_83220 n1_M2_16260_83220 0.988200
R9255 n1_M2_16260_83220 n1_M2_17340_83220 0.988200
R9256 n1_M2_17340_83220 n1_M2_18420_83220 0.988200
R9257 n1_M2_18420_83220 n1_M2_19500_83220 0.988200
R9258 n1_M2_19500_83220 n1_M2_20580_83220 0.988200
R9259 n1_M2_20580_83220 n1_M2_21660_83220 0.988200
R9260 n1_M2_21660_83220 n1_M2_22740_83220 0.988200
R9261 n1_M2_22740_83220 n1_M2_23820_83220 0.988200
R9262 n1_M2_23820_83220 n1_M2_24900_83220 0.988200
R9263 n1_M2_24900_83220 n1_M2_25980_83220 0.988200
R9264 n1_M2_25980_83220 n1_M2_27060_83220 0.988200
R9265 n1_M2_27060_83220 n1_M2_28140_83220 0.988200
R9266 n1_M2_28140_83220 n1_M2_29220_83220 0.988200
R9267 n1_M2_29220_83220 n1_M2_30300_83220 0.988200
R9268 n1_M2_30300_83220 n1_M2_31380_83220 0.988200
R9269 n1_M2_31380_83220 n1_M2_32460_83220 0.988200
R9270 n1_M2_32460_83220 n1_M2_33540_83220 0.988200
R9271 n1_M2_33540_83220 n1_M2_34620_83220 0.988200
R9272 n1_M2_34620_83220 n1_M2_35700_83220 0.988200
R9273 n1_M2_35700_83220 n1_M2_36780_83220 0.988200
R9274 n1_M2_36780_83220 n1_M2_37860_83220 0.988200
R9275 n1_M2_37860_83220 n1_M2_38940_83220 0.988200
R9276 n1_M2_38940_83220 n1_M2_40020_83220 0.988200
R9277 n1_M2_40020_83220 n1_M2_41100_83220 0.988200
R9278 n1_M2_41100_83220 n1_M2_42180_83220 0.988200
R9279 n1_M2_42180_83220 n1_M2_43260_83220 0.988200
R9280 n1_M2_43260_83220 n1_M2_44340_83220 0.988200
R9281 n1_M2_44340_83220 n1_M2_45420_83220 0.988200
R9282 n1_M2_45420_83220 n1_M2_46500_83220 0.988200
R9283 n1_M2_46500_83220 n1_M2_47580_83220 0.988200
R9284 n1_M2_47580_83220 n1_M2_48660_83220 0.988200
R9285 n1_M2_48660_83220 n1_M2_49740_83220 0.988200
R9286 n1_M2_49740_83220 n1_M2_50820_83220 0.988200
R9287 n1_M2_50820_83220 n1_M2_51900_83220 0.988200
R9288 n1_M2_51900_83220 n1_M2_52980_83220 0.988200
R9289 n1_M2_52980_83220 n1_M2_54060_83220 0.988200
R9290 n1_M2_54060_83220 n1_M2_55140_83220 0.988200
R9291 n1_M2_55140_83220 n1_M2_56220_83220 0.988200
R9292 n1_M2_56220_83220 n1_M2_57300_83220 0.988200
R9293 n1_M2_57300_83220 n1_M2_58380_83220 0.988200
R9294 n1_M2_58380_83220 n1_M2_59460_83220 0.988200
R9295 n1_M2_59460_83220 n1_M2_60540_83220 0.988200
R9296 n1_M2_60540_83220 n1_M2_61620_83220 0.988200
R9297 n1_M2_61620_83220 n1_M2_62700_83220 0.988200
R9298 n1_M2_62700_83220 n1_M2_63780_83220 0.988200
R9299 n1_M2_63780_83220 n1_M2_64860_83220 0.988200
R9300 n1_M2_64860_83220 n1_M2_65940_83220 0.988200
R9301 n1_M2_65940_83220 n1_M2_67020_83220 0.988200
R9302 n1_M2_67020_83220 n1_M2_68100_83220 0.988200
R9303 n1_M2_68100_83220 n1_M2_69180_83220 0.988200
R9304 n1_M2_69180_83220 n1_M2_70260_83220 0.988200
R9305 n1_M2_70260_83220 n1_M2_71340_83220 0.988200
R9306 n1_M2_71340_83220 n1_M2_72420_83220 0.988200
R9307 n1_M2_72420_83220 n1_M2_73500_83220 0.988200
R9308 n1_M2_73500_83220 n1_M2_74580_83220 0.988200
R9309 n1_M2_74580_83220 n1_M2_75660_83220 0.988200
R9310 n1_M2_75660_83220 n1_M2_76740_83220 0.988200
R9311 n1_M2_76740_83220 n1_M2_77820_83220 0.988200
R9312 n1_M2_77820_83220 n1_M2_78900_83220 0.988200
R9313 n1_M2_78900_83220 n1_M2_79980_83220 0.988200
R9314 n1_M2_79980_83220 n1_M2_81060_83220 0.988200
R9315 n1_M2_81060_83220 n1_M2_82140_83220 0.988200
R9316 n1_M2_82140_83220 n1_M2_83220_83220 0.988200
R9317 n1_M2_83220_83220 n1_M2_84300_83220 0.988200
R9318 n1_M2_84300_83220 n1_M2_85380_83220 0.988200
R9319 n1_M2_85380_83220 n1_M2_86460_83220 0.988200
R9320 n1_M2_86460_83220 n1_M2_87540_83220 0.988200
R9321 n1_M2_87540_83220 n1_M2_88620_83220 0.988200
R9322 n1_M2_88620_83220 n1_M2_89700_83220 0.988200
R9323 n1_M2_89700_83220 n1_M2_90780_83220 0.988200
R9324 n1_M2_90780_83220 n1_M2_91860_83220 0.988200
R9325 n1_M2_91860_83220 n1_M2_92940_83220 0.988200
R9326 n1_M2_92940_83220 n1_M2_94020_83220 0.988200
R9327 n1_M2_94020_83220 n1_M2_95100_83220 0.988200
R9328 n1_M2_95100_83220 n1_M2_96180_83220 0.988200
R9329 n1_M2_96180_83220 n1_M2_97260_83220 0.988200
R9330 n1_M2_97260_83220 n1_M2_98340_83220 0.988200
R9331 n1_M2_98340_83220 n1_M2_99420_83220 0.988200
R9332 n1_M2_99420_83220 n1_M2_100500_83220 0.988200
R9333 n1_M2_100500_83220 n1_M2_101580_83220 0.988200
R9334 n1_M2_101580_83220 n1_M2_102660_83220 0.988200
R9335 n1_M2_102660_83220 n1_M2_103740_83220 0.988200
R9336 n1_M2_103740_83220 n1_M2_104820_83220 0.988200
R9337 n1_M2_104820_83220 n1_M2_105900_83220 0.988200
R9338 n1_M2_105900_83220 n1_M2_106980_83220 0.988200
R9339 n1_M2_106980_83220 n1_M2_108060_83220 0.988200
R9340 n1_M2_108060_83220 n1_M2_109140_83220 0.988200
R9341 n1_M2_109140_83220 n1_M2_110220_83220 0.988200
R9342 n1_M2_110220_83220 n1_M2_111300_83220 0.988200
R9343 n1_M2_111300_83220 n1_M2_112380_83220 0.988200
R9344 n1_M2_112380_83220 n1_M2_113460_83220 0.988200
R9345 n1_M2_113460_83220 n1_M2_114540_83220 0.988200
R9346 n1_M2_114540_83220 n1_M2_115620_83220 0.988200
R9347 n1_M2_115620_83220 n1_M2_116700_83220 0.988200
R9348 n1_M2_116700_83220 n1_M2_117780_83220 0.988200
R9349 n1_M2_117780_83220 n1_M2_118860_83220 0.988200
R9350 n1_M2_118860_83220 n1_M2_119940_83220 0.988200
R9351 n1_M2_119940_83220 n1_M2_121020_83220 0.988200
R9352 n1_M2_121020_83220 n1_M2_122100_83220 0.988200
R9353 n1_M2_122100_83220 n1_M2_123180_83220 0.988200
R9354 n1_M2_123180_83220 n1_M2_124260_83220 0.988200
R9355 n1_M2_124260_83220 n1_M2_125340_83220 0.988200
R9356 n1_M2_125340_83220 n1_M2_126420_83220 0.988200
R9357 n1_M2_126420_83220 n1_M2_127500_83220 0.988200
R9358 n1_M2_127500_83220 n1_M2_128580_83220 0.988200
R9359 n1_M2_128580_83220 n1_M2_129660_83220 0.988200
R9360 n1_M2_60_84300 n1_M2_1140_84300 0.988200
R9361 n1_M2_1140_84300 n1_M2_2220_84300 0.988200
R9362 n1_M2_2220_84300 n1_M2_3300_84300 0.988200
R9363 n1_M2_3300_84300 n1_M2_4380_84300 0.988200
R9364 n1_M2_4380_84300 n1_M2_5460_84300 0.988200
R9365 n1_M2_5460_84300 n1_M2_6540_84300 0.988200
R9366 n1_M2_6540_84300 n1_M2_7620_84300 0.988200
R9367 n1_M2_7620_84300 n1_M2_8700_84300 0.988200
R9368 n1_M2_8700_84300 n1_M2_9780_84300 0.988200
R9369 n1_M2_9780_84300 n1_M2_10860_84300 0.988200
R9370 n1_M2_10860_84300 n1_M2_11940_84300 0.988200
R9371 n1_M2_11940_84300 n1_M2_13020_84300 0.988200
R9372 n1_M2_13020_84300 n1_M2_14100_84300 0.988200
R9373 n1_M2_14100_84300 n1_M2_15180_84300 0.988200
R9374 n1_M2_15180_84300 n1_M2_16260_84300 0.988200
R9375 n1_M2_16260_84300 n1_M2_17340_84300 0.988200
R9376 n1_M2_17340_84300 n1_M2_18420_84300 0.988200
R9377 n1_M2_18420_84300 n1_M2_19500_84300 0.988200
R9378 n1_M2_19500_84300 n1_M2_20580_84300 0.988200
R9379 n1_M2_20580_84300 n1_M2_21660_84300 0.988200
R9380 n1_M2_21660_84300 n1_M2_22740_84300 0.988200
R9381 n1_M2_22740_84300 n1_M2_23820_84300 0.988200
R9382 n1_M2_23820_84300 n1_M2_24900_84300 0.988200
R9383 n1_M2_24900_84300 n1_M2_25980_84300 0.988200
R9384 n1_M2_25980_84300 n1_M2_27060_84300 0.988200
R9385 n1_M2_27060_84300 n1_M2_28140_84300 0.988200
R9386 n1_M2_28140_84300 n1_M2_29220_84300 0.988200
R9387 n1_M2_29220_84300 n1_M2_30300_84300 0.988200
R9388 n1_M2_30300_84300 n1_M2_31380_84300 0.988200
R9389 n1_M2_31380_84300 n1_M2_32460_84300 0.988200
R9390 n1_M2_32460_84300 n1_M2_33540_84300 0.988200
R9391 n1_M2_33540_84300 n1_M2_34620_84300 0.988200
R9392 n1_M2_34620_84300 n1_M2_35700_84300 0.988200
R9393 n1_M2_35700_84300 n1_M2_36780_84300 0.988200
R9394 n1_M2_36780_84300 n1_M2_37860_84300 0.988200
R9395 n1_M2_37860_84300 n1_M2_38940_84300 0.988200
R9396 n1_M2_38940_84300 n1_M2_40020_84300 0.988200
R9397 n1_M2_40020_84300 n1_M2_41100_84300 0.988200
R9398 n1_M2_41100_84300 n1_M2_42180_84300 0.988200
R9399 n1_M2_42180_84300 n1_M2_43260_84300 0.988200
R9400 n1_M2_43260_84300 n1_M2_44340_84300 0.988200
R9401 n1_M2_44340_84300 n1_M2_45420_84300 0.988200
R9402 n1_M2_45420_84300 n1_M2_46500_84300 0.988200
R9403 n1_M2_46500_84300 n1_M2_47580_84300 0.988200
R9404 n1_M2_47580_84300 n1_M2_48660_84300 0.988200
R9405 n1_M2_48660_84300 n1_M2_49740_84300 0.988200
R9406 n1_M2_49740_84300 n1_M2_50820_84300 0.988200
R9407 n1_M2_50820_84300 n1_M2_51900_84300 0.988200
R9408 n1_M2_51900_84300 n1_M2_52980_84300 0.988200
R9409 n1_M2_52980_84300 n1_M2_54060_84300 0.988200
R9410 n1_M2_54060_84300 n1_M2_55140_84300 0.988200
R9411 n1_M2_55140_84300 n1_M2_56220_84300 0.988200
R9412 n1_M2_56220_84300 n1_M2_57300_84300 0.988200
R9413 n1_M2_57300_84300 n1_M2_58380_84300 0.988200
R9414 n1_M2_58380_84300 n1_M2_59460_84300 0.988200
R9415 n1_M2_59460_84300 n1_M2_60540_84300 0.988200
R9416 n1_M2_60540_84300 n1_M2_61620_84300 0.988200
R9417 n1_M2_61620_84300 n1_M2_62700_84300 0.988200
R9418 n1_M2_62700_84300 n1_M2_63780_84300 0.988200
R9419 n1_M2_63780_84300 n1_M2_64860_84300 0.988200
R9420 n1_M2_64860_84300 n1_M2_65940_84300 0.988200
R9421 n1_M2_65940_84300 n1_M2_67020_84300 0.988200
R9422 n1_M2_67020_84300 n1_M2_68100_84300 0.988200
R9423 n1_M2_68100_84300 n1_M2_69180_84300 0.988200
R9424 n1_M2_69180_84300 n1_M2_70260_84300 0.988200
R9425 n1_M2_70260_84300 n1_M2_71340_84300 0.988200
R9426 n1_M2_71340_84300 n1_M2_72420_84300 0.988200
R9427 n1_M2_72420_84300 n1_M2_73500_84300 0.988200
R9428 n1_M2_73500_84300 n1_M2_74580_84300 0.988200
R9429 n1_M2_74580_84300 n1_M2_75660_84300 0.988200
R9430 n1_M2_75660_84300 n1_M2_76740_84300 0.988200
R9431 n1_M2_76740_84300 n1_M2_77820_84300 0.988200
R9432 n1_M2_77820_84300 n1_M2_78900_84300 0.988200
R9433 n1_M2_78900_84300 n1_M2_79980_84300 0.988200
R9434 n1_M2_79980_84300 n1_M2_81060_84300 0.988200
R9435 n1_M2_81060_84300 n1_M2_82140_84300 0.988200
R9436 n1_M2_82140_84300 n1_M2_83220_84300 0.988200
R9437 n1_M2_83220_84300 n1_M2_84300_84300 0.988200
R9438 n1_M2_84300_84300 n1_M2_85380_84300 0.988200
R9439 n1_M2_85380_84300 n1_M2_86460_84300 0.988200
R9440 n1_M2_86460_84300 n1_M2_87540_84300 0.988200
R9441 n1_M2_87540_84300 n1_M2_88620_84300 0.988200
R9442 n1_M2_88620_84300 n1_M2_89700_84300 0.988200
R9443 n1_M2_89700_84300 n1_M2_90780_84300 0.988200
R9444 n1_M2_90780_84300 n1_M2_91860_84300 0.988200
R9445 n1_M2_91860_84300 n1_M2_92940_84300 0.988200
R9446 n1_M2_92940_84300 n1_M2_94020_84300 0.988200
R9447 n1_M2_94020_84300 n1_M2_95100_84300 0.988200
R9448 n1_M2_95100_84300 n1_M2_96180_84300 0.988200
R9449 n1_M2_96180_84300 n1_M2_97260_84300 0.988200
R9450 n1_M2_97260_84300 n1_M2_98340_84300 0.988200
R9451 n1_M2_98340_84300 n1_M2_99420_84300 0.988200
R9452 n1_M2_99420_84300 n1_M2_100500_84300 0.988200
R9453 n1_M2_100500_84300 n1_M2_101580_84300 0.988200
R9454 n1_M2_101580_84300 n1_M2_102660_84300 0.988200
R9455 n1_M2_102660_84300 n1_M2_103740_84300 0.988200
R9456 n1_M2_103740_84300 n1_M2_104820_84300 0.988200
R9457 n1_M2_104820_84300 n1_M2_105900_84300 0.988200
R9458 n1_M2_105900_84300 n1_M2_106980_84300 0.988200
R9459 n1_M2_106980_84300 n1_M2_108060_84300 0.988200
R9460 n1_M2_108060_84300 n1_M2_109140_84300 0.988200
R9461 n1_M2_109140_84300 n1_M2_110220_84300 0.988200
R9462 n1_M2_110220_84300 n1_M2_111300_84300 0.988200
R9463 n1_M2_111300_84300 n1_M2_112380_84300 0.988200
R9464 n1_M2_112380_84300 n1_M2_113460_84300 0.988200
R9465 n1_M2_113460_84300 n1_M2_114540_84300 0.988200
R9466 n1_M2_114540_84300 n1_M2_115620_84300 0.988200
R9467 n1_M2_115620_84300 n1_M2_116700_84300 0.988200
R9468 n1_M2_116700_84300 n1_M2_117780_84300 0.988200
R9469 n1_M2_117780_84300 n1_M2_118860_84300 0.988200
R9470 n1_M2_118860_84300 n1_M2_119940_84300 0.988200
R9471 n1_M2_119940_84300 n1_M2_121020_84300 0.988200
R9472 n1_M2_121020_84300 n1_M2_122100_84300 0.988200
R9473 n1_M2_122100_84300 n1_M2_123180_84300 0.988200
R9474 n1_M2_123180_84300 n1_M2_124260_84300 0.988200
R9475 n1_M2_124260_84300 n1_M2_125340_84300 0.988200
R9476 n1_M2_125340_84300 n1_M2_126420_84300 0.988200
R9477 n1_M2_126420_84300 n1_M2_127500_84300 0.988200
R9478 n1_M2_127500_84300 n1_M2_128580_84300 0.988200
R9479 n1_M2_128580_84300 n1_M2_129660_84300 0.988200
R9480 n1_M2_60_85380 n1_M2_1140_85380 0.988200
R9481 n1_M2_1140_85380 n1_M2_2220_85380 0.988200
R9482 n1_M2_2220_85380 n1_M2_3300_85380 0.988200
R9483 n1_M2_3300_85380 n1_M2_4380_85380 0.988200
R9484 n1_M2_4380_85380 n1_M2_5460_85380 0.988200
R9485 n1_M2_5460_85380 n1_M2_6540_85380 0.988200
R9486 n1_M2_6540_85380 n1_M2_7620_85380 0.988200
R9487 n1_M2_7620_85380 n1_M2_8700_85380 0.988200
R9488 n1_M2_8700_85380 n1_M2_9780_85380 0.988200
R9489 n1_M2_9780_85380 n1_M2_10860_85380 0.988200
R9490 n1_M2_10860_85380 n1_M2_11940_85380 0.988200
R9491 n1_M2_11940_85380 n1_M2_13020_85380 0.988200
R9492 n1_M2_13020_85380 n1_M2_14100_85380 0.988200
R9493 n1_M2_14100_85380 n1_M2_15180_85380 0.988200
R9494 n1_M2_15180_85380 n1_M2_16260_85380 0.988200
R9495 n1_M2_16260_85380 n1_M2_17340_85380 0.988200
R9496 n1_M2_17340_85380 n1_M2_18420_85380 0.988200
R9497 n1_M2_18420_85380 n1_M2_19500_85380 0.988200
R9498 n1_M2_19500_85380 n1_M2_20580_85380 0.988200
R9499 n1_M2_20580_85380 n1_M2_21660_85380 0.988200
R9500 n1_M2_21660_85380 n1_M2_22740_85380 0.988200
R9501 n1_M2_22740_85380 n1_M2_23820_85380 0.988200
R9502 n1_M2_23820_85380 n1_M2_24900_85380 0.988200
R9503 n1_M2_24900_85380 n1_M2_25980_85380 0.988200
R9504 n1_M2_25980_85380 n1_M2_27060_85380 0.988200
R9505 n1_M2_27060_85380 n1_M2_28140_85380 0.988200
R9506 n1_M2_28140_85380 n1_M2_29220_85380 0.988200
R9507 n1_M2_29220_85380 n1_M2_30300_85380 0.988200
R9508 n1_M2_30300_85380 n1_M2_31380_85380 0.988200
R9509 n1_M2_31380_85380 n1_M2_32460_85380 0.988200
R9510 n1_M2_32460_85380 n1_M2_33540_85380 0.988200
R9511 n1_M2_33540_85380 n1_M2_34620_85380 0.988200
R9512 n1_M2_34620_85380 n1_M2_35700_85380 0.988200
R9513 n1_M2_35700_85380 n1_M2_36780_85380 0.988200
R9514 n1_M2_36780_85380 n1_M2_37860_85380 0.988200
R9515 n1_M2_37860_85380 n1_M2_38940_85380 0.988200
R9516 n1_M2_38940_85380 n1_M2_40020_85380 0.988200
R9517 n1_M2_40020_85380 n1_M2_41100_85380 0.988200
R9518 n1_M2_41100_85380 n1_M2_42180_85380 0.988200
R9519 n1_M2_42180_85380 n1_M2_43260_85380 0.988200
R9520 n1_M2_43260_85380 n1_M2_44340_85380 0.988200
R9521 n1_M2_44340_85380 n1_M2_45420_85380 0.988200
R9522 n1_M2_45420_85380 n1_M2_46500_85380 0.988200
R9523 n1_M2_46500_85380 n1_M2_47580_85380 0.988200
R9524 n1_M2_47580_85380 n1_M2_48660_85380 0.988200
R9525 n1_M2_48660_85380 n1_M2_49740_85380 0.988200
R9526 n1_M2_49740_85380 n1_M2_50820_85380 0.988200
R9527 n1_M2_50820_85380 n1_M2_51900_85380 0.988200
R9528 n1_M2_51900_85380 n1_M2_52980_85380 0.988200
R9529 n1_M2_52980_85380 n1_M2_54060_85380 0.988200
R9530 n1_M2_54060_85380 n1_M2_55140_85380 0.988200
R9531 n1_M2_55140_85380 n1_M2_56220_85380 0.988200
R9532 n1_M2_56220_85380 n1_M2_57300_85380 0.988200
R9533 n1_M2_57300_85380 n1_M2_58380_85380 0.988200
R9534 n1_M2_58380_85380 n1_M2_59460_85380 0.988200
R9535 n1_M2_59460_85380 n1_M2_60540_85380 0.988200
R9536 n1_M2_60540_85380 n1_M2_61620_85380 0.988200
R9537 n1_M2_61620_85380 n1_M2_62700_85380 0.988200
R9538 n1_M2_62700_85380 n1_M2_63780_85380 0.988200
R9539 n1_M2_63780_85380 n1_M2_64860_85380 0.988200
R9540 n1_M2_64860_85380 n1_M2_65940_85380 0.988200
R9541 n1_M2_65940_85380 n1_M2_67020_85380 0.988200
R9542 n1_M2_67020_85380 n1_M2_68100_85380 0.988200
R9543 n1_M2_68100_85380 n1_M2_69180_85380 0.988200
R9544 n1_M2_69180_85380 n1_M2_70260_85380 0.988200
R9545 n1_M2_70260_85380 n1_M2_71340_85380 0.988200
R9546 n1_M2_71340_85380 n1_M2_72420_85380 0.988200
R9547 n1_M2_72420_85380 n1_M2_73500_85380 0.988200
R9548 n1_M2_73500_85380 n1_M2_74580_85380 0.988200
R9549 n1_M2_74580_85380 n1_M2_75660_85380 0.988200
R9550 n1_M2_75660_85380 n1_M2_76740_85380 0.988200
R9551 n1_M2_76740_85380 n1_M2_77820_85380 0.988200
R9552 n1_M2_77820_85380 n1_M2_78900_85380 0.988200
R9553 n1_M2_78900_85380 n1_M2_79980_85380 0.988200
R9554 n1_M2_79980_85380 n1_M2_81060_85380 0.988200
R9555 n1_M2_81060_85380 n1_M2_82140_85380 0.988200
R9556 n1_M2_82140_85380 n1_M2_83220_85380 0.988200
R9557 n1_M2_83220_85380 n1_M2_84300_85380 0.988200
R9558 n1_M2_84300_85380 n1_M2_85380_85380 0.988200
R9559 n1_M2_85380_85380 n1_M2_86460_85380 0.988200
R9560 n1_M2_86460_85380 n1_M2_87540_85380 0.988200
R9561 n1_M2_87540_85380 n1_M2_88620_85380 0.988200
R9562 n1_M2_88620_85380 n1_M2_89700_85380 0.988200
R9563 n1_M2_89700_85380 n1_M2_90780_85380 0.988200
R9564 n1_M2_90780_85380 n1_M2_91860_85380 0.988200
R9565 n1_M2_91860_85380 n1_M2_92940_85380 0.988200
R9566 n1_M2_92940_85380 n1_M2_94020_85380 0.988200
R9567 n1_M2_94020_85380 n1_M2_95100_85380 0.988200
R9568 n1_M2_95100_85380 n1_M2_96180_85380 0.988200
R9569 n1_M2_96180_85380 n1_M2_97260_85380 0.988200
R9570 n1_M2_97260_85380 n1_M2_98340_85380 0.988200
R9571 n1_M2_98340_85380 n1_M2_99420_85380 0.988200
R9572 n1_M2_99420_85380 n1_M2_100500_85380 0.988200
R9573 n1_M2_100500_85380 n1_M2_101580_85380 0.988200
R9574 n1_M2_101580_85380 n1_M2_102660_85380 0.988200
R9575 n1_M2_102660_85380 n1_M2_103740_85380 0.988200
R9576 n1_M2_103740_85380 n1_M2_104820_85380 0.988200
R9577 n1_M2_104820_85380 n1_M2_105900_85380 0.988200
R9578 n1_M2_105900_85380 n1_M2_106980_85380 0.988200
R9579 n1_M2_106980_85380 n1_M2_108060_85380 0.988200
R9580 n1_M2_108060_85380 n1_M2_109140_85380 0.988200
R9581 n1_M2_109140_85380 n1_M2_110220_85380 0.988200
R9582 n1_M2_110220_85380 n1_M2_111300_85380 0.988200
R9583 n1_M2_111300_85380 n1_M2_112380_85380 0.988200
R9584 n1_M2_112380_85380 n1_M2_113460_85380 0.988200
R9585 n1_M2_113460_85380 n1_M2_114540_85380 0.988200
R9586 n1_M2_114540_85380 n1_M2_115620_85380 0.988200
R9587 n1_M2_115620_85380 n1_M2_116700_85380 0.988200
R9588 n1_M2_116700_85380 n1_M2_117780_85380 0.988200
R9589 n1_M2_117780_85380 n1_M2_118860_85380 0.988200
R9590 n1_M2_118860_85380 n1_M2_119940_85380 0.988200
R9591 n1_M2_119940_85380 n1_M2_121020_85380 0.988200
R9592 n1_M2_121020_85380 n1_M2_122100_85380 0.988200
R9593 n1_M2_122100_85380 n1_M2_123180_85380 0.988200
R9594 n1_M2_123180_85380 n1_M2_124260_85380 0.988200
R9595 n1_M2_124260_85380 n1_M2_125340_85380 0.988200
R9596 n1_M2_125340_85380 n1_M2_126420_85380 0.988200
R9597 n1_M2_126420_85380 n1_M2_127500_85380 0.988200
R9598 n1_M2_127500_85380 n1_M2_128580_85380 0.988200
R9599 n1_M2_128580_85380 n1_M2_129660_85380 0.988200
R9600 n1_M2_60_86460 n1_M2_1140_86460 0.988200
R9601 n1_M2_1140_86460 n1_M2_2220_86460 0.988200
R9602 n1_M2_2220_86460 n1_M2_3300_86460 0.988200
R9603 n1_M2_3300_86460 n1_M2_4380_86460 0.988200
R9604 n1_M2_4380_86460 n1_M2_5460_86460 0.988200
R9605 n1_M2_5460_86460 n1_M2_6540_86460 0.988200
R9606 n1_M2_6540_86460 n1_M2_7620_86460 0.988200
R9607 n1_M2_7620_86460 n1_M2_8700_86460 0.988200
R9608 n1_M2_8700_86460 n1_M2_9780_86460 0.988200
R9609 n1_M2_9780_86460 n1_M2_10860_86460 0.988200
R9610 n1_M2_10860_86460 n1_M2_11940_86460 0.988200
R9611 n1_M2_11940_86460 n1_M2_13020_86460 0.988200
R9612 n1_M2_13020_86460 n1_M2_14100_86460 0.988200
R9613 n1_M2_14100_86460 n1_M2_15180_86460 0.988200
R9614 n1_M2_15180_86460 n1_M2_16260_86460 0.988200
R9615 n1_M2_16260_86460 n1_M2_17340_86460 0.988200
R9616 n1_M2_17340_86460 n1_M2_18420_86460 0.988200
R9617 n1_M2_18420_86460 n1_M2_19500_86460 0.988200
R9618 n1_M2_19500_86460 n1_M2_20580_86460 0.988200
R9619 n1_M2_20580_86460 n1_M2_21660_86460 0.988200
R9620 n1_M2_21660_86460 n1_M2_22740_86460 0.988200
R9621 n1_M2_22740_86460 n1_M2_23820_86460 0.988200
R9622 n1_M2_23820_86460 n1_M2_24900_86460 0.988200
R9623 n1_M2_24900_86460 n1_M2_25980_86460 0.988200
R9624 n1_M2_25980_86460 n1_M2_27060_86460 0.988200
R9625 n1_M2_27060_86460 n1_M2_28140_86460 0.988200
R9626 n1_M2_28140_86460 n1_M2_29220_86460 0.988200
R9627 n1_M2_29220_86460 n1_M2_30300_86460 0.988200
R9628 n1_M2_30300_86460 n1_M2_31380_86460 0.988200
R9629 n1_M2_31380_86460 n1_M2_32460_86460 0.988200
R9630 n1_M2_32460_86460 n1_M2_33540_86460 0.988200
R9631 n1_M2_33540_86460 n1_M2_34620_86460 0.988200
R9632 n1_M2_34620_86460 n1_M2_35700_86460 0.988200
R9633 n1_M2_35700_86460 n1_M2_36780_86460 0.988200
R9634 n1_M2_36780_86460 n1_M2_37860_86460 0.988200
R9635 n1_M2_37860_86460 n1_M2_38940_86460 0.988200
R9636 n1_M2_38940_86460 n1_M2_40020_86460 0.988200
R9637 n1_M2_40020_86460 n1_M2_41100_86460 0.988200
R9638 n1_M2_41100_86460 n1_M2_42180_86460 0.988200
R9639 n1_M2_42180_86460 n1_M2_43260_86460 0.988200
R9640 n1_M2_43260_86460 n1_M2_44340_86460 0.988200
R9641 n1_M2_44340_86460 n1_M2_45420_86460 0.988200
R9642 n1_M2_45420_86460 n1_M2_46500_86460 0.988200
R9643 n1_M2_46500_86460 n1_M2_47580_86460 0.988200
R9644 n1_M2_47580_86460 n1_M2_48660_86460 0.988200
R9645 n1_M2_48660_86460 n1_M2_49740_86460 0.988200
R9646 n1_M2_49740_86460 n1_M2_50820_86460 0.988200
R9647 n1_M2_50820_86460 n1_M2_51900_86460 0.988200
R9648 n1_M2_51900_86460 n1_M2_52980_86460 0.988200
R9649 n1_M2_52980_86460 n1_M2_54060_86460 0.988200
R9650 n1_M2_54060_86460 n1_M2_55140_86460 0.988200
R9651 n1_M2_55140_86460 n1_M2_56220_86460 0.988200
R9652 n1_M2_56220_86460 n1_M2_57300_86460 0.988200
R9653 n1_M2_57300_86460 n1_M2_58380_86460 0.988200
R9654 n1_M2_58380_86460 n1_M2_59460_86460 0.988200
R9655 n1_M2_59460_86460 n1_M2_60540_86460 0.988200
R9656 n1_M2_60540_86460 n1_M2_61620_86460 0.988200
R9657 n1_M2_61620_86460 n1_M2_62700_86460 0.988200
R9658 n1_M2_62700_86460 n1_M2_63780_86460 0.988200
R9659 n1_M2_63780_86460 n1_M2_64860_86460 0.988200
R9660 n1_M2_64860_86460 n1_M2_65940_86460 0.988200
R9661 n1_M2_65940_86460 n1_M2_67020_86460 0.988200
R9662 n1_M2_67020_86460 n1_M2_68100_86460 0.988200
R9663 n1_M2_68100_86460 n1_M2_69180_86460 0.988200
R9664 n1_M2_69180_86460 n1_M2_70260_86460 0.988200
R9665 n1_M2_70260_86460 n1_M2_71340_86460 0.988200
R9666 n1_M2_71340_86460 n1_M2_72420_86460 0.988200
R9667 n1_M2_72420_86460 n1_M2_73500_86460 0.988200
R9668 n1_M2_73500_86460 n1_M2_74580_86460 0.988200
R9669 n1_M2_74580_86460 n1_M2_75660_86460 0.988200
R9670 n1_M2_75660_86460 n1_M2_76740_86460 0.988200
R9671 n1_M2_76740_86460 n1_M2_77820_86460 0.988200
R9672 n1_M2_77820_86460 n1_M2_78900_86460 0.988200
R9673 n1_M2_78900_86460 n1_M2_79980_86460 0.988200
R9674 n1_M2_79980_86460 n1_M2_81060_86460 0.988200
R9675 n1_M2_81060_86460 n1_M2_82140_86460 0.988200
R9676 n1_M2_82140_86460 n1_M2_83220_86460 0.988200
R9677 n1_M2_83220_86460 n1_M2_84300_86460 0.988200
R9678 n1_M2_84300_86460 n1_M2_85380_86460 0.988200
R9679 n1_M2_85380_86460 n1_M2_86460_86460 0.988200
R9680 n1_M2_86460_86460 n1_M2_87540_86460 0.988200
R9681 n1_M2_87540_86460 n1_M2_88620_86460 0.988200
R9682 n1_M2_88620_86460 n1_M2_89700_86460 0.988200
R9683 n1_M2_89700_86460 n1_M2_90780_86460 0.988200
R9684 n1_M2_90780_86460 n1_M2_91860_86460 0.988200
R9685 n1_M2_91860_86460 n1_M2_92940_86460 0.988200
R9686 n1_M2_92940_86460 n1_M2_94020_86460 0.988200
R9687 n1_M2_94020_86460 n1_M2_95100_86460 0.988200
R9688 n1_M2_95100_86460 n1_M2_96180_86460 0.988200
R9689 n1_M2_96180_86460 n1_M2_97260_86460 0.988200
R9690 n1_M2_97260_86460 n1_M2_98340_86460 0.988200
R9691 n1_M2_98340_86460 n1_M2_99420_86460 0.988200
R9692 n1_M2_99420_86460 n1_M2_100500_86460 0.988200
R9693 n1_M2_100500_86460 n1_M2_101580_86460 0.988200
R9694 n1_M2_101580_86460 n1_M2_102660_86460 0.988200
R9695 n1_M2_102660_86460 n1_M2_103740_86460 0.988200
R9696 n1_M2_103740_86460 n1_M2_104820_86460 0.988200
R9697 n1_M2_104820_86460 n1_M2_105900_86460 0.988200
R9698 n1_M2_105900_86460 n1_M2_106980_86460 0.988200
R9699 n1_M2_106980_86460 n1_M2_108060_86460 0.988200
R9700 n1_M2_108060_86460 n1_M2_109140_86460 0.988200
R9701 n1_M2_109140_86460 n1_M2_110220_86460 0.988200
R9702 n1_M2_110220_86460 n1_M2_111300_86460 0.988200
R9703 n1_M2_111300_86460 n1_M2_112380_86460 0.988200
R9704 n1_M2_112380_86460 n1_M2_113460_86460 0.988200
R9705 n1_M2_113460_86460 n1_M2_114540_86460 0.988200
R9706 n1_M2_114540_86460 n1_M2_115620_86460 0.988200
R9707 n1_M2_115620_86460 n1_M2_116700_86460 0.988200
R9708 n1_M2_116700_86460 n1_M2_117780_86460 0.988200
R9709 n1_M2_117780_86460 n1_M2_118860_86460 0.988200
R9710 n1_M2_118860_86460 n1_M2_119940_86460 0.988200
R9711 n1_M2_119940_86460 n1_M2_121020_86460 0.988200
R9712 n1_M2_121020_86460 n1_M2_122100_86460 0.988200
R9713 n1_M2_122100_86460 n1_M2_123180_86460 0.988200
R9714 n1_M2_123180_86460 n1_M2_124260_86460 0.988200
R9715 n1_M2_124260_86460 n1_M2_125340_86460 0.988200
R9716 n1_M2_125340_86460 n1_M2_126420_86460 0.988200
R9717 n1_M2_126420_86460 n1_M2_127500_86460 0.988200
R9718 n1_M2_127500_86460 n1_M2_128580_86460 0.988200
R9719 n1_M2_128580_86460 n1_M2_129660_86460 0.988200
R9720 n1_M2_60_87540 n1_M2_1140_87540 0.988200
R9721 n1_M2_1140_87540 n1_M2_2220_87540 0.988200
R9722 n1_M2_2220_87540 n1_M2_3300_87540 0.988200
R9723 n1_M2_3300_87540 n1_M2_4380_87540 0.988200
R9724 n1_M2_4380_87540 n1_M2_5460_87540 0.988200
R9725 n1_M2_5460_87540 n1_M2_6540_87540 0.988200
R9726 n1_M2_6540_87540 n1_M2_7620_87540 0.988200
R9727 n1_M2_7620_87540 n1_M2_8700_87540 0.988200
R9728 n1_M2_8700_87540 n1_M2_9780_87540 0.988200
R9729 n1_M2_9780_87540 n1_M2_10860_87540 0.988200
R9730 n1_M2_10860_87540 n1_M2_11940_87540 0.988200
R9731 n1_M2_11940_87540 n1_M2_13020_87540 0.988200
R9732 n1_M2_13020_87540 n1_M2_14100_87540 0.988200
R9733 n1_M2_14100_87540 n1_M2_15180_87540 0.988200
R9734 n1_M2_15180_87540 n1_M2_16260_87540 0.988200
R9735 n1_M2_16260_87540 n1_M2_17340_87540 0.988200
R9736 n1_M2_17340_87540 n1_M2_18420_87540 0.988200
R9737 n1_M2_18420_87540 n1_M2_19500_87540 0.988200
R9738 n1_M2_19500_87540 n1_M2_20580_87540 0.988200
R9739 n1_M2_20580_87540 n1_M2_21660_87540 0.988200
R9740 n1_M2_21660_87540 n1_M2_22740_87540 0.988200
R9741 n1_M2_22740_87540 n1_M2_23820_87540 0.988200
R9742 n1_M2_23820_87540 n1_M2_24900_87540 0.988200
R9743 n1_M2_24900_87540 n1_M2_25980_87540 0.988200
R9744 n1_M2_25980_87540 n1_M2_27060_87540 0.988200
R9745 n1_M2_27060_87540 n1_M2_28140_87540 0.988200
R9746 n1_M2_28140_87540 n1_M2_29220_87540 0.988200
R9747 n1_M2_29220_87540 n1_M2_30300_87540 0.988200
R9748 n1_M2_30300_87540 n1_M2_31380_87540 0.988200
R9749 n1_M2_31380_87540 n1_M2_32460_87540 0.988200
R9750 n1_M2_32460_87540 n1_M2_33540_87540 0.988200
R9751 n1_M2_33540_87540 n1_M2_34620_87540 0.988200
R9752 n1_M2_34620_87540 n1_M2_35700_87540 0.988200
R9753 n1_M2_35700_87540 n1_M2_36780_87540 0.988200
R9754 n1_M2_36780_87540 n1_M2_37860_87540 0.988200
R9755 n1_M2_37860_87540 n1_M2_38940_87540 0.988200
R9756 n1_M2_38940_87540 n1_M2_40020_87540 0.988200
R9757 n1_M2_40020_87540 n1_M2_41100_87540 0.988200
R9758 n1_M2_41100_87540 n1_M2_42180_87540 0.988200
R9759 n1_M2_42180_87540 n1_M2_43260_87540 0.988200
R9760 n1_M2_43260_87540 n1_M2_44340_87540 0.988200
R9761 n1_M2_44340_87540 n1_M2_45420_87540 0.988200
R9762 n1_M2_45420_87540 n1_M2_46500_87540 0.988200
R9763 n1_M2_46500_87540 n1_M2_47580_87540 0.988200
R9764 n1_M2_47580_87540 n1_M2_48660_87540 0.988200
R9765 n1_M2_48660_87540 n1_M2_49740_87540 0.988200
R9766 n1_M2_49740_87540 n1_M2_50820_87540 0.988200
R9767 n1_M2_50820_87540 n1_M2_51900_87540 0.988200
R9768 n1_M2_51900_87540 n1_M2_52980_87540 0.988200
R9769 n1_M2_52980_87540 n1_M2_54060_87540 0.988200
R9770 n1_M2_54060_87540 n1_M2_55140_87540 0.988200
R9771 n1_M2_55140_87540 n1_M2_56220_87540 0.988200
R9772 n1_M2_56220_87540 n1_M2_57300_87540 0.988200
R9773 n1_M2_57300_87540 n1_M2_58380_87540 0.988200
R9774 n1_M2_58380_87540 n1_M2_59460_87540 0.988200
R9775 n1_M2_59460_87540 n1_M2_60540_87540 0.988200
R9776 n1_M2_60540_87540 n1_M2_61620_87540 0.988200
R9777 n1_M2_61620_87540 n1_M2_62700_87540 0.988200
R9778 n1_M2_62700_87540 n1_M2_63780_87540 0.988200
R9779 n1_M2_63780_87540 n1_M2_64860_87540 0.988200
R9780 n1_M2_64860_87540 n1_M2_65940_87540 0.988200
R9781 n1_M2_65940_87540 n1_M2_67020_87540 0.988200
R9782 n1_M2_67020_87540 n1_M2_68100_87540 0.988200
R9783 n1_M2_68100_87540 n1_M2_69180_87540 0.988200
R9784 n1_M2_69180_87540 n1_M2_70260_87540 0.988200
R9785 n1_M2_70260_87540 n1_M2_71340_87540 0.988200
R9786 n1_M2_71340_87540 n1_M2_72420_87540 0.988200
R9787 n1_M2_72420_87540 n1_M2_73500_87540 0.988200
R9788 n1_M2_73500_87540 n1_M2_74580_87540 0.988200
R9789 n1_M2_74580_87540 n1_M2_75660_87540 0.988200
R9790 n1_M2_75660_87540 n1_M2_76740_87540 0.988200
R9791 n1_M2_76740_87540 n1_M2_77820_87540 0.988200
R9792 n1_M2_77820_87540 n1_M2_78900_87540 0.988200
R9793 n1_M2_78900_87540 n1_M2_79980_87540 0.988200
R9794 n1_M2_79980_87540 n1_M2_81060_87540 0.988200
R9795 n1_M2_81060_87540 n1_M2_82140_87540 0.988200
R9796 n1_M2_82140_87540 n1_M2_83220_87540 0.988200
R9797 n1_M2_83220_87540 n1_M2_84300_87540 0.988200
R9798 n1_M2_84300_87540 n1_M2_85380_87540 0.988200
R9799 n1_M2_85380_87540 n1_M2_86460_87540 0.988200
R9800 n1_M2_86460_87540 n1_M2_87540_87540 0.988200
R9801 n1_M2_87540_87540 n1_M2_88620_87540 0.988200
R9802 n1_M2_88620_87540 n1_M2_89700_87540 0.988200
R9803 n1_M2_89700_87540 n1_M2_90780_87540 0.988200
R9804 n1_M2_90780_87540 n1_M2_91860_87540 0.988200
R9805 n1_M2_91860_87540 n1_M2_92940_87540 0.988200
R9806 n1_M2_92940_87540 n1_M2_94020_87540 0.988200
R9807 n1_M2_94020_87540 n1_M2_95100_87540 0.988200
R9808 n1_M2_95100_87540 n1_M2_96180_87540 0.988200
R9809 n1_M2_96180_87540 n1_M2_97260_87540 0.988200
R9810 n1_M2_97260_87540 n1_M2_98340_87540 0.988200
R9811 n1_M2_98340_87540 n1_M2_99420_87540 0.988200
R9812 n1_M2_99420_87540 n1_M2_100500_87540 0.988200
R9813 n1_M2_100500_87540 n1_M2_101580_87540 0.988200
R9814 n1_M2_101580_87540 n1_M2_102660_87540 0.988200
R9815 n1_M2_102660_87540 n1_M2_103740_87540 0.988200
R9816 n1_M2_103740_87540 n1_M2_104820_87540 0.988200
R9817 n1_M2_104820_87540 n1_M2_105900_87540 0.988200
R9818 n1_M2_105900_87540 n1_M2_106980_87540 0.988200
R9819 n1_M2_106980_87540 n1_M2_108060_87540 0.988200
R9820 n1_M2_108060_87540 n1_M2_109140_87540 0.988200
R9821 n1_M2_109140_87540 n1_M2_110220_87540 0.988200
R9822 n1_M2_110220_87540 n1_M2_111300_87540 0.988200
R9823 n1_M2_111300_87540 n1_M2_112380_87540 0.988200
R9824 n1_M2_112380_87540 n1_M2_113460_87540 0.988200
R9825 n1_M2_113460_87540 n1_M2_114540_87540 0.988200
R9826 n1_M2_114540_87540 n1_M2_115620_87540 0.988200
R9827 n1_M2_115620_87540 n1_M2_116700_87540 0.988200
R9828 n1_M2_116700_87540 n1_M2_117780_87540 0.988200
R9829 n1_M2_117780_87540 n1_M2_118860_87540 0.988200
R9830 n1_M2_118860_87540 n1_M2_119940_87540 0.988200
R9831 n1_M2_119940_87540 n1_M2_121020_87540 0.988200
R9832 n1_M2_121020_87540 n1_M2_122100_87540 0.988200
R9833 n1_M2_122100_87540 n1_M2_123180_87540 0.988200
R9834 n1_M2_123180_87540 n1_M2_124260_87540 0.988200
R9835 n1_M2_124260_87540 n1_M2_125340_87540 0.988200
R9836 n1_M2_125340_87540 n1_M2_126420_87540 0.988200
R9837 n1_M2_126420_87540 n1_M2_127500_87540 0.988200
R9838 n1_M2_127500_87540 n1_M2_128580_87540 0.988200
R9839 n1_M2_128580_87540 n1_M2_129660_87540 0.988200
R9840 n1_M2_60_88620 n1_M2_1140_88620 0.988200
R9841 n1_M2_1140_88620 n1_M2_2220_88620 0.988200
R9842 n1_M2_2220_88620 n1_M2_3300_88620 0.988200
R9843 n1_M2_3300_88620 n1_M2_4380_88620 0.988200
R9844 n1_M2_4380_88620 n1_M2_5460_88620 0.988200
R9845 n1_M2_5460_88620 n1_M2_6540_88620 0.988200
R9846 n1_M2_6540_88620 n1_M2_7620_88620 0.988200
R9847 n1_M2_7620_88620 n1_M2_8700_88620 0.988200
R9848 n1_M2_8700_88620 n1_M2_9780_88620 0.988200
R9849 n1_M2_9780_88620 n1_M2_10860_88620 0.988200
R9850 n1_M2_10860_88620 n1_M2_11940_88620 0.988200
R9851 n1_M2_11940_88620 n1_M2_13020_88620 0.988200
R9852 n1_M2_13020_88620 n1_M2_14100_88620 0.988200
R9853 n1_M2_14100_88620 n1_M2_15180_88620 0.988200
R9854 n1_M2_15180_88620 n1_M2_16260_88620 0.988200
R9855 n1_M2_16260_88620 n1_M2_17340_88620 0.988200
R9856 n1_M2_17340_88620 n1_M2_18420_88620 0.988200
R9857 n1_M2_18420_88620 n1_M2_19500_88620 0.988200
R9858 n1_M2_19500_88620 n1_M2_20580_88620 0.988200
R9859 n1_M2_20580_88620 n1_M2_21660_88620 0.988200
R9860 n1_M2_21660_88620 n1_M2_22740_88620 0.988200
R9861 n1_M2_22740_88620 n1_M2_23820_88620 0.988200
R9862 n1_M2_23820_88620 n1_M2_24900_88620 0.988200
R9863 n1_M2_24900_88620 n1_M2_25980_88620 0.988200
R9864 n1_M2_25980_88620 n1_M2_27060_88620 0.988200
R9865 n1_M2_27060_88620 n1_M2_28140_88620 0.988200
R9866 n1_M2_28140_88620 n1_M2_29220_88620 0.988200
R9867 n1_M2_29220_88620 n1_M2_30300_88620 0.988200
R9868 n1_M2_30300_88620 n1_M2_31380_88620 0.988200
R9869 n1_M2_31380_88620 n1_M2_32460_88620 0.988200
R9870 n1_M2_32460_88620 n1_M2_33540_88620 0.988200
R9871 n1_M2_33540_88620 n1_M2_34620_88620 0.988200
R9872 n1_M2_34620_88620 n1_M2_35700_88620 0.988200
R9873 n1_M2_35700_88620 n1_M2_36780_88620 0.988200
R9874 n1_M2_36780_88620 n1_M2_37860_88620 0.988200
R9875 n1_M2_37860_88620 n1_M2_38940_88620 0.988200
R9876 n1_M2_38940_88620 n1_M2_40020_88620 0.988200
R9877 n1_M2_40020_88620 n1_M2_41100_88620 0.988200
R9878 n1_M2_41100_88620 n1_M2_42180_88620 0.988200
R9879 n1_M2_42180_88620 n1_M2_43260_88620 0.988200
R9880 n1_M2_43260_88620 n1_M2_44340_88620 0.988200
R9881 n1_M2_44340_88620 n1_M2_45420_88620 0.988200
R9882 n1_M2_45420_88620 n1_M2_46500_88620 0.988200
R9883 n1_M2_46500_88620 n1_M2_47580_88620 0.988200
R9884 n1_M2_47580_88620 n1_M2_48660_88620 0.988200
R9885 n1_M2_48660_88620 n1_M2_49740_88620 0.988200
R9886 n1_M2_49740_88620 n1_M2_50820_88620 0.988200
R9887 n1_M2_50820_88620 n1_M2_51900_88620 0.988200
R9888 n1_M2_51900_88620 n1_M2_52980_88620 0.988200
R9889 n1_M2_52980_88620 n1_M2_54060_88620 0.988200
R9890 n1_M2_54060_88620 n1_M2_55140_88620 0.988200
R9891 n1_M2_55140_88620 n1_M2_56220_88620 0.988200
R9892 n1_M2_56220_88620 n1_M2_57300_88620 0.988200
R9893 n1_M2_57300_88620 n1_M2_58380_88620 0.988200
R9894 n1_M2_58380_88620 n1_M2_59460_88620 0.988200
R9895 n1_M2_59460_88620 n1_M2_60540_88620 0.988200
R9896 n1_M2_60540_88620 n1_M2_61620_88620 0.988200
R9897 n1_M2_61620_88620 n1_M2_62700_88620 0.988200
R9898 n1_M2_62700_88620 n1_M2_63780_88620 0.988200
R9899 n1_M2_63780_88620 n1_M2_64860_88620 0.988200
R9900 n1_M2_64860_88620 n1_M2_65940_88620 0.988200
R9901 n1_M2_65940_88620 n1_M2_67020_88620 0.988200
R9902 n1_M2_67020_88620 n1_M2_68100_88620 0.988200
R9903 n1_M2_68100_88620 n1_M2_69180_88620 0.988200
R9904 n1_M2_69180_88620 n1_M2_70260_88620 0.988200
R9905 n1_M2_70260_88620 n1_M2_71340_88620 0.988200
R9906 n1_M2_71340_88620 n1_M2_72420_88620 0.988200
R9907 n1_M2_72420_88620 n1_M2_73500_88620 0.988200
R9908 n1_M2_73500_88620 n1_M2_74580_88620 0.988200
R9909 n1_M2_74580_88620 n1_M2_75660_88620 0.988200
R9910 n1_M2_75660_88620 n1_M2_76740_88620 0.988200
R9911 n1_M2_76740_88620 n1_M2_77820_88620 0.988200
R9912 n1_M2_77820_88620 n1_M2_78900_88620 0.988200
R9913 n1_M2_78900_88620 n1_M2_79980_88620 0.988200
R9914 n1_M2_79980_88620 n1_M2_81060_88620 0.988200
R9915 n1_M2_81060_88620 n1_M2_82140_88620 0.988200
R9916 n1_M2_82140_88620 n1_M2_83220_88620 0.988200
R9917 n1_M2_83220_88620 n1_M2_84300_88620 0.988200
R9918 n1_M2_84300_88620 n1_M2_85380_88620 0.988200
R9919 n1_M2_85380_88620 n1_M2_86460_88620 0.988200
R9920 n1_M2_86460_88620 n1_M2_87540_88620 0.988200
R9921 n1_M2_87540_88620 n1_M2_88620_88620 0.988200
R9922 n1_M2_88620_88620 n1_M2_89700_88620 0.988200
R9923 n1_M2_89700_88620 n1_M2_90780_88620 0.988200
R9924 n1_M2_90780_88620 n1_M2_91860_88620 0.988200
R9925 n1_M2_91860_88620 n1_M2_92940_88620 0.988200
R9926 n1_M2_92940_88620 n1_M2_94020_88620 0.988200
R9927 n1_M2_94020_88620 n1_M2_95100_88620 0.988200
R9928 n1_M2_95100_88620 n1_M2_96180_88620 0.988200
R9929 n1_M2_96180_88620 n1_M2_97260_88620 0.988200
R9930 n1_M2_97260_88620 n1_M2_98340_88620 0.988200
R9931 n1_M2_98340_88620 n1_M2_99420_88620 0.988200
R9932 n1_M2_99420_88620 n1_M2_100500_88620 0.988200
R9933 n1_M2_100500_88620 n1_M2_101580_88620 0.988200
R9934 n1_M2_101580_88620 n1_M2_102660_88620 0.988200
R9935 n1_M2_102660_88620 n1_M2_103740_88620 0.988200
R9936 n1_M2_103740_88620 n1_M2_104820_88620 0.988200
R9937 n1_M2_104820_88620 n1_M2_105900_88620 0.988200
R9938 n1_M2_105900_88620 n1_M2_106980_88620 0.988200
R9939 n1_M2_106980_88620 n1_M2_108060_88620 0.988200
R9940 n1_M2_108060_88620 n1_M2_109140_88620 0.988200
R9941 n1_M2_109140_88620 n1_M2_110220_88620 0.988200
R9942 n1_M2_110220_88620 n1_M2_111300_88620 0.988200
R9943 n1_M2_111300_88620 n1_M2_112380_88620 0.988200
R9944 n1_M2_112380_88620 n1_M2_113460_88620 0.988200
R9945 n1_M2_113460_88620 n1_M2_114540_88620 0.988200
R9946 n1_M2_114540_88620 n1_M2_115620_88620 0.988200
R9947 n1_M2_115620_88620 n1_M2_116700_88620 0.988200
R9948 n1_M2_116700_88620 n1_M2_117780_88620 0.988200
R9949 n1_M2_117780_88620 n1_M2_118860_88620 0.988200
R9950 n1_M2_118860_88620 n1_M2_119940_88620 0.988200
R9951 n1_M2_119940_88620 n1_M2_121020_88620 0.988200
R9952 n1_M2_121020_88620 n1_M2_122100_88620 0.988200
R9953 n1_M2_122100_88620 n1_M2_123180_88620 0.988200
R9954 n1_M2_123180_88620 n1_M2_124260_88620 0.988200
R9955 n1_M2_124260_88620 n1_M2_125340_88620 0.988200
R9956 n1_M2_125340_88620 n1_M2_126420_88620 0.988200
R9957 n1_M2_126420_88620 n1_M2_127500_88620 0.988200
R9958 n1_M2_127500_88620 n1_M2_128580_88620 0.988200
R9959 n1_M2_128580_88620 n1_M2_129660_88620 0.988200
R9960 n1_M2_60_89700 n1_M2_1140_89700 0.988200
R9961 n1_M2_1140_89700 n1_M2_2220_89700 0.988200
R9962 n1_M2_2220_89700 n1_M2_3300_89700 0.988200
R9963 n1_M2_3300_89700 n1_M2_4380_89700 0.988200
R9964 n1_M2_4380_89700 n1_M2_5460_89700 0.988200
R9965 n1_M2_5460_89700 n1_M2_6540_89700 0.988200
R9966 n1_M2_6540_89700 n1_M2_7620_89700 0.988200
R9967 n1_M2_7620_89700 n1_M2_8700_89700 0.988200
R9968 n1_M2_8700_89700 n1_M2_9780_89700 0.988200
R9969 n1_M2_9780_89700 n1_M2_10860_89700 0.988200
R9970 n1_M2_10860_89700 n1_M2_11940_89700 0.988200
R9971 n1_M2_11940_89700 n1_M2_13020_89700 0.988200
R9972 n1_M2_13020_89700 n1_M2_14100_89700 0.988200
R9973 n1_M2_14100_89700 n1_M2_15180_89700 0.988200
R9974 n1_M2_15180_89700 n1_M2_16260_89700 0.988200
R9975 n1_M2_16260_89700 n1_M2_17340_89700 0.988200
R9976 n1_M2_17340_89700 n1_M2_18420_89700 0.988200
R9977 n1_M2_18420_89700 n1_M2_19500_89700 0.988200
R9978 n1_M2_19500_89700 n1_M2_20580_89700 0.988200
R9979 n1_M2_20580_89700 n1_M2_21660_89700 0.988200
R9980 n1_M2_21660_89700 n1_M2_22740_89700 0.988200
R9981 n1_M2_22740_89700 n1_M2_23820_89700 0.988200
R9982 n1_M2_23820_89700 n1_M2_24900_89700 0.988200
R9983 n1_M2_24900_89700 n1_M2_25980_89700 0.988200
R9984 n1_M2_25980_89700 n1_M2_27060_89700 0.988200
R9985 n1_M2_27060_89700 n1_M2_28140_89700 0.988200
R9986 n1_M2_28140_89700 n1_M2_29220_89700 0.988200
R9987 n1_M2_29220_89700 n1_M2_30300_89700 0.988200
R9988 n1_M2_30300_89700 n1_M2_31380_89700 0.988200
R9989 n1_M2_31380_89700 n1_M2_32460_89700 0.988200
R9990 n1_M2_32460_89700 n1_M2_33540_89700 0.988200
R9991 n1_M2_33540_89700 n1_M2_34620_89700 0.988200
R9992 n1_M2_34620_89700 n1_M2_35700_89700 0.988200
R9993 n1_M2_35700_89700 n1_M2_36780_89700 0.988200
R9994 n1_M2_36780_89700 n1_M2_37860_89700 0.988200
R9995 n1_M2_37860_89700 n1_M2_38940_89700 0.988200
R9996 n1_M2_38940_89700 n1_M2_40020_89700 0.988200
R9997 n1_M2_40020_89700 n1_M2_41100_89700 0.988200
R9998 n1_M2_41100_89700 n1_M2_42180_89700 0.988200
R9999 n1_M2_42180_89700 n1_M2_43260_89700 0.988200
R10000 n1_M2_43260_89700 n1_M2_44340_89700 0.988200
R10001 n1_M2_44340_89700 n1_M2_45420_89700 0.988200
R10002 n1_M2_45420_89700 n1_M2_46500_89700 0.988200
R10003 n1_M2_46500_89700 n1_M2_47580_89700 0.988200
R10004 n1_M2_47580_89700 n1_M2_48660_89700 0.988200
R10005 n1_M2_48660_89700 n1_M2_49740_89700 0.988200
R10006 n1_M2_49740_89700 n1_M2_50820_89700 0.988200
R10007 n1_M2_50820_89700 n1_M2_51900_89700 0.988200
R10008 n1_M2_51900_89700 n1_M2_52980_89700 0.988200
R10009 n1_M2_52980_89700 n1_M2_54060_89700 0.988200
R10010 n1_M2_54060_89700 n1_M2_55140_89700 0.988200
R10011 n1_M2_55140_89700 n1_M2_56220_89700 0.988200
R10012 n1_M2_56220_89700 n1_M2_57300_89700 0.988200
R10013 n1_M2_57300_89700 n1_M2_58380_89700 0.988200
R10014 n1_M2_58380_89700 n1_M2_59460_89700 0.988200
R10015 n1_M2_59460_89700 n1_M2_60540_89700 0.988200
R10016 n1_M2_60540_89700 n1_M2_61620_89700 0.988200
R10017 n1_M2_61620_89700 n1_M2_62700_89700 0.988200
R10018 n1_M2_62700_89700 n1_M2_63780_89700 0.988200
R10019 n1_M2_63780_89700 n1_M2_64860_89700 0.988200
R10020 n1_M2_64860_89700 n1_M2_65940_89700 0.988200
R10021 n1_M2_65940_89700 n1_M2_67020_89700 0.988200
R10022 n1_M2_67020_89700 n1_M2_68100_89700 0.988200
R10023 n1_M2_68100_89700 n1_M2_69180_89700 0.988200
R10024 n1_M2_69180_89700 n1_M2_70260_89700 0.988200
R10025 n1_M2_70260_89700 n1_M2_71340_89700 0.988200
R10026 n1_M2_71340_89700 n1_M2_72420_89700 0.988200
R10027 n1_M2_72420_89700 n1_M2_73500_89700 0.988200
R10028 n1_M2_73500_89700 n1_M2_74580_89700 0.988200
R10029 n1_M2_74580_89700 n1_M2_75660_89700 0.988200
R10030 n1_M2_75660_89700 n1_M2_76740_89700 0.988200
R10031 n1_M2_76740_89700 n1_M2_77820_89700 0.988200
R10032 n1_M2_77820_89700 n1_M2_78900_89700 0.988200
R10033 n1_M2_78900_89700 n1_M2_79980_89700 0.988200
R10034 n1_M2_79980_89700 n1_M2_81060_89700 0.988200
R10035 n1_M2_81060_89700 n1_M2_82140_89700 0.988200
R10036 n1_M2_82140_89700 n1_M2_83220_89700 0.988200
R10037 n1_M2_83220_89700 n1_M2_84300_89700 0.988200
R10038 n1_M2_84300_89700 n1_M2_85380_89700 0.988200
R10039 n1_M2_85380_89700 n1_M2_86460_89700 0.988200
R10040 n1_M2_86460_89700 n1_M2_87540_89700 0.988200
R10041 n1_M2_87540_89700 n1_M2_88620_89700 0.988200
R10042 n1_M2_88620_89700 n1_M2_89700_89700 0.988200
R10043 n1_M2_89700_89700 n1_M2_90780_89700 0.988200
R10044 n1_M2_90780_89700 n1_M2_91860_89700 0.988200
R10045 n1_M2_91860_89700 n1_M2_92940_89700 0.988200
R10046 n1_M2_92940_89700 n1_M2_94020_89700 0.988200
R10047 n1_M2_94020_89700 n1_M2_95100_89700 0.988200
R10048 n1_M2_95100_89700 n1_M2_96180_89700 0.988200
R10049 n1_M2_96180_89700 n1_M2_97260_89700 0.988200
R10050 n1_M2_97260_89700 n1_M2_98340_89700 0.988200
R10051 n1_M2_98340_89700 n1_M2_99420_89700 0.988200
R10052 n1_M2_99420_89700 n1_M2_100500_89700 0.988200
R10053 n1_M2_100500_89700 n1_M2_101580_89700 0.988200
R10054 n1_M2_101580_89700 n1_M2_102660_89700 0.988200
R10055 n1_M2_102660_89700 n1_M2_103740_89700 0.988200
R10056 n1_M2_103740_89700 n1_M2_104820_89700 0.988200
R10057 n1_M2_104820_89700 n1_M2_105900_89700 0.988200
R10058 n1_M2_105900_89700 n1_M2_106980_89700 0.988200
R10059 n1_M2_106980_89700 n1_M2_108060_89700 0.988200
R10060 n1_M2_108060_89700 n1_M2_109140_89700 0.988200
R10061 n1_M2_109140_89700 n1_M2_110220_89700 0.988200
R10062 n1_M2_110220_89700 n1_M2_111300_89700 0.988200
R10063 n1_M2_111300_89700 n1_M2_112380_89700 0.988200
R10064 n1_M2_112380_89700 n1_M2_113460_89700 0.988200
R10065 n1_M2_113460_89700 n1_M2_114540_89700 0.988200
R10066 n1_M2_114540_89700 n1_M2_115620_89700 0.988200
R10067 n1_M2_115620_89700 n1_M2_116700_89700 0.988200
R10068 n1_M2_116700_89700 n1_M2_117780_89700 0.988200
R10069 n1_M2_117780_89700 n1_M2_118860_89700 0.988200
R10070 n1_M2_118860_89700 n1_M2_119940_89700 0.988200
R10071 n1_M2_119940_89700 n1_M2_121020_89700 0.988200
R10072 n1_M2_121020_89700 n1_M2_122100_89700 0.988200
R10073 n1_M2_122100_89700 n1_M2_123180_89700 0.988200
R10074 n1_M2_123180_89700 n1_M2_124260_89700 0.988200
R10075 n1_M2_124260_89700 n1_M2_125340_89700 0.988200
R10076 n1_M2_125340_89700 n1_M2_126420_89700 0.988200
R10077 n1_M2_126420_89700 n1_M2_127500_89700 0.988200
R10078 n1_M2_127500_89700 n1_M2_128580_89700 0.988200
R10079 n1_M2_128580_89700 n1_M2_129660_89700 0.988200
R10080 n1_M2_60_90780 n1_M2_1140_90780 0.988200
R10081 n1_M2_1140_90780 n1_M2_2220_90780 0.988200
R10082 n1_M2_2220_90780 n1_M2_3300_90780 0.988200
R10083 n1_M2_3300_90780 n1_M2_4380_90780 0.988200
R10084 n1_M2_4380_90780 n1_M2_5460_90780 0.988200
R10085 n1_M2_5460_90780 n1_M2_6540_90780 0.988200
R10086 n1_M2_6540_90780 n1_M2_7620_90780 0.988200
R10087 n1_M2_7620_90780 n1_M2_8700_90780 0.988200
R10088 n1_M2_8700_90780 n1_M2_9780_90780 0.988200
R10089 n1_M2_9780_90780 n1_M2_10860_90780 0.988200
R10090 n1_M2_10860_90780 n1_M2_11940_90780 0.988200
R10091 n1_M2_11940_90780 n1_M2_13020_90780 0.988200
R10092 n1_M2_13020_90780 n1_M2_14100_90780 0.988200
R10093 n1_M2_14100_90780 n1_M2_15180_90780 0.988200
R10094 n1_M2_15180_90780 n1_M2_16260_90780 0.988200
R10095 n1_M2_16260_90780 n1_M2_17340_90780 0.988200
R10096 n1_M2_17340_90780 n1_M2_18420_90780 0.988200
R10097 n1_M2_18420_90780 n1_M2_19500_90780 0.988200
R10098 n1_M2_19500_90780 n1_M2_20580_90780 0.988200
R10099 n1_M2_20580_90780 n1_M2_21660_90780 0.988200
R10100 n1_M2_21660_90780 n1_M2_22740_90780 0.988200
R10101 n1_M2_22740_90780 n1_M2_23820_90780 0.988200
R10102 n1_M2_23820_90780 n1_M2_24900_90780 0.988200
R10103 n1_M2_24900_90780 n1_M2_25980_90780 0.988200
R10104 n1_M2_25980_90780 n1_M2_27060_90780 0.988200
R10105 n1_M2_27060_90780 n1_M2_28140_90780 0.988200
R10106 n1_M2_28140_90780 n1_M2_29220_90780 0.988200
R10107 n1_M2_29220_90780 n1_M2_30300_90780 0.988200
R10108 n1_M2_30300_90780 n1_M2_31380_90780 0.988200
R10109 n1_M2_31380_90780 n1_M2_32460_90780 0.988200
R10110 n1_M2_32460_90780 n1_M2_33540_90780 0.988200
R10111 n1_M2_33540_90780 n1_M2_34620_90780 0.988200
R10112 n1_M2_34620_90780 n1_M2_35700_90780 0.988200
R10113 n1_M2_35700_90780 n1_M2_36780_90780 0.988200
R10114 n1_M2_36780_90780 n1_M2_37860_90780 0.988200
R10115 n1_M2_37860_90780 n1_M2_38940_90780 0.988200
R10116 n1_M2_38940_90780 n1_M2_40020_90780 0.988200
R10117 n1_M2_40020_90780 n1_M2_41100_90780 0.988200
R10118 n1_M2_41100_90780 n1_M2_42180_90780 0.988200
R10119 n1_M2_42180_90780 n1_M2_43260_90780 0.988200
R10120 n1_M2_43260_90780 n1_M2_44340_90780 0.988200
R10121 n1_M2_44340_90780 n1_M2_45420_90780 0.988200
R10122 n1_M2_45420_90780 n1_M2_46500_90780 0.988200
R10123 n1_M2_46500_90780 n1_M2_47580_90780 0.988200
R10124 n1_M2_47580_90780 n1_M2_48660_90780 0.988200
R10125 n1_M2_48660_90780 n1_M2_49740_90780 0.988200
R10126 n1_M2_49740_90780 n1_M2_50820_90780 0.988200
R10127 n1_M2_50820_90780 n1_M2_51900_90780 0.988200
R10128 n1_M2_51900_90780 n1_M2_52980_90780 0.988200
R10129 n1_M2_52980_90780 n1_M2_54060_90780 0.988200
R10130 n1_M2_54060_90780 n1_M2_55140_90780 0.988200
R10131 n1_M2_55140_90780 n1_M2_56220_90780 0.988200
R10132 n1_M2_56220_90780 n1_M2_57300_90780 0.988200
R10133 n1_M2_57300_90780 n1_M2_58380_90780 0.988200
R10134 n1_M2_58380_90780 n1_M2_59460_90780 0.988200
R10135 n1_M2_59460_90780 n1_M2_60540_90780 0.988200
R10136 n1_M2_60540_90780 n1_M2_61620_90780 0.988200
R10137 n1_M2_61620_90780 n1_M2_62700_90780 0.988200
R10138 n1_M2_62700_90780 n1_M2_63780_90780 0.988200
R10139 n1_M2_63780_90780 n1_M2_64860_90780 0.988200
R10140 n1_M2_64860_90780 n1_M2_65940_90780 0.988200
R10141 n1_M2_65940_90780 n1_M2_67020_90780 0.988200
R10142 n1_M2_67020_90780 n1_M2_68100_90780 0.988200
R10143 n1_M2_68100_90780 n1_M2_69180_90780 0.988200
R10144 n1_M2_69180_90780 n1_M2_70260_90780 0.988200
R10145 n1_M2_70260_90780 n1_M2_71340_90780 0.988200
R10146 n1_M2_71340_90780 n1_M2_72420_90780 0.988200
R10147 n1_M2_72420_90780 n1_M2_73500_90780 0.988200
R10148 n1_M2_73500_90780 n1_M2_74580_90780 0.988200
R10149 n1_M2_74580_90780 n1_M2_75660_90780 0.988200
R10150 n1_M2_75660_90780 n1_M2_76740_90780 0.988200
R10151 n1_M2_76740_90780 n1_M2_77820_90780 0.988200
R10152 n1_M2_77820_90780 n1_M2_78900_90780 0.988200
R10153 n1_M2_78900_90780 n1_M2_79980_90780 0.988200
R10154 n1_M2_79980_90780 n1_M2_81060_90780 0.988200
R10155 n1_M2_81060_90780 n1_M2_82140_90780 0.988200
R10156 n1_M2_82140_90780 n1_M2_83220_90780 0.988200
R10157 n1_M2_83220_90780 n1_M2_84300_90780 0.988200
R10158 n1_M2_84300_90780 n1_M2_85380_90780 0.988200
R10159 n1_M2_85380_90780 n1_M2_86460_90780 0.988200
R10160 n1_M2_86460_90780 n1_M2_87540_90780 0.988200
R10161 n1_M2_87540_90780 n1_M2_88620_90780 0.988200
R10162 n1_M2_88620_90780 n1_M2_89700_90780 0.988200
R10163 n1_M2_89700_90780 n1_M2_90780_90780 0.988200
R10164 n1_M2_90780_90780 n1_M2_91860_90780 0.988200
R10165 n1_M2_91860_90780 n1_M2_92940_90780 0.988200
R10166 n1_M2_92940_90780 n1_M2_94020_90780 0.988200
R10167 n1_M2_94020_90780 n1_M2_95100_90780 0.988200
R10168 n1_M2_95100_90780 n1_M2_96180_90780 0.988200
R10169 n1_M2_96180_90780 n1_M2_97260_90780 0.988200
R10170 n1_M2_97260_90780 n1_M2_98340_90780 0.988200
R10171 n1_M2_98340_90780 n1_M2_99420_90780 0.988200
R10172 n1_M2_99420_90780 n1_M2_100500_90780 0.988200
R10173 n1_M2_100500_90780 n1_M2_101580_90780 0.988200
R10174 n1_M2_101580_90780 n1_M2_102660_90780 0.988200
R10175 n1_M2_102660_90780 n1_M2_103740_90780 0.988200
R10176 n1_M2_103740_90780 n1_M2_104820_90780 0.988200
R10177 n1_M2_104820_90780 n1_M2_105900_90780 0.988200
R10178 n1_M2_105900_90780 n1_M2_106980_90780 0.988200
R10179 n1_M2_106980_90780 n1_M2_108060_90780 0.988200
R10180 n1_M2_108060_90780 n1_M2_109140_90780 0.988200
R10181 n1_M2_109140_90780 n1_M2_110220_90780 0.988200
R10182 n1_M2_110220_90780 n1_M2_111300_90780 0.988200
R10183 n1_M2_111300_90780 n1_M2_112380_90780 0.988200
R10184 n1_M2_112380_90780 n1_M2_113460_90780 0.988200
R10185 n1_M2_113460_90780 n1_M2_114540_90780 0.988200
R10186 n1_M2_114540_90780 n1_M2_115620_90780 0.988200
R10187 n1_M2_115620_90780 n1_M2_116700_90780 0.988200
R10188 n1_M2_116700_90780 n1_M2_117780_90780 0.988200
R10189 n1_M2_117780_90780 n1_M2_118860_90780 0.988200
R10190 n1_M2_118860_90780 n1_M2_119940_90780 0.988200
R10191 n1_M2_119940_90780 n1_M2_121020_90780 0.988200
R10192 n1_M2_121020_90780 n1_M2_122100_90780 0.988200
R10193 n1_M2_122100_90780 n1_M2_123180_90780 0.988200
R10194 n1_M2_123180_90780 n1_M2_124260_90780 0.988200
R10195 n1_M2_124260_90780 n1_M2_125340_90780 0.988200
R10196 n1_M2_125340_90780 n1_M2_126420_90780 0.988200
R10197 n1_M2_126420_90780 n1_M2_127500_90780 0.988200
R10198 n1_M2_127500_90780 n1_M2_128580_90780 0.988200
R10199 n1_M2_128580_90780 n1_M2_129660_90780 0.988200
R10200 n1_M2_60_91860 n1_M2_1140_91860 0.988200
R10201 n1_M2_1140_91860 n1_M2_2220_91860 0.988200
R10202 n1_M2_2220_91860 n1_M2_3300_91860 0.988200
R10203 n1_M2_3300_91860 n1_M2_4380_91860 0.988200
R10204 n1_M2_4380_91860 n1_M2_5460_91860 0.988200
R10205 n1_M2_5460_91860 n1_M2_6540_91860 0.988200
R10206 n1_M2_6540_91860 n1_M2_7620_91860 0.988200
R10207 n1_M2_7620_91860 n1_M2_8700_91860 0.988200
R10208 n1_M2_8700_91860 n1_M2_9780_91860 0.988200
R10209 n1_M2_9780_91860 n1_M2_10860_91860 0.988200
R10210 n1_M2_10860_91860 n1_M2_11940_91860 0.988200
R10211 n1_M2_11940_91860 n1_M2_13020_91860 0.988200
R10212 n1_M2_13020_91860 n1_M2_14100_91860 0.988200
R10213 n1_M2_14100_91860 n1_M2_15180_91860 0.988200
R10214 n1_M2_15180_91860 n1_M2_16260_91860 0.988200
R10215 n1_M2_16260_91860 n1_M2_17340_91860 0.988200
R10216 n1_M2_17340_91860 n1_M2_18420_91860 0.988200
R10217 n1_M2_18420_91860 n1_M2_19500_91860 0.988200
R10218 n1_M2_19500_91860 n1_M2_20580_91860 0.988200
R10219 n1_M2_20580_91860 n1_M2_21660_91860 0.988200
R10220 n1_M2_21660_91860 n1_M2_22740_91860 0.988200
R10221 n1_M2_22740_91860 n1_M2_23820_91860 0.988200
R10222 n1_M2_23820_91860 n1_M2_24900_91860 0.988200
R10223 n1_M2_24900_91860 n1_M2_25980_91860 0.988200
R10224 n1_M2_25980_91860 n1_M2_27060_91860 0.988200
R10225 n1_M2_27060_91860 n1_M2_28140_91860 0.988200
R10226 n1_M2_28140_91860 n1_M2_29220_91860 0.988200
R10227 n1_M2_29220_91860 n1_M2_30300_91860 0.988200
R10228 n1_M2_30300_91860 n1_M2_31380_91860 0.988200
R10229 n1_M2_31380_91860 n1_M2_32460_91860 0.988200
R10230 n1_M2_32460_91860 n1_M2_33540_91860 0.988200
R10231 n1_M2_33540_91860 n1_M2_34620_91860 0.988200
R10232 n1_M2_34620_91860 n1_M2_35700_91860 0.988200
R10233 n1_M2_35700_91860 n1_M2_36780_91860 0.988200
R10234 n1_M2_36780_91860 n1_M2_37860_91860 0.988200
R10235 n1_M2_37860_91860 n1_M2_38940_91860 0.988200
R10236 n1_M2_38940_91860 n1_M2_40020_91860 0.988200
R10237 n1_M2_40020_91860 n1_M2_41100_91860 0.988200
R10238 n1_M2_41100_91860 n1_M2_42180_91860 0.988200
R10239 n1_M2_42180_91860 n1_M2_43260_91860 0.988200
R10240 n1_M2_43260_91860 n1_M2_44340_91860 0.988200
R10241 n1_M2_44340_91860 n1_M2_45420_91860 0.988200
R10242 n1_M2_45420_91860 n1_M2_46500_91860 0.988200
R10243 n1_M2_46500_91860 n1_M2_47580_91860 0.988200
R10244 n1_M2_47580_91860 n1_M2_48660_91860 0.988200
R10245 n1_M2_48660_91860 n1_M2_49740_91860 0.988200
R10246 n1_M2_49740_91860 n1_M2_50820_91860 0.988200
R10247 n1_M2_50820_91860 n1_M2_51900_91860 0.988200
R10248 n1_M2_51900_91860 n1_M2_52980_91860 0.988200
R10249 n1_M2_52980_91860 n1_M2_54060_91860 0.988200
R10250 n1_M2_54060_91860 n1_M2_55140_91860 0.988200
R10251 n1_M2_55140_91860 n1_M2_56220_91860 0.988200
R10252 n1_M2_56220_91860 n1_M2_57300_91860 0.988200
R10253 n1_M2_57300_91860 n1_M2_58380_91860 0.988200
R10254 n1_M2_58380_91860 n1_M2_59460_91860 0.988200
R10255 n1_M2_59460_91860 n1_M2_60540_91860 0.988200
R10256 n1_M2_60540_91860 n1_M2_61620_91860 0.988200
R10257 n1_M2_61620_91860 n1_M2_62700_91860 0.988200
R10258 n1_M2_62700_91860 n1_M2_63780_91860 0.988200
R10259 n1_M2_63780_91860 n1_M2_64860_91860 0.988200
R10260 n1_M2_64860_91860 n1_M2_65940_91860 0.988200
R10261 n1_M2_65940_91860 n1_M2_67020_91860 0.988200
R10262 n1_M2_67020_91860 n1_M2_68100_91860 0.988200
R10263 n1_M2_68100_91860 n1_M2_69180_91860 0.988200
R10264 n1_M2_69180_91860 n1_M2_70260_91860 0.988200
R10265 n1_M2_70260_91860 n1_M2_71340_91860 0.988200
R10266 n1_M2_71340_91860 n1_M2_72420_91860 0.988200
R10267 n1_M2_72420_91860 n1_M2_73500_91860 0.988200
R10268 n1_M2_73500_91860 n1_M2_74580_91860 0.988200
R10269 n1_M2_74580_91860 n1_M2_75660_91860 0.988200
R10270 n1_M2_75660_91860 n1_M2_76740_91860 0.988200
R10271 n1_M2_76740_91860 n1_M2_77820_91860 0.988200
R10272 n1_M2_77820_91860 n1_M2_78900_91860 0.988200
R10273 n1_M2_78900_91860 n1_M2_79980_91860 0.988200
R10274 n1_M2_79980_91860 n1_M2_81060_91860 0.988200
R10275 n1_M2_81060_91860 n1_M2_82140_91860 0.988200
R10276 n1_M2_82140_91860 n1_M2_83220_91860 0.988200
R10277 n1_M2_83220_91860 n1_M2_84300_91860 0.988200
R10278 n1_M2_84300_91860 n1_M2_85380_91860 0.988200
R10279 n1_M2_85380_91860 n1_M2_86460_91860 0.988200
R10280 n1_M2_86460_91860 n1_M2_87540_91860 0.988200
R10281 n1_M2_87540_91860 n1_M2_88620_91860 0.988200
R10282 n1_M2_88620_91860 n1_M2_89700_91860 0.988200
R10283 n1_M2_89700_91860 n1_M2_90780_91860 0.988200
R10284 n1_M2_90780_91860 n1_M2_91860_91860 0.988200
R10285 n1_M2_91860_91860 n1_M2_92940_91860 0.988200
R10286 n1_M2_92940_91860 n1_M2_94020_91860 0.988200
R10287 n1_M2_94020_91860 n1_M2_95100_91860 0.988200
R10288 n1_M2_95100_91860 n1_M2_96180_91860 0.988200
R10289 n1_M2_96180_91860 n1_M2_97260_91860 0.988200
R10290 n1_M2_97260_91860 n1_M2_98340_91860 0.988200
R10291 n1_M2_98340_91860 n1_M2_99420_91860 0.988200
R10292 n1_M2_99420_91860 n1_M2_100500_91860 0.988200
R10293 n1_M2_100500_91860 n1_M2_101580_91860 0.988200
R10294 n1_M2_101580_91860 n1_M2_102660_91860 0.988200
R10295 n1_M2_102660_91860 n1_M2_103740_91860 0.988200
R10296 n1_M2_103740_91860 n1_M2_104820_91860 0.988200
R10297 n1_M2_104820_91860 n1_M2_105900_91860 0.988200
R10298 n1_M2_105900_91860 n1_M2_106980_91860 0.988200
R10299 n1_M2_106980_91860 n1_M2_108060_91860 0.988200
R10300 n1_M2_108060_91860 n1_M2_109140_91860 0.988200
R10301 n1_M2_109140_91860 n1_M2_110220_91860 0.988200
R10302 n1_M2_110220_91860 n1_M2_111300_91860 0.988200
R10303 n1_M2_111300_91860 n1_M2_112380_91860 0.988200
R10304 n1_M2_112380_91860 n1_M2_113460_91860 0.988200
R10305 n1_M2_113460_91860 n1_M2_114540_91860 0.988200
R10306 n1_M2_114540_91860 n1_M2_115620_91860 0.988200
R10307 n1_M2_115620_91860 n1_M2_116700_91860 0.988200
R10308 n1_M2_116700_91860 n1_M2_117780_91860 0.988200
R10309 n1_M2_117780_91860 n1_M2_118860_91860 0.988200
R10310 n1_M2_118860_91860 n1_M2_119940_91860 0.988200
R10311 n1_M2_119940_91860 n1_M2_121020_91860 0.988200
R10312 n1_M2_121020_91860 n1_M2_122100_91860 0.988200
R10313 n1_M2_122100_91860 n1_M2_123180_91860 0.988200
R10314 n1_M2_123180_91860 n1_M2_124260_91860 0.988200
R10315 n1_M2_124260_91860 n1_M2_125340_91860 0.988200
R10316 n1_M2_125340_91860 n1_M2_126420_91860 0.988200
R10317 n1_M2_126420_91860 n1_M2_127500_91860 0.988200
R10318 n1_M2_127500_91860 n1_M2_128580_91860 0.988200
R10319 n1_M2_128580_91860 n1_M2_129660_91860 0.988200
R10320 n1_M2_60_92940 n1_M2_1140_92940 0.988200
R10321 n1_M2_1140_92940 n1_M2_2220_92940 0.988200
R10322 n1_M2_2220_92940 n1_M2_3300_92940 0.988200
R10323 n1_M2_3300_92940 n1_M2_4380_92940 0.988200
R10324 n1_M2_4380_92940 n1_M2_5460_92940 0.988200
R10325 n1_M2_5460_92940 n1_M2_6540_92940 0.988200
R10326 n1_M2_6540_92940 n1_M2_7620_92940 0.988200
R10327 n1_M2_7620_92940 n1_M2_8700_92940 0.988200
R10328 n1_M2_8700_92940 n1_M2_9780_92940 0.988200
R10329 n1_M2_9780_92940 n1_M2_10860_92940 0.988200
R10330 n1_M2_10860_92940 n1_M2_11940_92940 0.988200
R10331 n1_M2_11940_92940 n1_M2_13020_92940 0.988200
R10332 n1_M2_13020_92940 n1_M2_14100_92940 0.988200
R10333 n1_M2_14100_92940 n1_M2_15180_92940 0.988200
R10334 n1_M2_15180_92940 n1_M2_16260_92940 0.988200
R10335 n1_M2_16260_92940 n1_M2_17340_92940 0.988200
R10336 n1_M2_17340_92940 n1_M2_18420_92940 0.988200
R10337 n1_M2_18420_92940 n1_M2_19500_92940 0.988200
R10338 n1_M2_19500_92940 n1_M2_20580_92940 0.988200
R10339 n1_M2_20580_92940 n1_M2_21660_92940 0.988200
R10340 n1_M2_21660_92940 n1_M2_22740_92940 0.988200
R10341 n1_M2_22740_92940 n1_M2_23820_92940 0.988200
R10342 n1_M2_23820_92940 n1_M2_24900_92940 0.988200
R10343 n1_M2_24900_92940 n1_M2_25980_92940 0.988200
R10344 n1_M2_25980_92940 n1_M2_27060_92940 0.988200
R10345 n1_M2_27060_92940 n1_M2_28140_92940 0.988200
R10346 n1_M2_28140_92940 n1_M2_29220_92940 0.988200
R10347 n1_M2_29220_92940 n1_M2_30300_92940 0.988200
R10348 n1_M2_30300_92940 n1_M2_31380_92940 0.988200
R10349 n1_M2_31380_92940 n1_M2_32460_92940 0.988200
R10350 n1_M2_32460_92940 n1_M2_33540_92940 0.988200
R10351 n1_M2_33540_92940 n1_M2_34620_92940 0.988200
R10352 n1_M2_34620_92940 n1_M2_35700_92940 0.988200
R10353 n1_M2_35700_92940 n1_M2_36780_92940 0.988200
R10354 n1_M2_36780_92940 n1_M2_37860_92940 0.988200
R10355 n1_M2_37860_92940 n1_M2_38940_92940 0.988200
R10356 n1_M2_38940_92940 n1_M2_40020_92940 0.988200
R10357 n1_M2_40020_92940 n1_M2_41100_92940 0.988200
R10358 n1_M2_41100_92940 n1_M2_42180_92940 0.988200
R10359 n1_M2_42180_92940 n1_M2_43260_92940 0.988200
R10360 n1_M2_43260_92940 n1_M2_44340_92940 0.988200
R10361 n1_M2_44340_92940 n1_M2_45420_92940 0.988200
R10362 n1_M2_45420_92940 n1_M2_46500_92940 0.988200
R10363 n1_M2_46500_92940 n1_M2_47580_92940 0.988200
R10364 n1_M2_47580_92940 n1_M2_48660_92940 0.988200
R10365 n1_M2_48660_92940 n1_M2_49740_92940 0.988200
R10366 n1_M2_49740_92940 n1_M2_50820_92940 0.988200
R10367 n1_M2_50820_92940 n1_M2_51900_92940 0.988200
R10368 n1_M2_51900_92940 n1_M2_52980_92940 0.988200
R10369 n1_M2_52980_92940 n1_M2_54060_92940 0.988200
R10370 n1_M2_54060_92940 n1_M2_55140_92940 0.988200
R10371 n1_M2_55140_92940 n1_M2_56220_92940 0.988200
R10372 n1_M2_56220_92940 n1_M2_57300_92940 0.988200
R10373 n1_M2_57300_92940 n1_M2_58380_92940 0.988200
R10374 n1_M2_58380_92940 n1_M2_59460_92940 0.988200
R10375 n1_M2_59460_92940 n1_M2_60540_92940 0.988200
R10376 n1_M2_60540_92940 n1_M2_61620_92940 0.988200
R10377 n1_M2_61620_92940 n1_M2_62700_92940 0.988200
R10378 n1_M2_62700_92940 n1_M2_63780_92940 0.988200
R10379 n1_M2_63780_92940 n1_M2_64860_92940 0.988200
R10380 n1_M2_64860_92940 n1_M2_65940_92940 0.988200
R10381 n1_M2_65940_92940 n1_M2_67020_92940 0.988200
R10382 n1_M2_67020_92940 n1_M2_68100_92940 0.988200
R10383 n1_M2_68100_92940 n1_M2_69180_92940 0.988200
R10384 n1_M2_69180_92940 n1_M2_70260_92940 0.988200
R10385 n1_M2_70260_92940 n1_M2_71340_92940 0.988200
R10386 n1_M2_71340_92940 n1_M2_72420_92940 0.988200
R10387 n1_M2_72420_92940 n1_M2_73500_92940 0.988200
R10388 n1_M2_73500_92940 n1_M2_74580_92940 0.988200
R10389 n1_M2_74580_92940 n1_M2_75660_92940 0.988200
R10390 n1_M2_75660_92940 n1_M2_76740_92940 0.988200
R10391 n1_M2_76740_92940 n1_M2_77820_92940 0.988200
R10392 n1_M2_77820_92940 n1_M2_78900_92940 0.988200
R10393 n1_M2_78900_92940 n1_M2_79980_92940 0.988200
R10394 n1_M2_79980_92940 n1_M2_81060_92940 0.988200
R10395 n1_M2_81060_92940 n1_M2_82140_92940 0.988200
R10396 n1_M2_82140_92940 n1_M2_83220_92940 0.988200
R10397 n1_M2_83220_92940 n1_M2_84300_92940 0.988200
R10398 n1_M2_84300_92940 n1_M2_85380_92940 0.988200
R10399 n1_M2_85380_92940 n1_M2_86460_92940 0.988200
R10400 n1_M2_86460_92940 n1_M2_87540_92940 0.988200
R10401 n1_M2_87540_92940 n1_M2_88620_92940 0.988200
R10402 n1_M2_88620_92940 n1_M2_89700_92940 0.988200
R10403 n1_M2_89700_92940 n1_M2_90780_92940 0.988200
R10404 n1_M2_90780_92940 n1_M2_91860_92940 0.988200
R10405 n1_M2_91860_92940 n1_M2_92940_92940 0.988200
R10406 n1_M2_92940_92940 n1_M2_94020_92940 0.988200
R10407 n1_M2_94020_92940 n1_M2_95100_92940 0.988200
R10408 n1_M2_95100_92940 n1_M2_96180_92940 0.988200
R10409 n1_M2_96180_92940 n1_M2_97260_92940 0.988200
R10410 n1_M2_97260_92940 n1_M2_98340_92940 0.988200
R10411 n1_M2_98340_92940 n1_M2_99420_92940 0.988200
R10412 n1_M2_99420_92940 n1_M2_100500_92940 0.988200
R10413 n1_M2_100500_92940 n1_M2_101580_92940 0.988200
R10414 n1_M2_101580_92940 n1_M2_102660_92940 0.988200
R10415 n1_M2_102660_92940 n1_M2_103740_92940 0.988200
R10416 n1_M2_103740_92940 n1_M2_104820_92940 0.988200
R10417 n1_M2_104820_92940 n1_M2_105900_92940 0.988200
R10418 n1_M2_105900_92940 n1_M2_106980_92940 0.988200
R10419 n1_M2_106980_92940 n1_M2_108060_92940 0.988200
R10420 n1_M2_108060_92940 n1_M2_109140_92940 0.988200
R10421 n1_M2_109140_92940 n1_M2_110220_92940 0.988200
R10422 n1_M2_110220_92940 n1_M2_111300_92940 0.988200
R10423 n1_M2_111300_92940 n1_M2_112380_92940 0.988200
R10424 n1_M2_112380_92940 n1_M2_113460_92940 0.988200
R10425 n1_M2_113460_92940 n1_M2_114540_92940 0.988200
R10426 n1_M2_114540_92940 n1_M2_115620_92940 0.988200
R10427 n1_M2_115620_92940 n1_M2_116700_92940 0.988200
R10428 n1_M2_116700_92940 n1_M2_117780_92940 0.988200
R10429 n1_M2_117780_92940 n1_M2_118860_92940 0.988200
R10430 n1_M2_118860_92940 n1_M2_119940_92940 0.988200
R10431 n1_M2_119940_92940 n1_M2_121020_92940 0.988200
R10432 n1_M2_121020_92940 n1_M2_122100_92940 0.988200
R10433 n1_M2_122100_92940 n1_M2_123180_92940 0.988200
R10434 n1_M2_123180_92940 n1_M2_124260_92940 0.988200
R10435 n1_M2_124260_92940 n1_M2_125340_92940 0.988200
R10436 n1_M2_125340_92940 n1_M2_126420_92940 0.988200
R10437 n1_M2_126420_92940 n1_M2_127500_92940 0.988200
R10438 n1_M2_127500_92940 n1_M2_128580_92940 0.988200
R10439 n1_M2_128580_92940 n1_M2_129660_92940 0.988200
R10440 n1_M2_60_94020 n1_M2_1140_94020 0.988200
R10441 n1_M2_1140_94020 n1_M2_2220_94020 0.988200
R10442 n1_M2_2220_94020 n1_M2_3300_94020 0.988200
R10443 n1_M2_3300_94020 n1_M2_4380_94020 0.988200
R10444 n1_M2_4380_94020 n1_M2_5460_94020 0.988200
R10445 n1_M2_5460_94020 n1_M2_6540_94020 0.988200
R10446 n1_M2_6540_94020 n1_M2_7620_94020 0.988200
R10447 n1_M2_7620_94020 n1_M2_8700_94020 0.988200
R10448 n1_M2_8700_94020 n1_M2_9780_94020 0.988200
R10449 n1_M2_9780_94020 n1_M2_10860_94020 0.988200
R10450 n1_M2_10860_94020 n1_M2_11940_94020 0.988200
R10451 n1_M2_11940_94020 n1_M2_13020_94020 0.988200
R10452 n1_M2_13020_94020 n1_M2_14100_94020 0.988200
R10453 n1_M2_14100_94020 n1_M2_15180_94020 0.988200
R10454 n1_M2_15180_94020 n1_M2_16260_94020 0.988200
R10455 n1_M2_16260_94020 n1_M2_17340_94020 0.988200
R10456 n1_M2_17340_94020 n1_M2_18420_94020 0.988200
R10457 n1_M2_18420_94020 n1_M2_19500_94020 0.988200
R10458 n1_M2_19500_94020 n1_M2_20580_94020 0.988200
R10459 n1_M2_20580_94020 n1_M2_21660_94020 0.988200
R10460 n1_M2_21660_94020 n1_M2_22740_94020 0.988200
R10461 n1_M2_22740_94020 n1_M2_23820_94020 0.988200
R10462 n1_M2_23820_94020 n1_M2_24900_94020 0.988200
R10463 n1_M2_24900_94020 n1_M2_25980_94020 0.988200
R10464 n1_M2_25980_94020 n1_M2_27060_94020 0.988200
R10465 n1_M2_27060_94020 n1_M2_28140_94020 0.988200
R10466 n1_M2_28140_94020 n1_M2_29220_94020 0.988200
R10467 n1_M2_29220_94020 n1_M2_30300_94020 0.988200
R10468 n1_M2_30300_94020 n1_M2_31380_94020 0.988200
R10469 n1_M2_31380_94020 n1_M2_32460_94020 0.988200
R10470 n1_M2_32460_94020 n1_M2_33540_94020 0.988200
R10471 n1_M2_33540_94020 n1_M2_34620_94020 0.988200
R10472 n1_M2_34620_94020 n1_M2_35700_94020 0.988200
R10473 n1_M2_35700_94020 n1_M2_36780_94020 0.988200
R10474 n1_M2_36780_94020 n1_M2_37860_94020 0.988200
R10475 n1_M2_37860_94020 n1_M2_38940_94020 0.988200
R10476 n1_M2_38940_94020 n1_M2_40020_94020 0.988200
R10477 n1_M2_40020_94020 n1_M2_41100_94020 0.988200
R10478 n1_M2_41100_94020 n1_M2_42180_94020 0.988200
R10479 n1_M2_42180_94020 n1_M2_43260_94020 0.988200
R10480 n1_M2_43260_94020 n1_M2_44340_94020 0.988200
R10481 n1_M2_44340_94020 n1_M2_45420_94020 0.988200
R10482 n1_M2_45420_94020 n1_M2_46500_94020 0.988200
R10483 n1_M2_46500_94020 n1_M2_47580_94020 0.988200
R10484 n1_M2_47580_94020 n1_M2_48660_94020 0.988200
R10485 n1_M2_48660_94020 n1_M2_49740_94020 0.988200
R10486 n1_M2_49740_94020 n1_M2_50820_94020 0.988200
R10487 n1_M2_50820_94020 n1_M2_51900_94020 0.988200
R10488 n1_M2_51900_94020 n1_M2_52980_94020 0.988200
R10489 n1_M2_52980_94020 n1_M2_54060_94020 0.988200
R10490 n1_M2_54060_94020 n1_M2_55140_94020 0.988200
R10491 n1_M2_55140_94020 n1_M2_56220_94020 0.988200
R10492 n1_M2_56220_94020 n1_M2_57300_94020 0.988200
R10493 n1_M2_57300_94020 n1_M2_58380_94020 0.988200
R10494 n1_M2_58380_94020 n1_M2_59460_94020 0.988200
R10495 n1_M2_59460_94020 n1_M2_60540_94020 0.988200
R10496 n1_M2_60540_94020 n1_M2_61620_94020 0.988200
R10497 n1_M2_61620_94020 n1_M2_62700_94020 0.988200
R10498 n1_M2_62700_94020 n1_M2_63780_94020 0.988200
R10499 n1_M2_63780_94020 n1_M2_64860_94020 0.988200
R10500 n1_M2_64860_94020 n1_M2_65940_94020 0.988200
R10501 n1_M2_65940_94020 n1_M2_67020_94020 0.988200
R10502 n1_M2_67020_94020 n1_M2_68100_94020 0.988200
R10503 n1_M2_68100_94020 n1_M2_69180_94020 0.988200
R10504 n1_M2_69180_94020 n1_M2_70260_94020 0.988200
R10505 n1_M2_70260_94020 n1_M2_71340_94020 0.988200
R10506 n1_M2_71340_94020 n1_M2_72420_94020 0.988200
R10507 n1_M2_72420_94020 n1_M2_73500_94020 0.988200
R10508 n1_M2_73500_94020 n1_M2_74580_94020 0.988200
R10509 n1_M2_74580_94020 n1_M2_75660_94020 0.988200
R10510 n1_M2_75660_94020 n1_M2_76740_94020 0.988200
R10511 n1_M2_76740_94020 n1_M2_77820_94020 0.988200
R10512 n1_M2_77820_94020 n1_M2_78900_94020 0.988200
R10513 n1_M2_78900_94020 n1_M2_79980_94020 0.988200
R10514 n1_M2_79980_94020 n1_M2_81060_94020 0.988200
R10515 n1_M2_81060_94020 n1_M2_82140_94020 0.988200
R10516 n1_M2_82140_94020 n1_M2_83220_94020 0.988200
R10517 n1_M2_83220_94020 n1_M2_84300_94020 0.988200
R10518 n1_M2_84300_94020 n1_M2_85380_94020 0.988200
R10519 n1_M2_85380_94020 n1_M2_86460_94020 0.988200
R10520 n1_M2_86460_94020 n1_M2_87540_94020 0.988200
R10521 n1_M2_87540_94020 n1_M2_88620_94020 0.988200
R10522 n1_M2_88620_94020 n1_M2_89700_94020 0.988200
R10523 n1_M2_89700_94020 n1_M2_90780_94020 0.988200
R10524 n1_M2_90780_94020 n1_M2_91860_94020 0.988200
R10525 n1_M2_91860_94020 n1_M2_92940_94020 0.988200
R10526 n1_M2_92940_94020 n1_M2_94020_94020 0.988200
R10527 n1_M2_94020_94020 n1_M2_95100_94020 0.988200
R10528 n1_M2_95100_94020 n1_M2_96180_94020 0.988200
R10529 n1_M2_96180_94020 n1_M2_97260_94020 0.988200
R10530 n1_M2_97260_94020 n1_M2_98340_94020 0.988200
R10531 n1_M2_98340_94020 n1_M2_99420_94020 0.988200
R10532 n1_M2_99420_94020 n1_M2_100500_94020 0.988200
R10533 n1_M2_100500_94020 n1_M2_101580_94020 0.988200
R10534 n1_M2_101580_94020 n1_M2_102660_94020 0.988200
R10535 n1_M2_102660_94020 n1_M2_103740_94020 0.988200
R10536 n1_M2_103740_94020 n1_M2_104820_94020 0.988200
R10537 n1_M2_104820_94020 n1_M2_105900_94020 0.988200
R10538 n1_M2_105900_94020 n1_M2_106980_94020 0.988200
R10539 n1_M2_106980_94020 n1_M2_108060_94020 0.988200
R10540 n1_M2_108060_94020 n1_M2_109140_94020 0.988200
R10541 n1_M2_109140_94020 n1_M2_110220_94020 0.988200
R10542 n1_M2_110220_94020 n1_M2_111300_94020 0.988200
R10543 n1_M2_111300_94020 n1_M2_112380_94020 0.988200
R10544 n1_M2_112380_94020 n1_M2_113460_94020 0.988200
R10545 n1_M2_113460_94020 n1_M2_114540_94020 0.988200
R10546 n1_M2_114540_94020 n1_M2_115620_94020 0.988200
R10547 n1_M2_115620_94020 n1_M2_116700_94020 0.988200
R10548 n1_M2_116700_94020 n1_M2_117780_94020 0.988200
R10549 n1_M2_117780_94020 n1_M2_118860_94020 0.988200
R10550 n1_M2_118860_94020 n1_M2_119940_94020 0.988200
R10551 n1_M2_119940_94020 n1_M2_121020_94020 0.988200
R10552 n1_M2_121020_94020 n1_M2_122100_94020 0.988200
R10553 n1_M2_122100_94020 n1_M2_123180_94020 0.988200
R10554 n1_M2_123180_94020 n1_M2_124260_94020 0.988200
R10555 n1_M2_124260_94020 n1_M2_125340_94020 0.988200
R10556 n1_M2_125340_94020 n1_M2_126420_94020 0.988200
R10557 n1_M2_126420_94020 n1_M2_127500_94020 0.988200
R10558 n1_M2_127500_94020 n1_M2_128580_94020 0.988200
R10559 n1_M2_128580_94020 n1_M2_129660_94020 0.988200
R10560 n1_M2_60_95100 n1_M2_1140_95100 0.988200
R10561 n1_M2_1140_95100 n1_M2_2220_95100 0.988200
R10562 n1_M2_2220_95100 n1_M2_3300_95100 0.988200
R10563 n1_M2_3300_95100 n1_M2_4380_95100 0.988200
R10564 n1_M2_4380_95100 n1_M2_5460_95100 0.988200
R10565 n1_M2_5460_95100 n1_M2_6540_95100 0.988200
R10566 n1_M2_6540_95100 n1_M2_7620_95100 0.988200
R10567 n1_M2_7620_95100 n1_M2_8700_95100 0.988200
R10568 n1_M2_8700_95100 n1_M2_9780_95100 0.988200
R10569 n1_M2_9780_95100 n1_M2_10860_95100 0.988200
R10570 n1_M2_10860_95100 n1_M2_11940_95100 0.988200
R10571 n1_M2_11940_95100 n1_M2_13020_95100 0.988200
R10572 n1_M2_13020_95100 n1_M2_14100_95100 0.988200
R10573 n1_M2_14100_95100 n1_M2_15180_95100 0.988200
R10574 n1_M2_15180_95100 n1_M2_16260_95100 0.988200
R10575 n1_M2_16260_95100 n1_M2_17340_95100 0.988200
R10576 n1_M2_17340_95100 n1_M2_18420_95100 0.988200
R10577 n1_M2_18420_95100 n1_M2_19500_95100 0.988200
R10578 n1_M2_19500_95100 n1_M2_20580_95100 0.988200
R10579 n1_M2_20580_95100 n1_M2_21660_95100 0.988200
R10580 n1_M2_21660_95100 n1_M2_22740_95100 0.988200
R10581 n1_M2_22740_95100 n1_M2_23820_95100 0.988200
R10582 n1_M2_23820_95100 n1_M2_24900_95100 0.988200
R10583 n1_M2_24900_95100 n1_M2_25980_95100 0.988200
R10584 n1_M2_25980_95100 n1_M2_27060_95100 0.988200
R10585 n1_M2_27060_95100 n1_M2_28140_95100 0.988200
R10586 n1_M2_28140_95100 n1_M2_29220_95100 0.988200
R10587 n1_M2_29220_95100 n1_M2_30300_95100 0.988200
R10588 n1_M2_30300_95100 n1_M2_31380_95100 0.988200
R10589 n1_M2_31380_95100 n1_M2_32460_95100 0.988200
R10590 n1_M2_32460_95100 n1_M2_33540_95100 0.988200
R10591 n1_M2_33540_95100 n1_M2_34620_95100 0.988200
R10592 n1_M2_34620_95100 n1_M2_35700_95100 0.988200
R10593 n1_M2_35700_95100 n1_M2_36780_95100 0.988200
R10594 n1_M2_36780_95100 n1_M2_37860_95100 0.988200
R10595 n1_M2_37860_95100 n1_M2_38940_95100 0.988200
R10596 n1_M2_38940_95100 n1_M2_40020_95100 0.988200
R10597 n1_M2_40020_95100 n1_M2_41100_95100 0.988200
R10598 n1_M2_41100_95100 n1_M2_42180_95100 0.988200
R10599 n1_M2_42180_95100 n1_M2_43260_95100 0.988200
R10600 n1_M2_43260_95100 n1_M2_44340_95100 0.988200
R10601 n1_M2_44340_95100 n1_M2_45420_95100 0.988200
R10602 n1_M2_45420_95100 n1_M2_46500_95100 0.988200
R10603 n1_M2_46500_95100 n1_M2_47580_95100 0.988200
R10604 n1_M2_47580_95100 n1_M2_48660_95100 0.988200
R10605 n1_M2_48660_95100 n1_M2_49740_95100 0.988200
R10606 n1_M2_49740_95100 n1_M2_50820_95100 0.988200
R10607 n1_M2_50820_95100 n1_M2_51900_95100 0.988200
R10608 n1_M2_51900_95100 n1_M2_52980_95100 0.988200
R10609 n1_M2_52980_95100 n1_M2_54060_95100 0.988200
R10610 n1_M2_54060_95100 n1_M2_55140_95100 0.988200
R10611 n1_M2_55140_95100 n1_M2_56220_95100 0.988200
R10612 n1_M2_56220_95100 n1_M2_57300_95100 0.988200
R10613 n1_M2_57300_95100 n1_M2_58380_95100 0.988200
R10614 n1_M2_58380_95100 n1_M2_59460_95100 0.988200
R10615 n1_M2_59460_95100 n1_M2_60540_95100 0.988200
R10616 n1_M2_60540_95100 n1_M2_61620_95100 0.988200
R10617 n1_M2_61620_95100 n1_M2_62700_95100 0.988200
R10618 n1_M2_62700_95100 n1_M2_63780_95100 0.988200
R10619 n1_M2_63780_95100 n1_M2_64860_95100 0.988200
R10620 n1_M2_64860_95100 n1_M2_65940_95100 0.988200
R10621 n1_M2_65940_95100 n1_M2_67020_95100 0.988200
R10622 n1_M2_67020_95100 n1_M2_68100_95100 0.988200
R10623 n1_M2_68100_95100 n1_M2_69180_95100 0.988200
R10624 n1_M2_69180_95100 n1_M2_70260_95100 0.988200
R10625 n1_M2_70260_95100 n1_M2_71340_95100 0.988200
R10626 n1_M2_71340_95100 n1_M2_72420_95100 0.988200
R10627 n1_M2_72420_95100 n1_M2_73500_95100 0.988200
R10628 n1_M2_73500_95100 n1_M2_74580_95100 0.988200
R10629 n1_M2_74580_95100 n1_M2_75660_95100 0.988200
R10630 n1_M2_75660_95100 n1_M2_76740_95100 0.988200
R10631 n1_M2_76740_95100 n1_M2_77820_95100 0.988200
R10632 n1_M2_77820_95100 n1_M2_78900_95100 0.988200
R10633 n1_M2_78900_95100 n1_M2_79980_95100 0.988200
R10634 n1_M2_79980_95100 n1_M2_81060_95100 0.988200
R10635 n1_M2_81060_95100 n1_M2_82140_95100 0.988200
R10636 n1_M2_82140_95100 n1_M2_83220_95100 0.988200
R10637 n1_M2_83220_95100 n1_M2_84300_95100 0.988200
R10638 n1_M2_84300_95100 n1_M2_85380_95100 0.988200
R10639 n1_M2_85380_95100 n1_M2_86460_95100 0.988200
R10640 n1_M2_86460_95100 n1_M2_87540_95100 0.988200
R10641 n1_M2_87540_95100 n1_M2_88620_95100 0.988200
R10642 n1_M2_88620_95100 n1_M2_89700_95100 0.988200
R10643 n1_M2_89700_95100 n1_M2_90780_95100 0.988200
R10644 n1_M2_90780_95100 n1_M2_91860_95100 0.988200
R10645 n1_M2_91860_95100 n1_M2_92940_95100 0.988200
R10646 n1_M2_92940_95100 n1_M2_94020_95100 0.988200
R10647 n1_M2_94020_95100 n1_M2_95100_95100 0.988200
R10648 n1_M2_95100_95100 n1_M2_96180_95100 0.988200
R10649 n1_M2_96180_95100 n1_M2_97260_95100 0.988200
R10650 n1_M2_97260_95100 n1_M2_98340_95100 0.988200
R10651 n1_M2_98340_95100 n1_M2_99420_95100 0.988200
R10652 n1_M2_99420_95100 n1_M2_100500_95100 0.988200
R10653 n1_M2_100500_95100 n1_M2_101580_95100 0.988200
R10654 n1_M2_101580_95100 n1_M2_102660_95100 0.988200
R10655 n1_M2_102660_95100 n1_M2_103740_95100 0.988200
R10656 n1_M2_103740_95100 n1_M2_104820_95100 0.988200
R10657 n1_M2_104820_95100 n1_M2_105900_95100 0.988200
R10658 n1_M2_105900_95100 n1_M2_106980_95100 0.988200
R10659 n1_M2_106980_95100 n1_M2_108060_95100 0.988200
R10660 n1_M2_108060_95100 n1_M2_109140_95100 0.988200
R10661 n1_M2_109140_95100 n1_M2_110220_95100 0.988200
R10662 n1_M2_110220_95100 n1_M2_111300_95100 0.988200
R10663 n1_M2_111300_95100 n1_M2_112380_95100 0.988200
R10664 n1_M2_112380_95100 n1_M2_113460_95100 0.988200
R10665 n1_M2_113460_95100 n1_M2_114540_95100 0.988200
R10666 n1_M2_114540_95100 n1_M2_115620_95100 0.988200
R10667 n1_M2_115620_95100 n1_M2_116700_95100 0.988200
R10668 n1_M2_116700_95100 n1_M2_117780_95100 0.988200
R10669 n1_M2_117780_95100 n1_M2_118860_95100 0.988200
R10670 n1_M2_118860_95100 n1_M2_119940_95100 0.988200
R10671 n1_M2_119940_95100 n1_M2_121020_95100 0.988200
R10672 n1_M2_121020_95100 n1_M2_122100_95100 0.988200
R10673 n1_M2_122100_95100 n1_M2_123180_95100 0.988200
R10674 n1_M2_123180_95100 n1_M2_124260_95100 0.988200
R10675 n1_M2_124260_95100 n1_M2_125340_95100 0.988200
R10676 n1_M2_125340_95100 n1_M2_126420_95100 0.988200
R10677 n1_M2_126420_95100 n1_M2_127500_95100 0.988200
R10678 n1_M2_127500_95100 n1_M2_128580_95100 0.988200
R10679 n1_M2_128580_95100 n1_M2_129660_95100 0.988200
R10680 n1_M2_60_96180 n1_M2_1140_96180 0.988200
R10681 n1_M2_1140_96180 n1_M2_2220_96180 0.988200
R10682 n1_M2_2220_96180 n1_M2_3300_96180 0.988200
R10683 n1_M2_3300_96180 n1_M2_4380_96180 0.988200
R10684 n1_M2_4380_96180 n1_M2_5460_96180 0.988200
R10685 n1_M2_5460_96180 n1_M2_6540_96180 0.988200
R10686 n1_M2_6540_96180 n1_M2_7620_96180 0.988200
R10687 n1_M2_7620_96180 n1_M2_8700_96180 0.988200
R10688 n1_M2_8700_96180 n1_M2_9780_96180 0.988200
R10689 n1_M2_9780_96180 n1_M2_10860_96180 0.988200
R10690 n1_M2_10860_96180 n1_M2_11940_96180 0.988200
R10691 n1_M2_11940_96180 n1_M2_13020_96180 0.988200
R10692 n1_M2_13020_96180 n1_M2_14100_96180 0.988200
R10693 n1_M2_14100_96180 n1_M2_15180_96180 0.988200
R10694 n1_M2_15180_96180 n1_M2_16260_96180 0.988200
R10695 n1_M2_16260_96180 n1_M2_17340_96180 0.988200
R10696 n1_M2_17340_96180 n1_M2_18420_96180 0.988200
R10697 n1_M2_18420_96180 n1_M2_19500_96180 0.988200
R10698 n1_M2_19500_96180 n1_M2_20580_96180 0.988200
R10699 n1_M2_20580_96180 n1_M2_21660_96180 0.988200
R10700 n1_M2_21660_96180 n1_M2_22740_96180 0.988200
R10701 n1_M2_22740_96180 n1_M2_23820_96180 0.988200
R10702 n1_M2_23820_96180 n1_M2_24900_96180 0.988200
R10703 n1_M2_24900_96180 n1_M2_25980_96180 0.988200
R10704 n1_M2_25980_96180 n1_M2_27060_96180 0.988200
R10705 n1_M2_27060_96180 n1_M2_28140_96180 0.988200
R10706 n1_M2_28140_96180 n1_M2_29220_96180 0.988200
R10707 n1_M2_29220_96180 n1_M2_30300_96180 0.988200
R10708 n1_M2_30300_96180 n1_M2_31380_96180 0.988200
R10709 n1_M2_31380_96180 n1_M2_32460_96180 0.988200
R10710 n1_M2_32460_96180 n1_M2_33540_96180 0.988200
R10711 n1_M2_33540_96180 n1_M2_34620_96180 0.988200
R10712 n1_M2_34620_96180 n1_M2_35700_96180 0.988200
R10713 n1_M2_35700_96180 n1_M2_36780_96180 0.988200
R10714 n1_M2_36780_96180 n1_M2_37860_96180 0.988200
R10715 n1_M2_37860_96180 n1_M2_38940_96180 0.988200
R10716 n1_M2_38940_96180 n1_M2_40020_96180 0.988200
R10717 n1_M2_40020_96180 n1_M2_41100_96180 0.988200
R10718 n1_M2_41100_96180 n1_M2_42180_96180 0.988200
R10719 n1_M2_42180_96180 n1_M2_43260_96180 0.988200
R10720 n1_M2_43260_96180 n1_M2_44340_96180 0.988200
R10721 n1_M2_44340_96180 n1_M2_45420_96180 0.988200
R10722 n1_M2_45420_96180 n1_M2_46500_96180 0.988200
R10723 n1_M2_46500_96180 n1_M2_47580_96180 0.988200
R10724 n1_M2_47580_96180 n1_M2_48660_96180 0.988200
R10725 n1_M2_48660_96180 n1_M2_49740_96180 0.988200
R10726 n1_M2_49740_96180 n1_M2_50820_96180 0.988200
R10727 n1_M2_50820_96180 n1_M2_51900_96180 0.988200
R10728 n1_M2_51900_96180 n1_M2_52980_96180 0.988200
R10729 n1_M2_52980_96180 n1_M2_54060_96180 0.988200
R10730 n1_M2_54060_96180 n1_M2_55140_96180 0.988200
R10731 n1_M2_55140_96180 n1_M2_56220_96180 0.988200
R10732 n1_M2_56220_96180 n1_M2_57300_96180 0.988200
R10733 n1_M2_57300_96180 n1_M2_58380_96180 0.988200
R10734 n1_M2_58380_96180 n1_M2_59460_96180 0.988200
R10735 n1_M2_59460_96180 n1_M2_60540_96180 0.988200
R10736 n1_M2_60540_96180 n1_M2_61620_96180 0.988200
R10737 n1_M2_61620_96180 n1_M2_62700_96180 0.988200
R10738 n1_M2_62700_96180 n1_M2_63780_96180 0.988200
R10739 n1_M2_63780_96180 n1_M2_64860_96180 0.988200
R10740 n1_M2_64860_96180 n1_M2_65940_96180 0.988200
R10741 n1_M2_65940_96180 n1_M2_67020_96180 0.988200
R10742 n1_M2_67020_96180 n1_M2_68100_96180 0.988200
R10743 n1_M2_68100_96180 n1_M2_69180_96180 0.988200
R10744 n1_M2_69180_96180 n1_M2_70260_96180 0.988200
R10745 n1_M2_70260_96180 n1_M2_71340_96180 0.988200
R10746 n1_M2_71340_96180 n1_M2_72420_96180 0.988200
R10747 n1_M2_72420_96180 n1_M2_73500_96180 0.988200
R10748 n1_M2_73500_96180 n1_M2_74580_96180 0.988200
R10749 n1_M2_74580_96180 n1_M2_75660_96180 0.988200
R10750 n1_M2_75660_96180 n1_M2_76740_96180 0.988200
R10751 n1_M2_76740_96180 n1_M2_77820_96180 0.988200
R10752 n1_M2_77820_96180 n1_M2_78900_96180 0.988200
R10753 n1_M2_78900_96180 n1_M2_79980_96180 0.988200
R10754 n1_M2_79980_96180 n1_M2_81060_96180 0.988200
R10755 n1_M2_81060_96180 n1_M2_82140_96180 0.988200
R10756 n1_M2_82140_96180 n1_M2_83220_96180 0.988200
R10757 n1_M2_83220_96180 n1_M2_84300_96180 0.988200
R10758 n1_M2_84300_96180 n1_M2_85380_96180 0.988200
R10759 n1_M2_85380_96180 n1_M2_86460_96180 0.988200
R10760 n1_M2_86460_96180 n1_M2_87540_96180 0.988200
R10761 n1_M2_87540_96180 n1_M2_88620_96180 0.988200
R10762 n1_M2_88620_96180 n1_M2_89700_96180 0.988200
R10763 n1_M2_89700_96180 n1_M2_90780_96180 0.988200
R10764 n1_M2_90780_96180 n1_M2_91860_96180 0.988200
R10765 n1_M2_91860_96180 n1_M2_92940_96180 0.988200
R10766 n1_M2_92940_96180 n1_M2_94020_96180 0.988200
R10767 n1_M2_94020_96180 n1_M2_95100_96180 0.988200
R10768 n1_M2_95100_96180 n1_M2_96180_96180 0.988200
R10769 n1_M2_96180_96180 n1_M2_97260_96180 0.988200
R10770 n1_M2_97260_96180 n1_M2_98340_96180 0.988200
R10771 n1_M2_98340_96180 n1_M2_99420_96180 0.988200
R10772 n1_M2_99420_96180 n1_M2_100500_96180 0.988200
R10773 n1_M2_100500_96180 n1_M2_101580_96180 0.988200
R10774 n1_M2_101580_96180 n1_M2_102660_96180 0.988200
R10775 n1_M2_102660_96180 n1_M2_103740_96180 0.988200
R10776 n1_M2_103740_96180 n1_M2_104820_96180 0.988200
R10777 n1_M2_104820_96180 n1_M2_105900_96180 0.988200
R10778 n1_M2_105900_96180 n1_M2_106980_96180 0.988200
R10779 n1_M2_106980_96180 n1_M2_108060_96180 0.988200
R10780 n1_M2_108060_96180 n1_M2_109140_96180 0.988200
R10781 n1_M2_109140_96180 n1_M2_110220_96180 0.988200
R10782 n1_M2_110220_96180 n1_M2_111300_96180 0.988200
R10783 n1_M2_111300_96180 n1_M2_112380_96180 0.988200
R10784 n1_M2_112380_96180 n1_M2_113460_96180 0.988200
R10785 n1_M2_113460_96180 n1_M2_114540_96180 0.988200
R10786 n1_M2_114540_96180 n1_M2_115620_96180 0.988200
R10787 n1_M2_115620_96180 n1_M2_116700_96180 0.988200
R10788 n1_M2_116700_96180 n1_M2_117780_96180 0.988200
R10789 n1_M2_117780_96180 n1_M2_118860_96180 0.988200
R10790 n1_M2_118860_96180 n1_M2_119940_96180 0.988200
R10791 n1_M2_119940_96180 n1_M2_121020_96180 0.988200
R10792 n1_M2_121020_96180 n1_M2_122100_96180 0.988200
R10793 n1_M2_122100_96180 n1_M2_123180_96180 0.988200
R10794 n1_M2_123180_96180 n1_M2_124260_96180 0.988200
R10795 n1_M2_124260_96180 n1_M2_125340_96180 0.988200
R10796 n1_M2_125340_96180 n1_M2_126420_96180 0.988200
R10797 n1_M2_126420_96180 n1_M2_127500_96180 0.988200
R10798 n1_M2_127500_96180 n1_M2_128580_96180 0.988200
R10799 n1_M2_128580_96180 n1_M2_129660_96180 0.988200
R10800 n1_M2_60_97260 n1_M2_1140_97260 0.988200
R10801 n1_M2_1140_97260 n1_M2_2220_97260 0.988200
R10802 n1_M2_2220_97260 n1_M2_3300_97260 0.988200
R10803 n1_M2_3300_97260 n1_M2_4380_97260 0.988200
R10804 n1_M2_4380_97260 n1_M2_5460_97260 0.988200
R10805 n1_M2_5460_97260 n1_M2_6540_97260 0.988200
R10806 n1_M2_6540_97260 n1_M2_7620_97260 0.988200
R10807 n1_M2_7620_97260 n1_M2_8700_97260 0.988200
R10808 n1_M2_8700_97260 n1_M2_9780_97260 0.988200
R10809 n1_M2_9780_97260 n1_M2_10860_97260 0.988200
R10810 n1_M2_10860_97260 n1_M2_11940_97260 0.988200
R10811 n1_M2_11940_97260 n1_M2_13020_97260 0.988200
R10812 n1_M2_13020_97260 n1_M2_14100_97260 0.988200
R10813 n1_M2_14100_97260 n1_M2_15180_97260 0.988200
R10814 n1_M2_15180_97260 n1_M2_16260_97260 0.988200
R10815 n1_M2_16260_97260 n1_M2_17340_97260 0.988200
R10816 n1_M2_17340_97260 n1_M2_18420_97260 0.988200
R10817 n1_M2_18420_97260 n1_M2_19500_97260 0.988200
R10818 n1_M2_19500_97260 n1_M2_20580_97260 0.988200
R10819 n1_M2_20580_97260 n1_M2_21660_97260 0.988200
R10820 n1_M2_21660_97260 n1_M2_22740_97260 0.988200
R10821 n1_M2_22740_97260 n1_M2_23820_97260 0.988200
R10822 n1_M2_23820_97260 n1_M2_24900_97260 0.988200
R10823 n1_M2_24900_97260 n1_M2_25980_97260 0.988200
R10824 n1_M2_25980_97260 n1_M2_27060_97260 0.988200
R10825 n1_M2_27060_97260 n1_M2_28140_97260 0.988200
R10826 n1_M2_28140_97260 n1_M2_29220_97260 0.988200
R10827 n1_M2_29220_97260 n1_M2_30300_97260 0.988200
R10828 n1_M2_30300_97260 n1_M2_31380_97260 0.988200
R10829 n1_M2_31380_97260 n1_M2_32460_97260 0.988200
R10830 n1_M2_32460_97260 n1_M2_33540_97260 0.988200
R10831 n1_M2_33540_97260 n1_M2_34620_97260 0.988200
R10832 n1_M2_34620_97260 n1_M2_35700_97260 0.988200
R10833 n1_M2_35700_97260 n1_M2_36780_97260 0.988200
R10834 n1_M2_36780_97260 n1_M2_37860_97260 0.988200
R10835 n1_M2_37860_97260 n1_M2_38940_97260 0.988200
R10836 n1_M2_38940_97260 n1_M2_40020_97260 0.988200
R10837 n1_M2_40020_97260 n1_M2_41100_97260 0.988200
R10838 n1_M2_41100_97260 n1_M2_42180_97260 0.988200
R10839 n1_M2_42180_97260 n1_M2_43260_97260 0.988200
R10840 n1_M2_43260_97260 n1_M2_44340_97260 0.988200
R10841 n1_M2_44340_97260 n1_M2_45420_97260 0.988200
R10842 n1_M2_45420_97260 n1_M2_46500_97260 0.988200
R10843 n1_M2_46500_97260 n1_M2_47580_97260 0.988200
R10844 n1_M2_47580_97260 n1_M2_48660_97260 0.988200
R10845 n1_M2_48660_97260 n1_M2_49740_97260 0.988200
R10846 n1_M2_49740_97260 n1_M2_50820_97260 0.988200
R10847 n1_M2_50820_97260 n1_M2_51900_97260 0.988200
R10848 n1_M2_51900_97260 n1_M2_52980_97260 0.988200
R10849 n1_M2_52980_97260 n1_M2_54060_97260 0.988200
R10850 n1_M2_54060_97260 n1_M2_55140_97260 0.988200
R10851 n1_M2_55140_97260 n1_M2_56220_97260 0.988200
R10852 n1_M2_56220_97260 n1_M2_57300_97260 0.988200
R10853 n1_M2_57300_97260 n1_M2_58380_97260 0.988200
R10854 n1_M2_58380_97260 n1_M2_59460_97260 0.988200
R10855 n1_M2_59460_97260 n1_M2_60540_97260 0.988200
R10856 n1_M2_60540_97260 n1_M2_61620_97260 0.988200
R10857 n1_M2_61620_97260 n1_M2_62700_97260 0.988200
R10858 n1_M2_62700_97260 n1_M2_63780_97260 0.988200
R10859 n1_M2_63780_97260 n1_M2_64860_97260 0.988200
R10860 n1_M2_64860_97260 n1_M2_65940_97260 0.988200
R10861 n1_M2_65940_97260 n1_M2_67020_97260 0.988200
R10862 n1_M2_67020_97260 n1_M2_68100_97260 0.988200
R10863 n1_M2_68100_97260 n1_M2_69180_97260 0.988200
R10864 n1_M2_69180_97260 n1_M2_70260_97260 0.988200
R10865 n1_M2_70260_97260 n1_M2_71340_97260 0.988200
R10866 n1_M2_71340_97260 n1_M2_72420_97260 0.988200
R10867 n1_M2_72420_97260 n1_M2_73500_97260 0.988200
R10868 n1_M2_73500_97260 n1_M2_74580_97260 0.988200
R10869 n1_M2_74580_97260 n1_M2_75660_97260 0.988200
R10870 n1_M2_75660_97260 n1_M2_76740_97260 0.988200
R10871 n1_M2_76740_97260 n1_M2_77820_97260 0.988200
R10872 n1_M2_77820_97260 n1_M2_78900_97260 0.988200
R10873 n1_M2_78900_97260 n1_M2_79980_97260 0.988200
R10874 n1_M2_79980_97260 n1_M2_81060_97260 0.988200
R10875 n1_M2_81060_97260 n1_M2_82140_97260 0.988200
R10876 n1_M2_82140_97260 n1_M2_83220_97260 0.988200
R10877 n1_M2_83220_97260 n1_M2_84300_97260 0.988200
R10878 n1_M2_84300_97260 n1_M2_85380_97260 0.988200
R10879 n1_M2_85380_97260 n1_M2_86460_97260 0.988200
R10880 n1_M2_86460_97260 n1_M2_87540_97260 0.988200
R10881 n1_M2_87540_97260 n1_M2_88620_97260 0.988200
R10882 n1_M2_88620_97260 n1_M2_89700_97260 0.988200
R10883 n1_M2_89700_97260 n1_M2_90780_97260 0.988200
R10884 n1_M2_90780_97260 n1_M2_91860_97260 0.988200
R10885 n1_M2_91860_97260 n1_M2_92940_97260 0.988200
R10886 n1_M2_92940_97260 n1_M2_94020_97260 0.988200
R10887 n1_M2_94020_97260 n1_M2_95100_97260 0.988200
R10888 n1_M2_95100_97260 n1_M2_96180_97260 0.988200
R10889 n1_M2_96180_97260 n1_M2_97260_97260 0.988200
R10890 n1_M2_97260_97260 n1_M2_98340_97260 0.988200
R10891 n1_M2_98340_97260 n1_M2_99420_97260 0.988200
R10892 n1_M2_99420_97260 n1_M2_100500_97260 0.988200
R10893 n1_M2_100500_97260 n1_M2_101580_97260 0.988200
R10894 n1_M2_101580_97260 n1_M2_102660_97260 0.988200
R10895 n1_M2_102660_97260 n1_M2_103740_97260 0.988200
R10896 n1_M2_103740_97260 n1_M2_104820_97260 0.988200
R10897 n1_M2_104820_97260 n1_M2_105900_97260 0.988200
R10898 n1_M2_105900_97260 n1_M2_106980_97260 0.988200
R10899 n1_M2_106980_97260 n1_M2_108060_97260 0.988200
R10900 n1_M2_108060_97260 n1_M2_109140_97260 0.988200
R10901 n1_M2_109140_97260 n1_M2_110220_97260 0.988200
R10902 n1_M2_110220_97260 n1_M2_111300_97260 0.988200
R10903 n1_M2_111300_97260 n1_M2_112380_97260 0.988200
R10904 n1_M2_112380_97260 n1_M2_113460_97260 0.988200
R10905 n1_M2_113460_97260 n1_M2_114540_97260 0.988200
R10906 n1_M2_114540_97260 n1_M2_115620_97260 0.988200
R10907 n1_M2_115620_97260 n1_M2_116700_97260 0.988200
R10908 n1_M2_116700_97260 n1_M2_117780_97260 0.988200
R10909 n1_M2_117780_97260 n1_M2_118860_97260 0.988200
R10910 n1_M2_118860_97260 n1_M2_119940_97260 0.988200
R10911 n1_M2_119940_97260 n1_M2_121020_97260 0.988200
R10912 n1_M2_121020_97260 n1_M2_122100_97260 0.988200
R10913 n1_M2_122100_97260 n1_M2_123180_97260 0.988200
R10914 n1_M2_123180_97260 n1_M2_124260_97260 0.988200
R10915 n1_M2_124260_97260 n1_M2_125340_97260 0.988200
R10916 n1_M2_125340_97260 n1_M2_126420_97260 0.988200
R10917 n1_M2_126420_97260 n1_M2_127500_97260 0.988200
R10918 n1_M2_127500_97260 n1_M2_128580_97260 0.988200
R10919 n1_M2_128580_97260 n1_M2_129660_97260 0.988200
R10920 n1_M2_60_98340 n1_M2_1140_98340 0.988200
R10921 n1_M2_1140_98340 n1_M2_2220_98340 0.988200
R10922 n1_M2_2220_98340 n1_M2_3300_98340 0.988200
R10923 n1_M2_3300_98340 n1_M2_4380_98340 0.988200
R10924 n1_M2_4380_98340 n1_M2_5460_98340 0.988200
R10925 n1_M2_5460_98340 n1_M2_6540_98340 0.988200
R10926 n1_M2_6540_98340 n1_M2_7620_98340 0.988200
R10927 n1_M2_7620_98340 n1_M2_8700_98340 0.988200
R10928 n1_M2_8700_98340 n1_M2_9780_98340 0.988200
R10929 n1_M2_9780_98340 n1_M2_10860_98340 0.988200
R10930 n1_M2_10860_98340 n1_M2_11940_98340 0.988200
R10931 n1_M2_11940_98340 n1_M2_13020_98340 0.988200
R10932 n1_M2_13020_98340 n1_M2_14100_98340 0.988200
R10933 n1_M2_14100_98340 n1_M2_15180_98340 0.988200
R10934 n1_M2_15180_98340 n1_M2_16260_98340 0.988200
R10935 n1_M2_16260_98340 n1_M2_17340_98340 0.988200
R10936 n1_M2_17340_98340 n1_M2_18420_98340 0.988200
R10937 n1_M2_18420_98340 n1_M2_19500_98340 0.988200
R10938 n1_M2_19500_98340 n1_M2_20580_98340 0.988200
R10939 n1_M2_20580_98340 n1_M2_21660_98340 0.988200
R10940 n1_M2_21660_98340 n1_M2_22740_98340 0.988200
R10941 n1_M2_22740_98340 n1_M2_23820_98340 0.988200
R10942 n1_M2_23820_98340 n1_M2_24900_98340 0.988200
R10943 n1_M2_24900_98340 n1_M2_25980_98340 0.988200
R10944 n1_M2_25980_98340 n1_M2_27060_98340 0.988200
R10945 n1_M2_27060_98340 n1_M2_28140_98340 0.988200
R10946 n1_M2_28140_98340 n1_M2_29220_98340 0.988200
R10947 n1_M2_29220_98340 n1_M2_30300_98340 0.988200
R10948 n1_M2_30300_98340 n1_M2_31380_98340 0.988200
R10949 n1_M2_31380_98340 n1_M2_32460_98340 0.988200
R10950 n1_M2_32460_98340 n1_M2_33540_98340 0.988200
R10951 n1_M2_33540_98340 n1_M2_34620_98340 0.988200
R10952 n1_M2_34620_98340 n1_M2_35700_98340 0.988200
R10953 n1_M2_35700_98340 n1_M2_36780_98340 0.988200
R10954 n1_M2_36780_98340 n1_M2_37860_98340 0.988200
R10955 n1_M2_37860_98340 n1_M2_38940_98340 0.988200
R10956 n1_M2_38940_98340 n1_M2_40020_98340 0.988200
R10957 n1_M2_40020_98340 n1_M2_41100_98340 0.988200
R10958 n1_M2_41100_98340 n1_M2_42180_98340 0.988200
R10959 n1_M2_42180_98340 n1_M2_43260_98340 0.988200
R10960 n1_M2_43260_98340 n1_M2_44340_98340 0.988200
R10961 n1_M2_44340_98340 n1_M2_45420_98340 0.988200
R10962 n1_M2_45420_98340 n1_M2_46500_98340 0.988200
R10963 n1_M2_46500_98340 n1_M2_47580_98340 0.988200
R10964 n1_M2_47580_98340 n1_M2_48660_98340 0.988200
R10965 n1_M2_48660_98340 n1_M2_49740_98340 0.988200
R10966 n1_M2_49740_98340 n1_M2_50820_98340 0.988200
R10967 n1_M2_50820_98340 n1_M2_51900_98340 0.988200
R10968 n1_M2_51900_98340 n1_M2_52980_98340 0.988200
R10969 n1_M2_52980_98340 n1_M2_54060_98340 0.988200
R10970 n1_M2_54060_98340 n1_M2_55140_98340 0.988200
R10971 n1_M2_55140_98340 n1_M2_56220_98340 0.988200
R10972 n1_M2_56220_98340 n1_M2_57300_98340 0.988200
R10973 n1_M2_57300_98340 n1_M2_58380_98340 0.988200
R10974 n1_M2_58380_98340 n1_M2_59460_98340 0.988200
R10975 n1_M2_59460_98340 n1_M2_60540_98340 0.988200
R10976 n1_M2_60540_98340 n1_M2_61620_98340 0.988200
R10977 n1_M2_61620_98340 n1_M2_62700_98340 0.988200
R10978 n1_M2_62700_98340 n1_M2_63780_98340 0.988200
R10979 n1_M2_63780_98340 n1_M2_64860_98340 0.988200
R10980 n1_M2_64860_98340 n1_M2_65940_98340 0.988200
R10981 n1_M2_65940_98340 n1_M2_67020_98340 0.988200
R10982 n1_M2_67020_98340 n1_M2_68100_98340 0.988200
R10983 n1_M2_68100_98340 n1_M2_69180_98340 0.988200
R10984 n1_M2_69180_98340 n1_M2_70260_98340 0.988200
R10985 n1_M2_70260_98340 n1_M2_71340_98340 0.988200
R10986 n1_M2_71340_98340 n1_M2_72420_98340 0.988200
R10987 n1_M2_72420_98340 n1_M2_73500_98340 0.988200
R10988 n1_M2_73500_98340 n1_M2_74580_98340 0.988200
R10989 n1_M2_74580_98340 n1_M2_75660_98340 0.988200
R10990 n1_M2_75660_98340 n1_M2_76740_98340 0.988200
R10991 n1_M2_76740_98340 n1_M2_77820_98340 0.988200
R10992 n1_M2_77820_98340 n1_M2_78900_98340 0.988200
R10993 n1_M2_78900_98340 n1_M2_79980_98340 0.988200
R10994 n1_M2_79980_98340 n1_M2_81060_98340 0.988200
R10995 n1_M2_81060_98340 n1_M2_82140_98340 0.988200
R10996 n1_M2_82140_98340 n1_M2_83220_98340 0.988200
R10997 n1_M2_83220_98340 n1_M2_84300_98340 0.988200
R10998 n1_M2_84300_98340 n1_M2_85380_98340 0.988200
R10999 n1_M2_85380_98340 n1_M2_86460_98340 0.988200
R11000 n1_M2_86460_98340 n1_M2_87540_98340 0.988200
R11001 n1_M2_87540_98340 n1_M2_88620_98340 0.988200
R11002 n1_M2_88620_98340 n1_M2_89700_98340 0.988200
R11003 n1_M2_89700_98340 n1_M2_90780_98340 0.988200
R11004 n1_M2_90780_98340 n1_M2_91860_98340 0.988200
R11005 n1_M2_91860_98340 n1_M2_92940_98340 0.988200
R11006 n1_M2_92940_98340 n1_M2_94020_98340 0.988200
R11007 n1_M2_94020_98340 n1_M2_95100_98340 0.988200
R11008 n1_M2_95100_98340 n1_M2_96180_98340 0.988200
R11009 n1_M2_96180_98340 n1_M2_97260_98340 0.988200
R11010 n1_M2_97260_98340 n1_M2_98340_98340 0.988200
R11011 n1_M2_98340_98340 n1_M2_99420_98340 0.988200
R11012 n1_M2_99420_98340 n1_M2_100500_98340 0.988200
R11013 n1_M2_100500_98340 n1_M2_101580_98340 0.988200
R11014 n1_M2_101580_98340 n1_M2_102660_98340 0.988200
R11015 n1_M2_102660_98340 n1_M2_103740_98340 0.988200
R11016 n1_M2_103740_98340 n1_M2_104820_98340 0.988200
R11017 n1_M2_104820_98340 n1_M2_105900_98340 0.988200
R11018 n1_M2_105900_98340 n1_M2_106980_98340 0.988200
R11019 n1_M2_106980_98340 n1_M2_108060_98340 0.988200
R11020 n1_M2_108060_98340 n1_M2_109140_98340 0.988200
R11021 n1_M2_109140_98340 n1_M2_110220_98340 0.988200
R11022 n1_M2_110220_98340 n1_M2_111300_98340 0.988200
R11023 n1_M2_111300_98340 n1_M2_112380_98340 0.988200
R11024 n1_M2_112380_98340 n1_M2_113460_98340 0.988200
R11025 n1_M2_113460_98340 n1_M2_114540_98340 0.988200
R11026 n1_M2_114540_98340 n1_M2_115620_98340 0.988200
R11027 n1_M2_115620_98340 n1_M2_116700_98340 0.988200
R11028 n1_M2_116700_98340 n1_M2_117780_98340 0.988200
R11029 n1_M2_117780_98340 n1_M2_118860_98340 0.988200
R11030 n1_M2_118860_98340 n1_M2_119940_98340 0.988200
R11031 n1_M2_119940_98340 n1_M2_121020_98340 0.988200
R11032 n1_M2_121020_98340 n1_M2_122100_98340 0.988200
R11033 n1_M2_122100_98340 n1_M2_123180_98340 0.988200
R11034 n1_M2_123180_98340 n1_M2_124260_98340 0.988200
R11035 n1_M2_124260_98340 n1_M2_125340_98340 0.988200
R11036 n1_M2_125340_98340 n1_M2_126420_98340 0.988200
R11037 n1_M2_126420_98340 n1_M2_127500_98340 0.988200
R11038 n1_M2_127500_98340 n1_M2_128580_98340 0.988200
R11039 n1_M2_128580_98340 n1_M2_129660_98340 0.988200
R11040 n1_M2_60_99420 n1_M2_1140_99420 0.988200
R11041 n1_M2_1140_99420 n1_M2_2220_99420 0.988200
R11042 n1_M2_2220_99420 n1_M2_3300_99420 0.988200
R11043 n1_M2_3300_99420 n1_M2_4380_99420 0.988200
R11044 n1_M2_4380_99420 n1_M2_5460_99420 0.988200
R11045 n1_M2_5460_99420 n1_M2_6540_99420 0.988200
R11046 n1_M2_6540_99420 n1_M2_7620_99420 0.988200
R11047 n1_M2_7620_99420 n1_M2_8700_99420 0.988200
R11048 n1_M2_8700_99420 n1_M2_9780_99420 0.988200
R11049 n1_M2_9780_99420 n1_M2_10860_99420 0.988200
R11050 n1_M2_10860_99420 n1_M2_11940_99420 0.988200
R11051 n1_M2_11940_99420 n1_M2_13020_99420 0.988200
R11052 n1_M2_13020_99420 n1_M2_14100_99420 0.988200
R11053 n1_M2_14100_99420 n1_M2_15180_99420 0.988200
R11054 n1_M2_15180_99420 n1_M2_16260_99420 0.988200
R11055 n1_M2_16260_99420 n1_M2_17340_99420 0.988200
R11056 n1_M2_17340_99420 n1_M2_18420_99420 0.988200
R11057 n1_M2_18420_99420 n1_M2_19500_99420 0.988200
R11058 n1_M2_19500_99420 n1_M2_20580_99420 0.988200
R11059 n1_M2_20580_99420 n1_M2_21660_99420 0.988200
R11060 n1_M2_21660_99420 n1_M2_22740_99420 0.988200
R11061 n1_M2_22740_99420 n1_M2_23820_99420 0.988200
R11062 n1_M2_23820_99420 n1_M2_24900_99420 0.988200
R11063 n1_M2_24900_99420 n1_M2_25980_99420 0.988200
R11064 n1_M2_25980_99420 n1_M2_27060_99420 0.988200
R11065 n1_M2_27060_99420 n1_M2_28140_99420 0.988200
R11066 n1_M2_28140_99420 n1_M2_29220_99420 0.988200
R11067 n1_M2_29220_99420 n1_M2_30300_99420 0.988200
R11068 n1_M2_30300_99420 n1_M2_31380_99420 0.988200
R11069 n1_M2_31380_99420 n1_M2_32460_99420 0.988200
R11070 n1_M2_32460_99420 n1_M2_33540_99420 0.988200
R11071 n1_M2_33540_99420 n1_M2_34620_99420 0.988200
R11072 n1_M2_34620_99420 n1_M2_35700_99420 0.988200
R11073 n1_M2_35700_99420 n1_M2_36780_99420 0.988200
R11074 n1_M2_36780_99420 n1_M2_37860_99420 0.988200
R11075 n1_M2_37860_99420 n1_M2_38940_99420 0.988200
R11076 n1_M2_38940_99420 n1_M2_40020_99420 0.988200
R11077 n1_M2_40020_99420 n1_M2_41100_99420 0.988200
R11078 n1_M2_41100_99420 n1_M2_42180_99420 0.988200
R11079 n1_M2_42180_99420 n1_M2_43260_99420 0.988200
R11080 n1_M2_43260_99420 n1_M2_44340_99420 0.988200
R11081 n1_M2_44340_99420 n1_M2_45420_99420 0.988200
R11082 n1_M2_45420_99420 n1_M2_46500_99420 0.988200
R11083 n1_M2_46500_99420 n1_M2_47580_99420 0.988200
R11084 n1_M2_47580_99420 n1_M2_48660_99420 0.988200
R11085 n1_M2_48660_99420 n1_M2_49740_99420 0.988200
R11086 n1_M2_49740_99420 n1_M2_50820_99420 0.988200
R11087 n1_M2_50820_99420 n1_M2_51900_99420 0.988200
R11088 n1_M2_51900_99420 n1_M2_52980_99420 0.988200
R11089 n1_M2_52980_99420 n1_M2_54060_99420 0.988200
R11090 n1_M2_54060_99420 n1_M2_55140_99420 0.988200
R11091 n1_M2_55140_99420 n1_M2_56220_99420 0.988200
R11092 n1_M2_56220_99420 n1_M2_57300_99420 0.988200
R11093 n1_M2_57300_99420 n1_M2_58380_99420 0.988200
R11094 n1_M2_58380_99420 n1_M2_59460_99420 0.988200
R11095 n1_M2_59460_99420 n1_M2_60540_99420 0.988200
R11096 n1_M2_60540_99420 n1_M2_61620_99420 0.988200
R11097 n1_M2_61620_99420 n1_M2_62700_99420 0.988200
R11098 n1_M2_62700_99420 n1_M2_63780_99420 0.988200
R11099 n1_M2_63780_99420 n1_M2_64860_99420 0.988200
R11100 n1_M2_64860_99420 n1_M2_65940_99420 0.988200
R11101 n1_M2_65940_99420 n1_M2_67020_99420 0.988200
R11102 n1_M2_67020_99420 n1_M2_68100_99420 0.988200
R11103 n1_M2_68100_99420 n1_M2_69180_99420 0.988200
R11104 n1_M2_69180_99420 n1_M2_70260_99420 0.988200
R11105 n1_M2_70260_99420 n1_M2_71340_99420 0.988200
R11106 n1_M2_71340_99420 n1_M2_72420_99420 0.988200
R11107 n1_M2_72420_99420 n1_M2_73500_99420 0.988200
R11108 n1_M2_73500_99420 n1_M2_74580_99420 0.988200
R11109 n1_M2_74580_99420 n1_M2_75660_99420 0.988200
R11110 n1_M2_75660_99420 n1_M2_76740_99420 0.988200
R11111 n1_M2_76740_99420 n1_M2_77820_99420 0.988200
R11112 n1_M2_77820_99420 n1_M2_78900_99420 0.988200
R11113 n1_M2_78900_99420 n1_M2_79980_99420 0.988200
R11114 n1_M2_79980_99420 n1_M2_81060_99420 0.988200
R11115 n1_M2_81060_99420 n1_M2_82140_99420 0.988200
R11116 n1_M2_82140_99420 n1_M2_83220_99420 0.988200
R11117 n1_M2_83220_99420 n1_M2_84300_99420 0.988200
R11118 n1_M2_84300_99420 n1_M2_85380_99420 0.988200
R11119 n1_M2_85380_99420 n1_M2_86460_99420 0.988200
R11120 n1_M2_86460_99420 n1_M2_87540_99420 0.988200
R11121 n1_M2_87540_99420 n1_M2_88620_99420 0.988200
R11122 n1_M2_88620_99420 n1_M2_89700_99420 0.988200
R11123 n1_M2_89700_99420 n1_M2_90780_99420 0.988200
R11124 n1_M2_90780_99420 n1_M2_91860_99420 0.988200
R11125 n1_M2_91860_99420 n1_M2_92940_99420 0.988200
R11126 n1_M2_92940_99420 n1_M2_94020_99420 0.988200
R11127 n1_M2_94020_99420 n1_M2_95100_99420 0.988200
R11128 n1_M2_95100_99420 n1_M2_96180_99420 0.988200
R11129 n1_M2_96180_99420 n1_M2_97260_99420 0.988200
R11130 n1_M2_97260_99420 n1_M2_98340_99420 0.988200
R11131 n1_M2_98340_99420 n1_M2_99420_99420 0.988200
R11132 n1_M2_99420_99420 n1_M2_100500_99420 0.988200
R11133 n1_M2_100500_99420 n1_M2_101580_99420 0.988200
R11134 n1_M2_101580_99420 n1_M2_102660_99420 0.988200
R11135 n1_M2_102660_99420 n1_M2_103740_99420 0.988200
R11136 n1_M2_103740_99420 n1_M2_104820_99420 0.988200
R11137 n1_M2_104820_99420 n1_M2_105900_99420 0.988200
R11138 n1_M2_105900_99420 n1_M2_106980_99420 0.988200
R11139 n1_M2_106980_99420 n1_M2_108060_99420 0.988200
R11140 n1_M2_108060_99420 n1_M2_109140_99420 0.988200
R11141 n1_M2_109140_99420 n1_M2_110220_99420 0.988200
R11142 n1_M2_110220_99420 n1_M2_111300_99420 0.988200
R11143 n1_M2_111300_99420 n1_M2_112380_99420 0.988200
R11144 n1_M2_112380_99420 n1_M2_113460_99420 0.988200
R11145 n1_M2_113460_99420 n1_M2_114540_99420 0.988200
R11146 n1_M2_114540_99420 n1_M2_115620_99420 0.988200
R11147 n1_M2_115620_99420 n1_M2_116700_99420 0.988200
R11148 n1_M2_116700_99420 n1_M2_117780_99420 0.988200
R11149 n1_M2_117780_99420 n1_M2_118860_99420 0.988200
R11150 n1_M2_118860_99420 n1_M2_119940_99420 0.988200
R11151 n1_M2_119940_99420 n1_M2_121020_99420 0.988200
R11152 n1_M2_121020_99420 n1_M2_122100_99420 0.988200
R11153 n1_M2_122100_99420 n1_M2_123180_99420 0.988200
R11154 n1_M2_123180_99420 n1_M2_124260_99420 0.988200
R11155 n1_M2_124260_99420 n1_M2_125340_99420 0.988200
R11156 n1_M2_125340_99420 n1_M2_126420_99420 0.988200
R11157 n1_M2_126420_99420 n1_M2_127500_99420 0.988200
R11158 n1_M2_127500_99420 n1_M2_128580_99420 0.988200
R11159 n1_M2_128580_99420 n1_M2_129660_99420 0.988200
R11160 n1_M2_60_100500 n1_M2_1140_100500 0.988200
R11161 n1_M2_1140_100500 n1_M2_2220_100500 0.988200
R11162 n1_M2_2220_100500 n1_M2_3300_100500 0.988200
R11163 n1_M2_3300_100500 n1_M2_4380_100500 0.988200
R11164 n1_M2_4380_100500 n1_M2_5460_100500 0.988200
R11165 n1_M2_5460_100500 n1_M2_6540_100500 0.988200
R11166 n1_M2_6540_100500 n1_M2_7620_100500 0.988200
R11167 n1_M2_7620_100500 n1_M2_8700_100500 0.988200
R11168 n1_M2_8700_100500 n1_M2_9780_100500 0.988200
R11169 n1_M2_9780_100500 n1_M2_10860_100500 0.988200
R11170 n1_M2_10860_100500 n1_M2_11940_100500 0.988200
R11171 n1_M2_11940_100500 n1_M2_13020_100500 0.988200
R11172 n1_M2_13020_100500 n1_M2_14100_100500 0.988200
R11173 n1_M2_14100_100500 n1_M2_15180_100500 0.988200
R11174 n1_M2_15180_100500 n1_M2_16260_100500 0.988200
R11175 n1_M2_16260_100500 n1_M2_17340_100500 0.988200
R11176 n1_M2_17340_100500 n1_M2_18420_100500 0.988200
R11177 n1_M2_18420_100500 n1_M2_19500_100500 0.988200
R11178 n1_M2_19500_100500 n1_M2_20580_100500 0.988200
R11179 n1_M2_20580_100500 n1_M2_21660_100500 0.988200
R11180 n1_M2_21660_100500 n1_M2_22740_100500 0.988200
R11181 n1_M2_22740_100500 n1_M2_23820_100500 0.988200
R11182 n1_M2_23820_100500 n1_M2_24900_100500 0.988200
R11183 n1_M2_24900_100500 n1_M2_25980_100500 0.988200
R11184 n1_M2_25980_100500 n1_M2_27060_100500 0.988200
R11185 n1_M2_27060_100500 n1_M2_28140_100500 0.988200
R11186 n1_M2_28140_100500 n1_M2_29220_100500 0.988200
R11187 n1_M2_29220_100500 n1_M2_30300_100500 0.988200
R11188 n1_M2_30300_100500 n1_M2_31380_100500 0.988200
R11189 n1_M2_31380_100500 n1_M2_32460_100500 0.988200
R11190 n1_M2_32460_100500 n1_M2_33540_100500 0.988200
R11191 n1_M2_33540_100500 n1_M2_34620_100500 0.988200
R11192 n1_M2_34620_100500 n1_M2_35700_100500 0.988200
R11193 n1_M2_35700_100500 n1_M2_36780_100500 0.988200
R11194 n1_M2_36780_100500 n1_M2_37860_100500 0.988200
R11195 n1_M2_37860_100500 n1_M2_38940_100500 0.988200
R11196 n1_M2_38940_100500 n1_M2_40020_100500 0.988200
R11197 n1_M2_40020_100500 n1_M2_41100_100500 0.988200
R11198 n1_M2_41100_100500 n1_M2_42180_100500 0.988200
R11199 n1_M2_42180_100500 n1_M2_43260_100500 0.988200
R11200 n1_M2_43260_100500 n1_M2_44340_100500 0.988200
R11201 n1_M2_44340_100500 n1_M2_45420_100500 0.988200
R11202 n1_M2_45420_100500 n1_M2_46500_100500 0.988200
R11203 n1_M2_46500_100500 n1_M2_47580_100500 0.988200
R11204 n1_M2_47580_100500 n1_M2_48660_100500 0.988200
R11205 n1_M2_48660_100500 n1_M2_49740_100500 0.988200
R11206 n1_M2_49740_100500 n1_M2_50820_100500 0.988200
R11207 n1_M2_50820_100500 n1_M2_51900_100500 0.988200
R11208 n1_M2_51900_100500 n1_M2_52980_100500 0.988200
R11209 n1_M2_52980_100500 n1_M2_54060_100500 0.988200
R11210 n1_M2_54060_100500 n1_M2_55140_100500 0.988200
R11211 n1_M2_55140_100500 n1_M2_56220_100500 0.988200
R11212 n1_M2_56220_100500 n1_M2_57300_100500 0.988200
R11213 n1_M2_57300_100500 n1_M2_58380_100500 0.988200
R11214 n1_M2_58380_100500 n1_M2_59460_100500 0.988200
R11215 n1_M2_59460_100500 n1_M2_60540_100500 0.988200
R11216 n1_M2_60540_100500 n1_M2_61620_100500 0.988200
R11217 n1_M2_61620_100500 n1_M2_62700_100500 0.988200
R11218 n1_M2_62700_100500 n1_M2_63780_100500 0.988200
R11219 n1_M2_63780_100500 n1_M2_64860_100500 0.988200
R11220 n1_M2_64860_100500 n1_M2_65940_100500 0.988200
R11221 n1_M2_65940_100500 n1_M2_67020_100500 0.988200
R11222 n1_M2_67020_100500 n1_M2_68100_100500 0.988200
R11223 n1_M2_68100_100500 n1_M2_69180_100500 0.988200
R11224 n1_M2_69180_100500 n1_M2_70260_100500 0.988200
R11225 n1_M2_70260_100500 n1_M2_71340_100500 0.988200
R11226 n1_M2_71340_100500 n1_M2_72420_100500 0.988200
R11227 n1_M2_72420_100500 n1_M2_73500_100500 0.988200
R11228 n1_M2_73500_100500 n1_M2_74580_100500 0.988200
R11229 n1_M2_74580_100500 n1_M2_75660_100500 0.988200
R11230 n1_M2_75660_100500 n1_M2_76740_100500 0.988200
R11231 n1_M2_76740_100500 n1_M2_77820_100500 0.988200
R11232 n1_M2_77820_100500 n1_M2_78900_100500 0.988200
R11233 n1_M2_78900_100500 n1_M2_79980_100500 0.988200
R11234 n1_M2_79980_100500 n1_M2_81060_100500 0.988200
R11235 n1_M2_81060_100500 n1_M2_82140_100500 0.988200
R11236 n1_M2_82140_100500 n1_M2_83220_100500 0.988200
R11237 n1_M2_83220_100500 n1_M2_84300_100500 0.988200
R11238 n1_M2_84300_100500 n1_M2_85380_100500 0.988200
R11239 n1_M2_85380_100500 n1_M2_86460_100500 0.988200
R11240 n1_M2_86460_100500 n1_M2_87540_100500 0.988200
R11241 n1_M2_87540_100500 n1_M2_88620_100500 0.988200
R11242 n1_M2_88620_100500 n1_M2_89700_100500 0.988200
R11243 n1_M2_89700_100500 n1_M2_90780_100500 0.988200
R11244 n1_M2_90780_100500 n1_M2_91860_100500 0.988200
R11245 n1_M2_91860_100500 n1_M2_92940_100500 0.988200
R11246 n1_M2_92940_100500 n1_M2_94020_100500 0.988200
R11247 n1_M2_94020_100500 n1_M2_95100_100500 0.988200
R11248 n1_M2_95100_100500 n1_M2_96180_100500 0.988200
R11249 n1_M2_96180_100500 n1_M2_97260_100500 0.988200
R11250 n1_M2_97260_100500 n1_M2_98340_100500 0.988200
R11251 n1_M2_98340_100500 n1_M2_99420_100500 0.988200
R11252 n1_M2_99420_100500 n1_M2_100500_100500 0.988200
R11253 n1_M2_100500_100500 n1_M2_101580_100500 0.988200
R11254 n1_M2_101580_100500 n1_M2_102660_100500 0.988200
R11255 n1_M2_102660_100500 n1_M2_103740_100500 0.988200
R11256 n1_M2_103740_100500 n1_M2_104820_100500 0.988200
R11257 n1_M2_104820_100500 n1_M2_105900_100500 0.988200
R11258 n1_M2_105900_100500 n1_M2_106980_100500 0.988200
R11259 n1_M2_106980_100500 n1_M2_108060_100500 0.988200
R11260 n1_M2_108060_100500 n1_M2_109140_100500 0.988200
R11261 n1_M2_109140_100500 n1_M2_110220_100500 0.988200
R11262 n1_M2_110220_100500 n1_M2_111300_100500 0.988200
R11263 n1_M2_111300_100500 n1_M2_112380_100500 0.988200
R11264 n1_M2_112380_100500 n1_M2_113460_100500 0.988200
R11265 n1_M2_113460_100500 n1_M2_114540_100500 0.988200
R11266 n1_M2_114540_100500 n1_M2_115620_100500 0.988200
R11267 n1_M2_115620_100500 n1_M2_116700_100500 0.988200
R11268 n1_M2_116700_100500 n1_M2_117780_100500 0.988200
R11269 n1_M2_117780_100500 n1_M2_118860_100500 0.988200
R11270 n1_M2_118860_100500 n1_M2_119940_100500 0.988200
R11271 n1_M2_119940_100500 n1_M2_121020_100500 0.988200
R11272 n1_M2_121020_100500 n1_M2_122100_100500 0.988200
R11273 n1_M2_122100_100500 n1_M2_123180_100500 0.988200
R11274 n1_M2_123180_100500 n1_M2_124260_100500 0.988200
R11275 n1_M2_124260_100500 n1_M2_125340_100500 0.988200
R11276 n1_M2_125340_100500 n1_M2_126420_100500 0.988200
R11277 n1_M2_126420_100500 n1_M2_127500_100500 0.988200
R11278 n1_M2_127500_100500 n1_M2_128580_100500 0.988200
R11279 n1_M2_128580_100500 n1_M2_129660_100500 0.988200
R11280 n1_M2_60_101580 n1_M2_1140_101580 0.988200
R11281 n1_M2_1140_101580 n1_M2_2220_101580 0.988200
R11282 n1_M2_2220_101580 n1_M2_3300_101580 0.988200
R11283 n1_M2_3300_101580 n1_M2_4380_101580 0.988200
R11284 n1_M2_4380_101580 n1_M2_5460_101580 0.988200
R11285 n1_M2_5460_101580 n1_M2_6540_101580 0.988200
R11286 n1_M2_6540_101580 n1_M2_7620_101580 0.988200
R11287 n1_M2_7620_101580 n1_M2_8700_101580 0.988200
R11288 n1_M2_8700_101580 n1_M2_9780_101580 0.988200
R11289 n1_M2_9780_101580 n1_M2_10860_101580 0.988200
R11290 n1_M2_10860_101580 n1_M2_11940_101580 0.988200
R11291 n1_M2_11940_101580 n1_M2_13020_101580 0.988200
R11292 n1_M2_13020_101580 n1_M2_14100_101580 0.988200
R11293 n1_M2_14100_101580 n1_M2_15180_101580 0.988200
R11294 n1_M2_15180_101580 n1_M2_16260_101580 0.988200
R11295 n1_M2_16260_101580 n1_M2_17340_101580 0.988200
R11296 n1_M2_17340_101580 n1_M2_18420_101580 0.988200
R11297 n1_M2_18420_101580 n1_M2_19500_101580 0.988200
R11298 n1_M2_19500_101580 n1_M2_20580_101580 0.988200
R11299 n1_M2_20580_101580 n1_M2_21660_101580 0.988200
R11300 n1_M2_21660_101580 n1_M2_22740_101580 0.988200
R11301 n1_M2_22740_101580 n1_M2_23820_101580 0.988200
R11302 n1_M2_23820_101580 n1_M2_24900_101580 0.988200
R11303 n1_M2_24900_101580 n1_M2_25980_101580 0.988200
R11304 n1_M2_25980_101580 n1_M2_27060_101580 0.988200
R11305 n1_M2_27060_101580 n1_M2_28140_101580 0.988200
R11306 n1_M2_28140_101580 n1_M2_29220_101580 0.988200
R11307 n1_M2_29220_101580 n1_M2_30300_101580 0.988200
R11308 n1_M2_30300_101580 n1_M2_31380_101580 0.988200
R11309 n1_M2_31380_101580 n1_M2_32460_101580 0.988200
R11310 n1_M2_32460_101580 n1_M2_33540_101580 0.988200
R11311 n1_M2_33540_101580 n1_M2_34620_101580 0.988200
R11312 n1_M2_34620_101580 n1_M2_35700_101580 0.988200
R11313 n1_M2_35700_101580 n1_M2_36780_101580 0.988200
R11314 n1_M2_36780_101580 n1_M2_37860_101580 0.988200
R11315 n1_M2_37860_101580 n1_M2_38940_101580 0.988200
R11316 n1_M2_38940_101580 n1_M2_40020_101580 0.988200
R11317 n1_M2_40020_101580 n1_M2_41100_101580 0.988200
R11318 n1_M2_41100_101580 n1_M2_42180_101580 0.988200
R11319 n1_M2_42180_101580 n1_M2_43260_101580 0.988200
R11320 n1_M2_43260_101580 n1_M2_44340_101580 0.988200
R11321 n1_M2_44340_101580 n1_M2_45420_101580 0.988200
R11322 n1_M2_45420_101580 n1_M2_46500_101580 0.988200
R11323 n1_M2_46500_101580 n1_M2_47580_101580 0.988200
R11324 n1_M2_47580_101580 n1_M2_48660_101580 0.988200
R11325 n1_M2_48660_101580 n1_M2_49740_101580 0.988200
R11326 n1_M2_49740_101580 n1_M2_50820_101580 0.988200
R11327 n1_M2_50820_101580 n1_M2_51900_101580 0.988200
R11328 n1_M2_51900_101580 n1_M2_52980_101580 0.988200
R11329 n1_M2_52980_101580 n1_M2_54060_101580 0.988200
R11330 n1_M2_54060_101580 n1_M2_55140_101580 0.988200
R11331 n1_M2_55140_101580 n1_M2_56220_101580 0.988200
R11332 n1_M2_56220_101580 n1_M2_57300_101580 0.988200
R11333 n1_M2_57300_101580 n1_M2_58380_101580 0.988200
R11334 n1_M2_58380_101580 n1_M2_59460_101580 0.988200
R11335 n1_M2_59460_101580 n1_M2_60540_101580 0.988200
R11336 n1_M2_60540_101580 n1_M2_61620_101580 0.988200
R11337 n1_M2_61620_101580 n1_M2_62700_101580 0.988200
R11338 n1_M2_62700_101580 n1_M2_63780_101580 0.988200
R11339 n1_M2_63780_101580 n1_M2_64860_101580 0.988200
R11340 n1_M2_64860_101580 n1_M2_65940_101580 0.988200
R11341 n1_M2_65940_101580 n1_M2_67020_101580 0.988200
R11342 n1_M2_67020_101580 n1_M2_68100_101580 0.988200
R11343 n1_M2_68100_101580 n1_M2_69180_101580 0.988200
R11344 n1_M2_69180_101580 n1_M2_70260_101580 0.988200
R11345 n1_M2_70260_101580 n1_M2_71340_101580 0.988200
R11346 n1_M2_71340_101580 n1_M2_72420_101580 0.988200
R11347 n1_M2_72420_101580 n1_M2_73500_101580 0.988200
R11348 n1_M2_73500_101580 n1_M2_74580_101580 0.988200
R11349 n1_M2_74580_101580 n1_M2_75660_101580 0.988200
R11350 n1_M2_75660_101580 n1_M2_76740_101580 0.988200
R11351 n1_M2_76740_101580 n1_M2_77820_101580 0.988200
R11352 n1_M2_77820_101580 n1_M2_78900_101580 0.988200
R11353 n1_M2_78900_101580 n1_M2_79980_101580 0.988200
R11354 n1_M2_79980_101580 n1_M2_81060_101580 0.988200
R11355 n1_M2_81060_101580 n1_M2_82140_101580 0.988200
R11356 n1_M2_82140_101580 n1_M2_83220_101580 0.988200
R11357 n1_M2_83220_101580 n1_M2_84300_101580 0.988200
R11358 n1_M2_84300_101580 n1_M2_85380_101580 0.988200
R11359 n1_M2_85380_101580 n1_M2_86460_101580 0.988200
R11360 n1_M2_86460_101580 n1_M2_87540_101580 0.988200
R11361 n1_M2_87540_101580 n1_M2_88620_101580 0.988200
R11362 n1_M2_88620_101580 n1_M2_89700_101580 0.988200
R11363 n1_M2_89700_101580 n1_M2_90780_101580 0.988200
R11364 n1_M2_90780_101580 n1_M2_91860_101580 0.988200
R11365 n1_M2_91860_101580 n1_M2_92940_101580 0.988200
R11366 n1_M2_92940_101580 n1_M2_94020_101580 0.988200
R11367 n1_M2_94020_101580 n1_M2_95100_101580 0.988200
R11368 n1_M2_95100_101580 n1_M2_96180_101580 0.988200
R11369 n1_M2_96180_101580 n1_M2_97260_101580 0.988200
R11370 n1_M2_97260_101580 n1_M2_98340_101580 0.988200
R11371 n1_M2_98340_101580 n1_M2_99420_101580 0.988200
R11372 n1_M2_99420_101580 n1_M2_100500_101580 0.988200
R11373 n1_M2_100500_101580 n1_M2_101580_101580 0.988200
R11374 n1_M2_101580_101580 n1_M2_102660_101580 0.988200
R11375 n1_M2_102660_101580 n1_M2_103740_101580 0.988200
R11376 n1_M2_103740_101580 n1_M2_104820_101580 0.988200
R11377 n1_M2_104820_101580 n1_M2_105900_101580 0.988200
R11378 n1_M2_105900_101580 n1_M2_106980_101580 0.988200
R11379 n1_M2_106980_101580 n1_M2_108060_101580 0.988200
R11380 n1_M2_108060_101580 n1_M2_109140_101580 0.988200
R11381 n1_M2_109140_101580 n1_M2_110220_101580 0.988200
R11382 n1_M2_110220_101580 n1_M2_111300_101580 0.988200
R11383 n1_M2_111300_101580 n1_M2_112380_101580 0.988200
R11384 n1_M2_112380_101580 n1_M2_113460_101580 0.988200
R11385 n1_M2_113460_101580 n1_M2_114540_101580 0.988200
R11386 n1_M2_114540_101580 n1_M2_115620_101580 0.988200
R11387 n1_M2_115620_101580 n1_M2_116700_101580 0.988200
R11388 n1_M2_116700_101580 n1_M2_117780_101580 0.988200
R11389 n1_M2_117780_101580 n1_M2_118860_101580 0.988200
R11390 n1_M2_118860_101580 n1_M2_119940_101580 0.988200
R11391 n1_M2_119940_101580 n1_M2_121020_101580 0.988200
R11392 n1_M2_121020_101580 n1_M2_122100_101580 0.988200
R11393 n1_M2_122100_101580 n1_M2_123180_101580 0.988200
R11394 n1_M2_123180_101580 n1_M2_124260_101580 0.988200
R11395 n1_M2_124260_101580 n1_M2_125340_101580 0.988200
R11396 n1_M2_125340_101580 n1_M2_126420_101580 0.988200
R11397 n1_M2_126420_101580 n1_M2_127500_101580 0.988200
R11398 n1_M2_127500_101580 n1_M2_128580_101580 0.988200
R11399 n1_M2_128580_101580 n1_M2_129660_101580 0.988200
R11400 n1_M2_60_102660 n1_M2_1140_102660 0.988200
R11401 n1_M2_1140_102660 n1_M2_2220_102660 0.988200
R11402 n1_M2_2220_102660 n1_M2_3300_102660 0.988200
R11403 n1_M2_3300_102660 n1_M2_4380_102660 0.988200
R11404 n1_M2_4380_102660 n1_M2_5460_102660 0.988200
R11405 n1_M2_5460_102660 n1_M2_6540_102660 0.988200
R11406 n1_M2_6540_102660 n1_M2_7620_102660 0.988200
R11407 n1_M2_7620_102660 n1_M2_8700_102660 0.988200
R11408 n1_M2_8700_102660 n1_M2_9780_102660 0.988200
R11409 n1_M2_9780_102660 n1_M2_10860_102660 0.988200
R11410 n1_M2_10860_102660 n1_M2_11940_102660 0.988200
R11411 n1_M2_11940_102660 n1_M2_13020_102660 0.988200
R11412 n1_M2_13020_102660 n1_M2_14100_102660 0.988200
R11413 n1_M2_14100_102660 n1_M2_15180_102660 0.988200
R11414 n1_M2_15180_102660 n1_M2_16260_102660 0.988200
R11415 n1_M2_16260_102660 n1_M2_17340_102660 0.988200
R11416 n1_M2_17340_102660 n1_M2_18420_102660 0.988200
R11417 n1_M2_18420_102660 n1_M2_19500_102660 0.988200
R11418 n1_M2_19500_102660 n1_M2_20580_102660 0.988200
R11419 n1_M2_20580_102660 n1_M2_21660_102660 0.988200
R11420 n1_M2_21660_102660 n1_M2_22740_102660 0.988200
R11421 n1_M2_22740_102660 n1_M2_23820_102660 0.988200
R11422 n1_M2_23820_102660 n1_M2_24900_102660 0.988200
R11423 n1_M2_24900_102660 n1_M2_25980_102660 0.988200
R11424 n1_M2_25980_102660 n1_M2_27060_102660 0.988200
R11425 n1_M2_27060_102660 n1_M2_28140_102660 0.988200
R11426 n1_M2_28140_102660 n1_M2_29220_102660 0.988200
R11427 n1_M2_29220_102660 n1_M2_30300_102660 0.988200
R11428 n1_M2_30300_102660 n1_M2_31380_102660 0.988200
R11429 n1_M2_31380_102660 n1_M2_32460_102660 0.988200
R11430 n1_M2_32460_102660 n1_M2_33540_102660 0.988200
R11431 n1_M2_33540_102660 n1_M2_34620_102660 0.988200
R11432 n1_M2_34620_102660 n1_M2_35700_102660 0.988200
R11433 n1_M2_35700_102660 n1_M2_36780_102660 0.988200
R11434 n1_M2_36780_102660 n1_M2_37860_102660 0.988200
R11435 n1_M2_37860_102660 n1_M2_38940_102660 0.988200
R11436 n1_M2_38940_102660 n1_M2_40020_102660 0.988200
R11437 n1_M2_40020_102660 n1_M2_41100_102660 0.988200
R11438 n1_M2_41100_102660 n1_M2_42180_102660 0.988200
R11439 n1_M2_42180_102660 n1_M2_43260_102660 0.988200
R11440 n1_M2_43260_102660 n1_M2_44340_102660 0.988200
R11441 n1_M2_44340_102660 n1_M2_45420_102660 0.988200
R11442 n1_M2_45420_102660 n1_M2_46500_102660 0.988200
R11443 n1_M2_46500_102660 n1_M2_47580_102660 0.988200
R11444 n1_M2_47580_102660 n1_M2_48660_102660 0.988200
R11445 n1_M2_48660_102660 n1_M2_49740_102660 0.988200
R11446 n1_M2_49740_102660 n1_M2_50820_102660 0.988200
R11447 n1_M2_50820_102660 n1_M2_51900_102660 0.988200
R11448 n1_M2_51900_102660 n1_M2_52980_102660 0.988200
R11449 n1_M2_52980_102660 n1_M2_54060_102660 0.988200
R11450 n1_M2_54060_102660 n1_M2_55140_102660 0.988200
R11451 n1_M2_55140_102660 n1_M2_56220_102660 0.988200
R11452 n1_M2_56220_102660 n1_M2_57300_102660 0.988200
R11453 n1_M2_57300_102660 n1_M2_58380_102660 0.988200
R11454 n1_M2_58380_102660 n1_M2_59460_102660 0.988200
R11455 n1_M2_59460_102660 n1_M2_60540_102660 0.988200
R11456 n1_M2_60540_102660 n1_M2_61620_102660 0.988200
R11457 n1_M2_61620_102660 n1_M2_62700_102660 0.988200
R11458 n1_M2_62700_102660 n1_M2_63780_102660 0.988200
R11459 n1_M2_63780_102660 n1_M2_64860_102660 0.988200
R11460 n1_M2_64860_102660 n1_M2_65940_102660 0.988200
R11461 n1_M2_65940_102660 n1_M2_67020_102660 0.988200
R11462 n1_M2_67020_102660 n1_M2_68100_102660 0.988200
R11463 n1_M2_68100_102660 n1_M2_69180_102660 0.988200
R11464 n1_M2_69180_102660 n1_M2_70260_102660 0.988200
R11465 n1_M2_70260_102660 n1_M2_71340_102660 0.988200
R11466 n1_M2_71340_102660 n1_M2_72420_102660 0.988200
R11467 n1_M2_72420_102660 n1_M2_73500_102660 0.988200
R11468 n1_M2_73500_102660 n1_M2_74580_102660 0.988200
R11469 n1_M2_74580_102660 n1_M2_75660_102660 0.988200
R11470 n1_M2_75660_102660 n1_M2_76740_102660 0.988200
R11471 n1_M2_76740_102660 n1_M2_77820_102660 0.988200
R11472 n1_M2_77820_102660 n1_M2_78900_102660 0.988200
R11473 n1_M2_78900_102660 n1_M2_79980_102660 0.988200
R11474 n1_M2_79980_102660 n1_M2_81060_102660 0.988200
R11475 n1_M2_81060_102660 n1_M2_82140_102660 0.988200
R11476 n1_M2_82140_102660 n1_M2_83220_102660 0.988200
R11477 n1_M2_83220_102660 n1_M2_84300_102660 0.988200
R11478 n1_M2_84300_102660 n1_M2_85380_102660 0.988200
R11479 n1_M2_85380_102660 n1_M2_86460_102660 0.988200
R11480 n1_M2_86460_102660 n1_M2_87540_102660 0.988200
R11481 n1_M2_87540_102660 n1_M2_88620_102660 0.988200
R11482 n1_M2_88620_102660 n1_M2_89700_102660 0.988200
R11483 n1_M2_89700_102660 n1_M2_90780_102660 0.988200
R11484 n1_M2_90780_102660 n1_M2_91860_102660 0.988200
R11485 n1_M2_91860_102660 n1_M2_92940_102660 0.988200
R11486 n1_M2_92940_102660 n1_M2_94020_102660 0.988200
R11487 n1_M2_94020_102660 n1_M2_95100_102660 0.988200
R11488 n1_M2_95100_102660 n1_M2_96180_102660 0.988200
R11489 n1_M2_96180_102660 n1_M2_97260_102660 0.988200
R11490 n1_M2_97260_102660 n1_M2_98340_102660 0.988200
R11491 n1_M2_98340_102660 n1_M2_99420_102660 0.988200
R11492 n1_M2_99420_102660 n1_M2_100500_102660 0.988200
R11493 n1_M2_100500_102660 n1_M2_101580_102660 0.988200
R11494 n1_M2_101580_102660 n1_M2_102660_102660 0.988200
R11495 n1_M2_102660_102660 n1_M2_103740_102660 0.988200
R11496 n1_M2_103740_102660 n1_M2_104820_102660 0.988200
R11497 n1_M2_104820_102660 n1_M2_105900_102660 0.988200
R11498 n1_M2_105900_102660 n1_M2_106980_102660 0.988200
R11499 n1_M2_106980_102660 n1_M2_108060_102660 0.988200
R11500 n1_M2_108060_102660 n1_M2_109140_102660 0.988200
R11501 n1_M2_109140_102660 n1_M2_110220_102660 0.988200
R11502 n1_M2_110220_102660 n1_M2_111300_102660 0.988200
R11503 n1_M2_111300_102660 n1_M2_112380_102660 0.988200
R11504 n1_M2_112380_102660 n1_M2_113460_102660 0.988200
R11505 n1_M2_113460_102660 n1_M2_114540_102660 0.988200
R11506 n1_M2_114540_102660 n1_M2_115620_102660 0.988200
R11507 n1_M2_115620_102660 n1_M2_116700_102660 0.988200
R11508 n1_M2_116700_102660 n1_M2_117780_102660 0.988200
R11509 n1_M2_117780_102660 n1_M2_118860_102660 0.988200
R11510 n1_M2_118860_102660 n1_M2_119940_102660 0.988200
R11511 n1_M2_119940_102660 n1_M2_121020_102660 0.988200
R11512 n1_M2_121020_102660 n1_M2_122100_102660 0.988200
R11513 n1_M2_122100_102660 n1_M2_123180_102660 0.988200
R11514 n1_M2_123180_102660 n1_M2_124260_102660 0.988200
R11515 n1_M2_124260_102660 n1_M2_125340_102660 0.988200
R11516 n1_M2_125340_102660 n1_M2_126420_102660 0.988200
R11517 n1_M2_126420_102660 n1_M2_127500_102660 0.988200
R11518 n1_M2_127500_102660 n1_M2_128580_102660 0.988200
R11519 n1_M2_128580_102660 n1_M2_129660_102660 0.988200
R11520 n1_M2_60_103740 n1_M2_1140_103740 0.988200
R11521 n1_M2_1140_103740 n1_M2_2220_103740 0.988200
R11522 n1_M2_2220_103740 n1_M2_3300_103740 0.988200
R11523 n1_M2_3300_103740 n1_M2_4380_103740 0.988200
R11524 n1_M2_4380_103740 n1_M2_5460_103740 0.988200
R11525 n1_M2_5460_103740 n1_M2_6540_103740 0.988200
R11526 n1_M2_6540_103740 n1_M2_7620_103740 0.988200
R11527 n1_M2_7620_103740 n1_M2_8700_103740 0.988200
R11528 n1_M2_8700_103740 n1_M2_9780_103740 0.988200
R11529 n1_M2_9780_103740 n1_M2_10860_103740 0.988200
R11530 n1_M2_10860_103740 n1_M2_11940_103740 0.988200
R11531 n1_M2_11940_103740 n1_M2_13020_103740 0.988200
R11532 n1_M2_13020_103740 n1_M2_14100_103740 0.988200
R11533 n1_M2_14100_103740 n1_M2_15180_103740 0.988200
R11534 n1_M2_15180_103740 n1_M2_16260_103740 0.988200
R11535 n1_M2_16260_103740 n1_M2_17340_103740 0.988200
R11536 n1_M2_17340_103740 n1_M2_18420_103740 0.988200
R11537 n1_M2_18420_103740 n1_M2_19500_103740 0.988200
R11538 n1_M2_19500_103740 n1_M2_20580_103740 0.988200
R11539 n1_M2_20580_103740 n1_M2_21660_103740 0.988200
R11540 n1_M2_21660_103740 n1_M2_22740_103740 0.988200
R11541 n1_M2_22740_103740 n1_M2_23820_103740 0.988200
R11542 n1_M2_23820_103740 n1_M2_24900_103740 0.988200
R11543 n1_M2_24900_103740 n1_M2_25980_103740 0.988200
R11544 n1_M2_25980_103740 n1_M2_27060_103740 0.988200
R11545 n1_M2_27060_103740 n1_M2_28140_103740 0.988200
R11546 n1_M2_28140_103740 n1_M2_29220_103740 0.988200
R11547 n1_M2_29220_103740 n1_M2_30300_103740 0.988200
R11548 n1_M2_30300_103740 n1_M2_31380_103740 0.988200
R11549 n1_M2_31380_103740 n1_M2_32460_103740 0.988200
R11550 n1_M2_32460_103740 n1_M2_33540_103740 0.988200
R11551 n1_M2_33540_103740 n1_M2_34620_103740 0.988200
R11552 n1_M2_34620_103740 n1_M2_35700_103740 0.988200
R11553 n1_M2_35700_103740 n1_M2_36780_103740 0.988200
R11554 n1_M2_36780_103740 n1_M2_37860_103740 0.988200
R11555 n1_M2_37860_103740 n1_M2_38940_103740 0.988200
R11556 n1_M2_38940_103740 n1_M2_40020_103740 0.988200
R11557 n1_M2_40020_103740 n1_M2_41100_103740 0.988200
R11558 n1_M2_41100_103740 n1_M2_42180_103740 0.988200
R11559 n1_M2_42180_103740 n1_M2_43260_103740 0.988200
R11560 n1_M2_43260_103740 n1_M2_44340_103740 0.988200
R11561 n1_M2_44340_103740 n1_M2_45420_103740 0.988200
R11562 n1_M2_45420_103740 n1_M2_46500_103740 0.988200
R11563 n1_M2_46500_103740 n1_M2_47580_103740 0.988200
R11564 n1_M2_47580_103740 n1_M2_48660_103740 0.988200
R11565 n1_M2_48660_103740 n1_M2_49740_103740 0.988200
R11566 n1_M2_49740_103740 n1_M2_50820_103740 0.988200
R11567 n1_M2_50820_103740 n1_M2_51900_103740 0.988200
R11568 n1_M2_51900_103740 n1_M2_52980_103740 0.988200
R11569 n1_M2_52980_103740 n1_M2_54060_103740 0.988200
R11570 n1_M2_54060_103740 n1_M2_55140_103740 0.988200
R11571 n1_M2_55140_103740 n1_M2_56220_103740 0.988200
R11572 n1_M2_56220_103740 n1_M2_57300_103740 0.988200
R11573 n1_M2_57300_103740 n1_M2_58380_103740 0.988200
R11574 n1_M2_58380_103740 n1_M2_59460_103740 0.988200
R11575 n1_M2_59460_103740 n1_M2_60540_103740 0.988200
R11576 n1_M2_60540_103740 n1_M2_61620_103740 0.988200
R11577 n1_M2_61620_103740 n1_M2_62700_103740 0.988200
R11578 n1_M2_62700_103740 n1_M2_63780_103740 0.988200
R11579 n1_M2_63780_103740 n1_M2_64860_103740 0.988200
R11580 n1_M2_64860_103740 n1_M2_65940_103740 0.988200
R11581 n1_M2_65940_103740 n1_M2_67020_103740 0.988200
R11582 n1_M2_67020_103740 n1_M2_68100_103740 0.988200
R11583 n1_M2_68100_103740 n1_M2_69180_103740 0.988200
R11584 n1_M2_69180_103740 n1_M2_70260_103740 0.988200
R11585 n1_M2_70260_103740 n1_M2_71340_103740 0.988200
R11586 n1_M2_71340_103740 n1_M2_72420_103740 0.988200
R11587 n1_M2_72420_103740 n1_M2_73500_103740 0.988200
R11588 n1_M2_73500_103740 n1_M2_74580_103740 0.988200
R11589 n1_M2_74580_103740 n1_M2_75660_103740 0.988200
R11590 n1_M2_75660_103740 n1_M2_76740_103740 0.988200
R11591 n1_M2_76740_103740 n1_M2_77820_103740 0.988200
R11592 n1_M2_77820_103740 n1_M2_78900_103740 0.988200
R11593 n1_M2_78900_103740 n1_M2_79980_103740 0.988200
R11594 n1_M2_79980_103740 n1_M2_81060_103740 0.988200
R11595 n1_M2_81060_103740 n1_M2_82140_103740 0.988200
R11596 n1_M2_82140_103740 n1_M2_83220_103740 0.988200
R11597 n1_M2_83220_103740 n1_M2_84300_103740 0.988200
R11598 n1_M2_84300_103740 n1_M2_85380_103740 0.988200
R11599 n1_M2_85380_103740 n1_M2_86460_103740 0.988200
R11600 n1_M2_86460_103740 n1_M2_87540_103740 0.988200
R11601 n1_M2_87540_103740 n1_M2_88620_103740 0.988200
R11602 n1_M2_88620_103740 n1_M2_89700_103740 0.988200
R11603 n1_M2_89700_103740 n1_M2_90780_103740 0.988200
R11604 n1_M2_90780_103740 n1_M2_91860_103740 0.988200
R11605 n1_M2_91860_103740 n1_M2_92940_103740 0.988200
R11606 n1_M2_92940_103740 n1_M2_94020_103740 0.988200
R11607 n1_M2_94020_103740 n1_M2_95100_103740 0.988200
R11608 n1_M2_95100_103740 n1_M2_96180_103740 0.988200
R11609 n1_M2_96180_103740 n1_M2_97260_103740 0.988200
R11610 n1_M2_97260_103740 n1_M2_98340_103740 0.988200
R11611 n1_M2_98340_103740 n1_M2_99420_103740 0.988200
R11612 n1_M2_99420_103740 n1_M2_100500_103740 0.988200
R11613 n1_M2_100500_103740 n1_M2_101580_103740 0.988200
R11614 n1_M2_101580_103740 n1_M2_102660_103740 0.988200
R11615 n1_M2_102660_103740 n1_M2_103740_103740 0.988200
R11616 n1_M2_103740_103740 n1_M2_104820_103740 0.988200
R11617 n1_M2_104820_103740 n1_M2_105900_103740 0.988200
R11618 n1_M2_105900_103740 n1_M2_106980_103740 0.988200
R11619 n1_M2_106980_103740 n1_M2_108060_103740 0.988200
R11620 n1_M2_108060_103740 n1_M2_109140_103740 0.988200
R11621 n1_M2_109140_103740 n1_M2_110220_103740 0.988200
R11622 n1_M2_110220_103740 n1_M2_111300_103740 0.988200
R11623 n1_M2_111300_103740 n1_M2_112380_103740 0.988200
R11624 n1_M2_112380_103740 n1_M2_113460_103740 0.988200
R11625 n1_M2_113460_103740 n1_M2_114540_103740 0.988200
R11626 n1_M2_114540_103740 n1_M2_115620_103740 0.988200
R11627 n1_M2_115620_103740 n1_M2_116700_103740 0.988200
R11628 n1_M2_116700_103740 n1_M2_117780_103740 0.988200
R11629 n1_M2_117780_103740 n1_M2_118860_103740 0.988200
R11630 n1_M2_118860_103740 n1_M2_119940_103740 0.988200
R11631 n1_M2_119940_103740 n1_M2_121020_103740 0.988200
R11632 n1_M2_121020_103740 n1_M2_122100_103740 0.988200
R11633 n1_M2_122100_103740 n1_M2_123180_103740 0.988200
R11634 n1_M2_123180_103740 n1_M2_124260_103740 0.988200
R11635 n1_M2_124260_103740 n1_M2_125340_103740 0.988200
R11636 n1_M2_125340_103740 n1_M2_126420_103740 0.988200
R11637 n1_M2_126420_103740 n1_M2_127500_103740 0.988200
R11638 n1_M2_127500_103740 n1_M2_128580_103740 0.988200
R11639 n1_M2_128580_103740 n1_M2_129660_103740 0.988200
R11640 n1_M2_60_104820 n1_M2_1140_104820 0.988200
R11641 n1_M2_1140_104820 n1_M2_2220_104820 0.988200
R11642 n1_M2_2220_104820 n1_M2_3300_104820 0.988200
R11643 n1_M2_3300_104820 n1_M2_4380_104820 0.988200
R11644 n1_M2_4380_104820 n1_M2_5460_104820 0.988200
R11645 n1_M2_5460_104820 n1_M2_6540_104820 0.988200
R11646 n1_M2_6540_104820 n1_M2_7620_104820 0.988200
R11647 n1_M2_7620_104820 n1_M2_8700_104820 0.988200
R11648 n1_M2_8700_104820 n1_M2_9780_104820 0.988200
R11649 n1_M2_9780_104820 n1_M2_10860_104820 0.988200
R11650 n1_M2_10860_104820 n1_M2_11940_104820 0.988200
R11651 n1_M2_11940_104820 n1_M2_13020_104820 0.988200
R11652 n1_M2_13020_104820 n1_M2_14100_104820 0.988200
R11653 n1_M2_14100_104820 n1_M2_15180_104820 0.988200
R11654 n1_M2_15180_104820 n1_M2_16260_104820 0.988200
R11655 n1_M2_16260_104820 n1_M2_17340_104820 0.988200
R11656 n1_M2_17340_104820 n1_M2_18420_104820 0.988200
R11657 n1_M2_18420_104820 n1_M2_19500_104820 0.988200
R11658 n1_M2_19500_104820 n1_M2_20580_104820 0.988200
R11659 n1_M2_20580_104820 n1_M2_21660_104820 0.988200
R11660 n1_M2_21660_104820 n1_M2_22740_104820 0.988200
R11661 n1_M2_22740_104820 n1_M2_23820_104820 0.988200
R11662 n1_M2_23820_104820 n1_M2_24900_104820 0.988200
R11663 n1_M2_24900_104820 n1_M2_25980_104820 0.988200
R11664 n1_M2_25980_104820 n1_M2_27060_104820 0.988200
R11665 n1_M2_27060_104820 n1_M2_28140_104820 0.988200
R11666 n1_M2_28140_104820 n1_M2_29220_104820 0.988200
R11667 n1_M2_29220_104820 n1_M2_30300_104820 0.988200
R11668 n1_M2_30300_104820 n1_M2_31380_104820 0.988200
R11669 n1_M2_31380_104820 n1_M2_32460_104820 0.988200
R11670 n1_M2_32460_104820 n1_M2_33540_104820 0.988200
R11671 n1_M2_33540_104820 n1_M2_34620_104820 0.988200
R11672 n1_M2_34620_104820 n1_M2_35700_104820 0.988200
R11673 n1_M2_35700_104820 n1_M2_36780_104820 0.988200
R11674 n1_M2_36780_104820 n1_M2_37860_104820 0.988200
R11675 n1_M2_37860_104820 n1_M2_38940_104820 0.988200
R11676 n1_M2_38940_104820 n1_M2_40020_104820 0.988200
R11677 n1_M2_40020_104820 n1_M2_41100_104820 0.988200
R11678 n1_M2_41100_104820 n1_M2_42180_104820 0.988200
R11679 n1_M2_42180_104820 n1_M2_43260_104820 0.988200
R11680 n1_M2_43260_104820 n1_M2_44340_104820 0.988200
R11681 n1_M2_44340_104820 n1_M2_45420_104820 0.988200
R11682 n1_M2_45420_104820 n1_M2_46500_104820 0.988200
R11683 n1_M2_46500_104820 n1_M2_47580_104820 0.988200
R11684 n1_M2_47580_104820 n1_M2_48660_104820 0.988200
R11685 n1_M2_48660_104820 n1_M2_49740_104820 0.988200
R11686 n1_M2_49740_104820 n1_M2_50820_104820 0.988200
R11687 n1_M2_50820_104820 n1_M2_51900_104820 0.988200
R11688 n1_M2_51900_104820 n1_M2_52980_104820 0.988200
R11689 n1_M2_52980_104820 n1_M2_54060_104820 0.988200
R11690 n1_M2_54060_104820 n1_M2_55140_104820 0.988200
R11691 n1_M2_55140_104820 n1_M2_56220_104820 0.988200
R11692 n1_M2_56220_104820 n1_M2_57300_104820 0.988200
R11693 n1_M2_57300_104820 n1_M2_58380_104820 0.988200
R11694 n1_M2_58380_104820 n1_M2_59460_104820 0.988200
R11695 n1_M2_59460_104820 n1_M2_60540_104820 0.988200
R11696 n1_M2_60540_104820 n1_M2_61620_104820 0.988200
R11697 n1_M2_61620_104820 n1_M2_62700_104820 0.988200
R11698 n1_M2_62700_104820 n1_M2_63780_104820 0.988200
R11699 n1_M2_63780_104820 n1_M2_64860_104820 0.988200
R11700 n1_M2_64860_104820 n1_M2_65940_104820 0.988200
R11701 n1_M2_65940_104820 n1_M2_67020_104820 0.988200
R11702 n1_M2_67020_104820 n1_M2_68100_104820 0.988200
R11703 n1_M2_68100_104820 n1_M2_69180_104820 0.988200
R11704 n1_M2_69180_104820 n1_M2_70260_104820 0.988200
R11705 n1_M2_70260_104820 n1_M2_71340_104820 0.988200
R11706 n1_M2_71340_104820 n1_M2_72420_104820 0.988200
R11707 n1_M2_72420_104820 n1_M2_73500_104820 0.988200
R11708 n1_M2_73500_104820 n1_M2_74580_104820 0.988200
R11709 n1_M2_74580_104820 n1_M2_75660_104820 0.988200
R11710 n1_M2_75660_104820 n1_M2_76740_104820 0.988200
R11711 n1_M2_76740_104820 n1_M2_77820_104820 0.988200
R11712 n1_M2_77820_104820 n1_M2_78900_104820 0.988200
R11713 n1_M2_78900_104820 n1_M2_79980_104820 0.988200
R11714 n1_M2_79980_104820 n1_M2_81060_104820 0.988200
R11715 n1_M2_81060_104820 n1_M2_82140_104820 0.988200
R11716 n1_M2_82140_104820 n1_M2_83220_104820 0.988200
R11717 n1_M2_83220_104820 n1_M2_84300_104820 0.988200
R11718 n1_M2_84300_104820 n1_M2_85380_104820 0.988200
R11719 n1_M2_85380_104820 n1_M2_86460_104820 0.988200
R11720 n1_M2_86460_104820 n1_M2_87540_104820 0.988200
R11721 n1_M2_87540_104820 n1_M2_88620_104820 0.988200
R11722 n1_M2_88620_104820 n1_M2_89700_104820 0.988200
R11723 n1_M2_89700_104820 n1_M2_90780_104820 0.988200
R11724 n1_M2_90780_104820 n1_M2_91860_104820 0.988200
R11725 n1_M2_91860_104820 n1_M2_92940_104820 0.988200
R11726 n1_M2_92940_104820 n1_M2_94020_104820 0.988200
R11727 n1_M2_94020_104820 n1_M2_95100_104820 0.988200
R11728 n1_M2_95100_104820 n1_M2_96180_104820 0.988200
R11729 n1_M2_96180_104820 n1_M2_97260_104820 0.988200
R11730 n1_M2_97260_104820 n1_M2_98340_104820 0.988200
R11731 n1_M2_98340_104820 n1_M2_99420_104820 0.988200
R11732 n1_M2_99420_104820 n1_M2_100500_104820 0.988200
R11733 n1_M2_100500_104820 n1_M2_101580_104820 0.988200
R11734 n1_M2_101580_104820 n1_M2_102660_104820 0.988200
R11735 n1_M2_102660_104820 n1_M2_103740_104820 0.988200
R11736 n1_M2_103740_104820 n1_M2_104820_104820 0.988200
R11737 n1_M2_104820_104820 n1_M2_105900_104820 0.988200
R11738 n1_M2_105900_104820 n1_M2_106980_104820 0.988200
R11739 n1_M2_106980_104820 n1_M2_108060_104820 0.988200
R11740 n1_M2_108060_104820 n1_M2_109140_104820 0.988200
R11741 n1_M2_109140_104820 n1_M2_110220_104820 0.988200
R11742 n1_M2_110220_104820 n1_M2_111300_104820 0.988200
R11743 n1_M2_111300_104820 n1_M2_112380_104820 0.988200
R11744 n1_M2_112380_104820 n1_M2_113460_104820 0.988200
R11745 n1_M2_113460_104820 n1_M2_114540_104820 0.988200
R11746 n1_M2_114540_104820 n1_M2_115620_104820 0.988200
R11747 n1_M2_115620_104820 n1_M2_116700_104820 0.988200
R11748 n1_M2_116700_104820 n1_M2_117780_104820 0.988200
R11749 n1_M2_117780_104820 n1_M2_118860_104820 0.988200
R11750 n1_M2_118860_104820 n1_M2_119940_104820 0.988200
R11751 n1_M2_119940_104820 n1_M2_121020_104820 0.988200
R11752 n1_M2_121020_104820 n1_M2_122100_104820 0.988200
R11753 n1_M2_122100_104820 n1_M2_123180_104820 0.988200
R11754 n1_M2_123180_104820 n1_M2_124260_104820 0.988200
R11755 n1_M2_124260_104820 n1_M2_125340_104820 0.988200
R11756 n1_M2_125340_104820 n1_M2_126420_104820 0.988200
R11757 n1_M2_126420_104820 n1_M2_127500_104820 0.988200
R11758 n1_M2_127500_104820 n1_M2_128580_104820 0.988200
R11759 n1_M2_128580_104820 n1_M2_129660_104820 0.988200
R11760 n1_M2_60_105900 n1_M2_1140_105900 0.988200
R11761 n1_M2_1140_105900 n1_M2_2220_105900 0.988200
R11762 n1_M2_2220_105900 n1_M2_3300_105900 0.988200
R11763 n1_M2_3300_105900 n1_M2_4380_105900 0.988200
R11764 n1_M2_4380_105900 n1_M2_5460_105900 0.988200
R11765 n1_M2_5460_105900 n1_M2_6540_105900 0.988200
R11766 n1_M2_6540_105900 n1_M2_7620_105900 0.988200
R11767 n1_M2_7620_105900 n1_M2_8700_105900 0.988200
R11768 n1_M2_8700_105900 n1_M2_9780_105900 0.988200
R11769 n1_M2_9780_105900 n1_M2_10860_105900 0.988200
R11770 n1_M2_10860_105900 n1_M2_11940_105900 0.988200
R11771 n1_M2_11940_105900 n1_M2_13020_105900 0.988200
R11772 n1_M2_13020_105900 n1_M2_14100_105900 0.988200
R11773 n1_M2_14100_105900 n1_M2_15180_105900 0.988200
R11774 n1_M2_15180_105900 n1_M2_16260_105900 0.988200
R11775 n1_M2_16260_105900 n1_M2_17340_105900 0.988200
R11776 n1_M2_17340_105900 n1_M2_18420_105900 0.988200
R11777 n1_M2_18420_105900 n1_M2_19500_105900 0.988200
R11778 n1_M2_19500_105900 n1_M2_20580_105900 0.988200
R11779 n1_M2_20580_105900 n1_M2_21660_105900 0.988200
R11780 n1_M2_21660_105900 n1_M2_22740_105900 0.988200
R11781 n1_M2_22740_105900 n1_M2_23820_105900 0.988200
R11782 n1_M2_23820_105900 n1_M2_24900_105900 0.988200
R11783 n1_M2_24900_105900 n1_M2_25980_105900 0.988200
R11784 n1_M2_25980_105900 n1_M2_27060_105900 0.988200
R11785 n1_M2_27060_105900 n1_M2_28140_105900 0.988200
R11786 n1_M2_28140_105900 n1_M2_29220_105900 0.988200
R11787 n1_M2_29220_105900 n1_M2_30300_105900 0.988200
R11788 n1_M2_30300_105900 n1_M2_31380_105900 0.988200
R11789 n1_M2_31380_105900 n1_M2_32460_105900 0.988200
R11790 n1_M2_32460_105900 n1_M2_33540_105900 0.988200
R11791 n1_M2_33540_105900 n1_M2_34620_105900 0.988200
R11792 n1_M2_34620_105900 n1_M2_35700_105900 0.988200
R11793 n1_M2_35700_105900 n1_M2_36780_105900 0.988200
R11794 n1_M2_36780_105900 n1_M2_37860_105900 0.988200
R11795 n1_M2_37860_105900 n1_M2_38940_105900 0.988200
R11796 n1_M2_38940_105900 n1_M2_40020_105900 0.988200
R11797 n1_M2_40020_105900 n1_M2_41100_105900 0.988200
R11798 n1_M2_41100_105900 n1_M2_42180_105900 0.988200
R11799 n1_M2_42180_105900 n1_M2_43260_105900 0.988200
R11800 n1_M2_43260_105900 n1_M2_44340_105900 0.988200
R11801 n1_M2_44340_105900 n1_M2_45420_105900 0.988200
R11802 n1_M2_45420_105900 n1_M2_46500_105900 0.988200
R11803 n1_M2_46500_105900 n1_M2_47580_105900 0.988200
R11804 n1_M2_47580_105900 n1_M2_48660_105900 0.988200
R11805 n1_M2_48660_105900 n1_M2_49740_105900 0.988200
R11806 n1_M2_49740_105900 n1_M2_50820_105900 0.988200
R11807 n1_M2_50820_105900 n1_M2_51900_105900 0.988200
R11808 n1_M2_51900_105900 n1_M2_52980_105900 0.988200
R11809 n1_M2_52980_105900 n1_M2_54060_105900 0.988200
R11810 n1_M2_54060_105900 n1_M2_55140_105900 0.988200
R11811 n1_M2_55140_105900 n1_M2_56220_105900 0.988200
R11812 n1_M2_56220_105900 n1_M2_57300_105900 0.988200
R11813 n1_M2_57300_105900 n1_M2_58380_105900 0.988200
R11814 n1_M2_58380_105900 n1_M2_59460_105900 0.988200
R11815 n1_M2_59460_105900 n1_M2_60540_105900 0.988200
R11816 n1_M2_60540_105900 n1_M2_61620_105900 0.988200
R11817 n1_M2_61620_105900 n1_M2_62700_105900 0.988200
R11818 n1_M2_62700_105900 n1_M2_63780_105900 0.988200
R11819 n1_M2_63780_105900 n1_M2_64860_105900 0.988200
R11820 n1_M2_64860_105900 n1_M2_65940_105900 0.988200
R11821 n1_M2_65940_105900 n1_M2_67020_105900 0.988200
R11822 n1_M2_67020_105900 n1_M2_68100_105900 0.988200
R11823 n1_M2_68100_105900 n1_M2_69180_105900 0.988200
R11824 n1_M2_69180_105900 n1_M2_70260_105900 0.988200
R11825 n1_M2_70260_105900 n1_M2_71340_105900 0.988200
R11826 n1_M2_71340_105900 n1_M2_72420_105900 0.988200
R11827 n1_M2_72420_105900 n1_M2_73500_105900 0.988200
R11828 n1_M2_73500_105900 n1_M2_74580_105900 0.988200
R11829 n1_M2_74580_105900 n1_M2_75660_105900 0.988200
R11830 n1_M2_75660_105900 n1_M2_76740_105900 0.988200
R11831 n1_M2_76740_105900 n1_M2_77820_105900 0.988200
R11832 n1_M2_77820_105900 n1_M2_78900_105900 0.988200
R11833 n1_M2_78900_105900 n1_M2_79980_105900 0.988200
R11834 n1_M2_79980_105900 n1_M2_81060_105900 0.988200
R11835 n1_M2_81060_105900 n1_M2_82140_105900 0.988200
R11836 n1_M2_82140_105900 n1_M2_83220_105900 0.988200
R11837 n1_M2_83220_105900 n1_M2_84300_105900 0.988200
R11838 n1_M2_84300_105900 n1_M2_85380_105900 0.988200
R11839 n1_M2_85380_105900 n1_M2_86460_105900 0.988200
R11840 n1_M2_86460_105900 n1_M2_87540_105900 0.988200
R11841 n1_M2_87540_105900 n1_M2_88620_105900 0.988200
R11842 n1_M2_88620_105900 n1_M2_89700_105900 0.988200
R11843 n1_M2_89700_105900 n1_M2_90780_105900 0.988200
R11844 n1_M2_90780_105900 n1_M2_91860_105900 0.988200
R11845 n1_M2_91860_105900 n1_M2_92940_105900 0.988200
R11846 n1_M2_92940_105900 n1_M2_94020_105900 0.988200
R11847 n1_M2_94020_105900 n1_M2_95100_105900 0.988200
R11848 n1_M2_95100_105900 n1_M2_96180_105900 0.988200
R11849 n1_M2_96180_105900 n1_M2_97260_105900 0.988200
R11850 n1_M2_97260_105900 n1_M2_98340_105900 0.988200
R11851 n1_M2_98340_105900 n1_M2_99420_105900 0.988200
R11852 n1_M2_99420_105900 n1_M2_100500_105900 0.988200
R11853 n1_M2_100500_105900 n1_M2_101580_105900 0.988200
R11854 n1_M2_101580_105900 n1_M2_102660_105900 0.988200
R11855 n1_M2_102660_105900 n1_M2_103740_105900 0.988200
R11856 n1_M2_103740_105900 n1_M2_104820_105900 0.988200
R11857 n1_M2_104820_105900 n1_M2_105900_105900 0.988200
R11858 n1_M2_105900_105900 n1_M2_106980_105900 0.988200
R11859 n1_M2_106980_105900 n1_M2_108060_105900 0.988200
R11860 n1_M2_108060_105900 n1_M2_109140_105900 0.988200
R11861 n1_M2_109140_105900 n1_M2_110220_105900 0.988200
R11862 n1_M2_110220_105900 n1_M2_111300_105900 0.988200
R11863 n1_M2_111300_105900 n1_M2_112380_105900 0.988200
R11864 n1_M2_112380_105900 n1_M2_113460_105900 0.988200
R11865 n1_M2_113460_105900 n1_M2_114540_105900 0.988200
R11866 n1_M2_114540_105900 n1_M2_115620_105900 0.988200
R11867 n1_M2_115620_105900 n1_M2_116700_105900 0.988200
R11868 n1_M2_116700_105900 n1_M2_117780_105900 0.988200
R11869 n1_M2_117780_105900 n1_M2_118860_105900 0.988200
R11870 n1_M2_118860_105900 n1_M2_119940_105900 0.988200
R11871 n1_M2_119940_105900 n1_M2_121020_105900 0.988200
R11872 n1_M2_121020_105900 n1_M2_122100_105900 0.988200
R11873 n1_M2_122100_105900 n1_M2_123180_105900 0.988200
R11874 n1_M2_123180_105900 n1_M2_124260_105900 0.988200
R11875 n1_M2_124260_105900 n1_M2_125340_105900 0.988200
R11876 n1_M2_125340_105900 n1_M2_126420_105900 0.988200
R11877 n1_M2_126420_105900 n1_M2_127500_105900 0.988200
R11878 n1_M2_127500_105900 n1_M2_128580_105900 0.988200
R11879 n1_M2_128580_105900 n1_M2_129660_105900 0.988200
R11880 n1_M2_60_106980 n1_M2_1140_106980 0.988200
R11881 n1_M2_1140_106980 n1_M2_2220_106980 0.988200
R11882 n1_M2_2220_106980 n1_M2_3300_106980 0.988200
R11883 n1_M2_3300_106980 n1_M2_4380_106980 0.988200
R11884 n1_M2_4380_106980 n1_M2_5460_106980 0.988200
R11885 n1_M2_5460_106980 n1_M2_6540_106980 0.988200
R11886 n1_M2_6540_106980 n1_M2_7620_106980 0.988200
R11887 n1_M2_7620_106980 n1_M2_8700_106980 0.988200
R11888 n1_M2_8700_106980 n1_M2_9780_106980 0.988200
R11889 n1_M2_9780_106980 n1_M2_10860_106980 0.988200
R11890 n1_M2_10860_106980 n1_M2_11940_106980 0.988200
R11891 n1_M2_11940_106980 n1_M2_13020_106980 0.988200
R11892 n1_M2_13020_106980 n1_M2_14100_106980 0.988200
R11893 n1_M2_14100_106980 n1_M2_15180_106980 0.988200
R11894 n1_M2_15180_106980 n1_M2_16260_106980 0.988200
R11895 n1_M2_16260_106980 n1_M2_17340_106980 0.988200
R11896 n1_M2_17340_106980 n1_M2_18420_106980 0.988200
R11897 n1_M2_18420_106980 n1_M2_19500_106980 0.988200
R11898 n1_M2_19500_106980 n1_M2_20580_106980 0.988200
R11899 n1_M2_20580_106980 n1_M2_21660_106980 0.988200
R11900 n1_M2_21660_106980 n1_M2_22740_106980 0.988200
R11901 n1_M2_22740_106980 n1_M2_23820_106980 0.988200
R11902 n1_M2_23820_106980 n1_M2_24900_106980 0.988200
R11903 n1_M2_24900_106980 n1_M2_25980_106980 0.988200
R11904 n1_M2_25980_106980 n1_M2_27060_106980 0.988200
R11905 n1_M2_27060_106980 n1_M2_28140_106980 0.988200
R11906 n1_M2_28140_106980 n1_M2_29220_106980 0.988200
R11907 n1_M2_29220_106980 n1_M2_30300_106980 0.988200
R11908 n1_M2_30300_106980 n1_M2_31380_106980 0.988200
R11909 n1_M2_31380_106980 n1_M2_32460_106980 0.988200
R11910 n1_M2_32460_106980 n1_M2_33540_106980 0.988200
R11911 n1_M2_33540_106980 n1_M2_34620_106980 0.988200
R11912 n1_M2_34620_106980 n1_M2_35700_106980 0.988200
R11913 n1_M2_35700_106980 n1_M2_36780_106980 0.988200
R11914 n1_M2_36780_106980 n1_M2_37860_106980 0.988200
R11915 n1_M2_37860_106980 n1_M2_38940_106980 0.988200
R11916 n1_M2_38940_106980 n1_M2_40020_106980 0.988200
R11917 n1_M2_40020_106980 n1_M2_41100_106980 0.988200
R11918 n1_M2_41100_106980 n1_M2_42180_106980 0.988200
R11919 n1_M2_42180_106980 n1_M2_43260_106980 0.988200
R11920 n1_M2_43260_106980 n1_M2_44340_106980 0.988200
R11921 n1_M2_44340_106980 n1_M2_45420_106980 0.988200
R11922 n1_M2_45420_106980 n1_M2_46500_106980 0.988200
R11923 n1_M2_46500_106980 n1_M2_47580_106980 0.988200
R11924 n1_M2_47580_106980 n1_M2_48660_106980 0.988200
R11925 n1_M2_48660_106980 n1_M2_49740_106980 0.988200
R11926 n1_M2_49740_106980 n1_M2_50820_106980 0.988200
R11927 n1_M2_50820_106980 n1_M2_51900_106980 0.988200
R11928 n1_M2_51900_106980 n1_M2_52980_106980 0.988200
R11929 n1_M2_52980_106980 n1_M2_54060_106980 0.988200
R11930 n1_M2_54060_106980 n1_M2_55140_106980 0.988200
R11931 n1_M2_55140_106980 n1_M2_56220_106980 0.988200
R11932 n1_M2_56220_106980 n1_M2_57300_106980 0.988200
R11933 n1_M2_57300_106980 n1_M2_58380_106980 0.988200
R11934 n1_M2_58380_106980 n1_M2_59460_106980 0.988200
R11935 n1_M2_59460_106980 n1_M2_60540_106980 0.988200
R11936 n1_M2_60540_106980 n1_M2_61620_106980 0.988200
R11937 n1_M2_61620_106980 n1_M2_62700_106980 0.988200
R11938 n1_M2_62700_106980 n1_M2_63780_106980 0.988200
R11939 n1_M2_63780_106980 n1_M2_64860_106980 0.988200
R11940 n1_M2_64860_106980 n1_M2_65940_106980 0.988200
R11941 n1_M2_65940_106980 n1_M2_67020_106980 0.988200
R11942 n1_M2_67020_106980 n1_M2_68100_106980 0.988200
R11943 n1_M2_68100_106980 n1_M2_69180_106980 0.988200
R11944 n1_M2_69180_106980 n1_M2_70260_106980 0.988200
R11945 n1_M2_70260_106980 n1_M2_71340_106980 0.988200
R11946 n1_M2_71340_106980 n1_M2_72420_106980 0.988200
R11947 n1_M2_72420_106980 n1_M2_73500_106980 0.988200
R11948 n1_M2_73500_106980 n1_M2_74580_106980 0.988200
R11949 n1_M2_74580_106980 n1_M2_75660_106980 0.988200
R11950 n1_M2_75660_106980 n1_M2_76740_106980 0.988200
R11951 n1_M2_76740_106980 n1_M2_77820_106980 0.988200
R11952 n1_M2_77820_106980 n1_M2_78900_106980 0.988200
R11953 n1_M2_78900_106980 n1_M2_79980_106980 0.988200
R11954 n1_M2_79980_106980 n1_M2_81060_106980 0.988200
R11955 n1_M2_81060_106980 n1_M2_82140_106980 0.988200
R11956 n1_M2_82140_106980 n1_M2_83220_106980 0.988200
R11957 n1_M2_83220_106980 n1_M2_84300_106980 0.988200
R11958 n1_M2_84300_106980 n1_M2_85380_106980 0.988200
R11959 n1_M2_85380_106980 n1_M2_86460_106980 0.988200
R11960 n1_M2_86460_106980 n1_M2_87540_106980 0.988200
R11961 n1_M2_87540_106980 n1_M2_88620_106980 0.988200
R11962 n1_M2_88620_106980 n1_M2_89700_106980 0.988200
R11963 n1_M2_89700_106980 n1_M2_90780_106980 0.988200
R11964 n1_M2_90780_106980 n1_M2_91860_106980 0.988200
R11965 n1_M2_91860_106980 n1_M2_92940_106980 0.988200
R11966 n1_M2_92940_106980 n1_M2_94020_106980 0.988200
R11967 n1_M2_94020_106980 n1_M2_95100_106980 0.988200
R11968 n1_M2_95100_106980 n1_M2_96180_106980 0.988200
R11969 n1_M2_96180_106980 n1_M2_97260_106980 0.988200
R11970 n1_M2_97260_106980 n1_M2_98340_106980 0.988200
R11971 n1_M2_98340_106980 n1_M2_99420_106980 0.988200
R11972 n1_M2_99420_106980 n1_M2_100500_106980 0.988200
R11973 n1_M2_100500_106980 n1_M2_101580_106980 0.988200
R11974 n1_M2_101580_106980 n1_M2_102660_106980 0.988200
R11975 n1_M2_102660_106980 n1_M2_103740_106980 0.988200
R11976 n1_M2_103740_106980 n1_M2_104820_106980 0.988200
R11977 n1_M2_104820_106980 n1_M2_105900_106980 0.988200
R11978 n1_M2_105900_106980 n1_M2_106980_106980 0.988200
R11979 n1_M2_106980_106980 n1_M2_108060_106980 0.988200
R11980 n1_M2_108060_106980 n1_M2_109140_106980 0.988200
R11981 n1_M2_109140_106980 n1_M2_110220_106980 0.988200
R11982 n1_M2_110220_106980 n1_M2_111300_106980 0.988200
R11983 n1_M2_111300_106980 n1_M2_112380_106980 0.988200
R11984 n1_M2_112380_106980 n1_M2_113460_106980 0.988200
R11985 n1_M2_113460_106980 n1_M2_114540_106980 0.988200
R11986 n1_M2_114540_106980 n1_M2_115620_106980 0.988200
R11987 n1_M2_115620_106980 n1_M2_116700_106980 0.988200
R11988 n1_M2_116700_106980 n1_M2_117780_106980 0.988200
R11989 n1_M2_117780_106980 n1_M2_118860_106980 0.988200
R11990 n1_M2_118860_106980 n1_M2_119940_106980 0.988200
R11991 n1_M2_119940_106980 n1_M2_121020_106980 0.988200
R11992 n1_M2_121020_106980 n1_M2_122100_106980 0.988200
R11993 n1_M2_122100_106980 n1_M2_123180_106980 0.988200
R11994 n1_M2_123180_106980 n1_M2_124260_106980 0.988200
R11995 n1_M2_124260_106980 n1_M2_125340_106980 0.988200
R11996 n1_M2_125340_106980 n1_M2_126420_106980 0.988200
R11997 n1_M2_126420_106980 n1_M2_127500_106980 0.988200
R11998 n1_M2_127500_106980 n1_M2_128580_106980 0.988200
R11999 n1_M2_128580_106980 n1_M2_129660_106980 0.988200
R12000 n1_M2_60_108060 n1_M2_1140_108060 0.988200
R12001 n1_M2_1140_108060 n1_M2_2220_108060 0.988200
R12002 n1_M2_2220_108060 n1_M2_3300_108060 0.988200
R12003 n1_M2_3300_108060 n1_M2_4380_108060 0.988200
R12004 n1_M2_4380_108060 n1_M2_5460_108060 0.988200
R12005 n1_M2_5460_108060 n1_M2_6540_108060 0.988200
R12006 n1_M2_6540_108060 n1_M2_7620_108060 0.988200
R12007 n1_M2_7620_108060 n1_M2_8700_108060 0.988200
R12008 n1_M2_8700_108060 n1_M2_9780_108060 0.988200
R12009 n1_M2_9780_108060 n1_M2_10860_108060 0.988200
R12010 n1_M2_10860_108060 n1_M2_11940_108060 0.988200
R12011 n1_M2_11940_108060 n1_M2_13020_108060 0.988200
R12012 n1_M2_13020_108060 n1_M2_14100_108060 0.988200
R12013 n1_M2_14100_108060 n1_M2_15180_108060 0.988200
R12014 n1_M2_15180_108060 n1_M2_16260_108060 0.988200
R12015 n1_M2_16260_108060 n1_M2_17340_108060 0.988200
R12016 n1_M2_17340_108060 n1_M2_18420_108060 0.988200
R12017 n1_M2_18420_108060 n1_M2_19500_108060 0.988200
R12018 n1_M2_19500_108060 n1_M2_20580_108060 0.988200
R12019 n1_M2_20580_108060 n1_M2_21660_108060 0.988200
R12020 n1_M2_21660_108060 n1_M2_22740_108060 0.988200
R12021 n1_M2_22740_108060 n1_M2_23820_108060 0.988200
R12022 n1_M2_23820_108060 n1_M2_24900_108060 0.988200
R12023 n1_M2_24900_108060 n1_M2_25980_108060 0.988200
R12024 n1_M2_25980_108060 n1_M2_27060_108060 0.988200
R12025 n1_M2_27060_108060 n1_M2_28140_108060 0.988200
R12026 n1_M2_28140_108060 n1_M2_29220_108060 0.988200
R12027 n1_M2_29220_108060 n1_M2_30300_108060 0.988200
R12028 n1_M2_30300_108060 n1_M2_31380_108060 0.988200
R12029 n1_M2_31380_108060 n1_M2_32460_108060 0.988200
R12030 n1_M2_32460_108060 n1_M2_33540_108060 0.988200
R12031 n1_M2_33540_108060 n1_M2_34620_108060 0.988200
R12032 n1_M2_34620_108060 n1_M2_35700_108060 0.988200
R12033 n1_M2_35700_108060 n1_M2_36780_108060 0.988200
R12034 n1_M2_36780_108060 n1_M2_37860_108060 0.988200
R12035 n1_M2_37860_108060 n1_M2_38940_108060 0.988200
R12036 n1_M2_38940_108060 n1_M2_40020_108060 0.988200
R12037 n1_M2_40020_108060 n1_M2_41100_108060 0.988200
R12038 n1_M2_41100_108060 n1_M2_42180_108060 0.988200
R12039 n1_M2_42180_108060 n1_M2_43260_108060 0.988200
R12040 n1_M2_43260_108060 n1_M2_44340_108060 0.988200
R12041 n1_M2_44340_108060 n1_M2_45420_108060 0.988200
R12042 n1_M2_45420_108060 n1_M2_46500_108060 0.988200
R12043 n1_M2_46500_108060 n1_M2_47580_108060 0.988200
R12044 n1_M2_47580_108060 n1_M2_48660_108060 0.988200
R12045 n1_M2_48660_108060 n1_M2_49740_108060 0.988200
R12046 n1_M2_49740_108060 n1_M2_50820_108060 0.988200
R12047 n1_M2_50820_108060 n1_M2_51900_108060 0.988200
R12048 n1_M2_51900_108060 n1_M2_52980_108060 0.988200
R12049 n1_M2_52980_108060 n1_M2_54060_108060 0.988200
R12050 n1_M2_54060_108060 n1_M2_55140_108060 0.988200
R12051 n1_M2_55140_108060 n1_M2_56220_108060 0.988200
R12052 n1_M2_56220_108060 n1_M2_57300_108060 0.988200
R12053 n1_M2_57300_108060 n1_M2_58380_108060 0.988200
R12054 n1_M2_58380_108060 n1_M2_59460_108060 0.988200
R12055 n1_M2_59460_108060 n1_M2_60540_108060 0.988200
R12056 n1_M2_60540_108060 n1_M2_61620_108060 0.988200
R12057 n1_M2_61620_108060 n1_M2_62700_108060 0.988200
R12058 n1_M2_62700_108060 n1_M2_63780_108060 0.988200
R12059 n1_M2_63780_108060 n1_M2_64860_108060 0.988200
R12060 n1_M2_64860_108060 n1_M2_65940_108060 0.988200
R12061 n1_M2_65940_108060 n1_M2_67020_108060 0.988200
R12062 n1_M2_67020_108060 n1_M2_68100_108060 0.988200
R12063 n1_M2_68100_108060 n1_M2_69180_108060 0.988200
R12064 n1_M2_69180_108060 n1_M2_70260_108060 0.988200
R12065 n1_M2_70260_108060 n1_M2_71340_108060 0.988200
R12066 n1_M2_71340_108060 n1_M2_72420_108060 0.988200
R12067 n1_M2_72420_108060 n1_M2_73500_108060 0.988200
R12068 n1_M2_73500_108060 n1_M2_74580_108060 0.988200
R12069 n1_M2_74580_108060 n1_M2_75660_108060 0.988200
R12070 n1_M2_75660_108060 n1_M2_76740_108060 0.988200
R12071 n1_M2_76740_108060 n1_M2_77820_108060 0.988200
R12072 n1_M2_77820_108060 n1_M2_78900_108060 0.988200
R12073 n1_M2_78900_108060 n1_M2_79980_108060 0.988200
R12074 n1_M2_79980_108060 n1_M2_81060_108060 0.988200
R12075 n1_M2_81060_108060 n1_M2_82140_108060 0.988200
R12076 n1_M2_82140_108060 n1_M2_83220_108060 0.988200
R12077 n1_M2_83220_108060 n1_M2_84300_108060 0.988200
R12078 n1_M2_84300_108060 n1_M2_85380_108060 0.988200
R12079 n1_M2_85380_108060 n1_M2_86460_108060 0.988200
R12080 n1_M2_86460_108060 n1_M2_87540_108060 0.988200
R12081 n1_M2_87540_108060 n1_M2_88620_108060 0.988200
R12082 n1_M2_88620_108060 n1_M2_89700_108060 0.988200
R12083 n1_M2_89700_108060 n1_M2_90780_108060 0.988200
R12084 n1_M2_90780_108060 n1_M2_91860_108060 0.988200
R12085 n1_M2_91860_108060 n1_M2_92940_108060 0.988200
R12086 n1_M2_92940_108060 n1_M2_94020_108060 0.988200
R12087 n1_M2_94020_108060 n1_M2_95100_108060 0.988200
R12088 n1_M2_95100_108060 n1_M2_96180_108060 0.988200
R12089 n1_M2_96180_108060 n1_M2_97260_108060 0.988200
R12090 n1_M2_97260_108060 n1_M2_98340_108060 0.988200
R12091 n1_M2_98340_108060 n1_M2_99420_108060 0.988200
R12092 n1_M2_99420_108060 n1_M2_100500_108060 0.988200
R12093 n1_M2_100500_108060 n1_M2_101580_108060 0.988200
R12094 n1_M2_101580_108060 n1_M2_102660_108060 0.988200
R12095 n1_M2_102660_108060 n1_M2_103740_108060 0.988200
R12096 n1_M2_103740_108060 n1_M2_104820_108060 0.988200
R12097 n1_M2_104820_108060 n1_M2_105900_108060 0.988200
R12098 n1_M2_105900_108060 n1_M2_106980_108060 0.988200
R12099 n1_M2_106980_108060 n1_M2_108060_108060 0.988200
R12100 n1_M2_108060_108060 n1_M2_109140_108060 0.988200
R12101 n1_M2_109140_108060 n1_M2_110220_108060 0.988200
R12102 n1_M2_110220_108060 n1_M2_111300_108060 0.988200
R12103 n1_M2_111300_108060 n1_M2_112380_108060 0.988200
R12104 n1_M2_112380_108060 n1_M2_113460_108060 0.988200
R12105 n1_M2_113460_108060 n1_M2_114540_108060 0.988200
R12106 n1_M2_114540_108060 n1_M2_115620_108060 0.988200
R12107 n1_M2_115620_108060 n1_M2_116700_108060 0.988200
R12108 n1_M2_116700_108060 n1_M2_117780_108060 0.988200
R12109 n1_M2_117780_108060 n1_M2_118860_108060 0.988200
R12110 n1_M2_118860_108060 n1_M2_119940_108060 0.988200
R12111 n1_M2_119940_108060 n1_M2_121020_108060 0.988200
R12112 n1_M2_121020_108060 n1_M2_122100_108060 0.988200
R12113 n1_M2_122100_108060 n1_M2_123180_108060 0.988200
R12114 n1_M2_123180_108060 n1_M2_124260_108060 0.988200
R12115 n1_M2_124260_108060 n1_M2_125340_108060 0.988200
R12116 n1_M2_125340_108060 n1_M2_126420_108060 0.988200
R12117 n1_M2_126420_108060 n1_M2_127500_108060 0.988200
R12118 n1_M2_127500_108060 n1_M2_128580_108060 0.988200
R12119 n1_M2_128580_108060 n1_M2_129660_108060 0.988200
R12120 n1_M2_60_109140 n1_M2_1140_109140 0.988200
R12121 n1_M2_1140_109140 n1_M2_2220_109140 0.988200
R12122 n1_M2_2220_109140 n1_M2_3300_109140 0.988200
R12123 n1_M2_3300_109140 n1_M2_4380_109140 0.988200
R12124 n1_M2_4380_109140 n1_M2_5460_109140 0.988200
R12125 n1_M2_5460_109140 n1_M2_6540_109140 0.988200
R12126 n1_M2_6540_109140 n1_M2_7620_109140 0.988200
R12127 n1_M2_7620_109140 n1_M2_8700_109140 0.988200
R12128 n1_M2_8700_109140 n1_M2_9780_109140 0.988200
R12129 n1_M2_9780_109140 n1_M2_10860_109140 0.988200
R12130 n1_M2_10860_109140 n1_M2_11940_109140 0.988200
R12131 n1_M2_11940_109140 n1_M2_13020_109140 0.988200
R12132 n1_M2_13020_109140 n1_M2_14100_109140 0.988200
R12133 n1_M2_14100_109140 n1_M2_15180_109140 0.988200
R12134 n1_M2_15180_109140 n1_M2_16260_109140 0.988200
R12135 n1_M2_16260_109140 n1_M2_17340_109140 0.988200
R12136 n1_M2_17340_109140 n1_M2_18420_109140 0.988200
R12137 n1_M2_18420_109140 n1_M2_19500_109140 0.988200
R12138 n1_M2_19500_109140 n1_M2_20580_109140 0.988200
R12139 n1_M2_20580_109140 n1_M2_21660_109140 0.988200
R12140 n1_M2_21660_109140 n1_M2_22740_109140 0.988200
R12141 n1_M2_22740_109140 n1_M2_23820_109140 0.988200
R12142 n1_M2_23820_109140 n1_M2_24900_109140 0.988200
R12143 n1_M2_24900_109140 n1_M2_25980_109140 0.988200
R12144 n1_M2_25980_109140 n1_M2_27060_109140 0.988200
R12145 n1_M2_27060_109140 n1_M2_28140_109140 0.988200
R12146 n1_M2_28140_109140 n1_M2_29220_109140 0.988200
R12147 n1_M2_29220_109140 n1_M2_30300_109140 0.988200
R12148 n1_M2_30300_109140 n1_M2_31380_109140 0.988200
R12149 n1_M2_31380_109140 n1_M2_32460_109140 0.988200
R12150 n1_M2_32460_109140 n1_M2_33540_109140 0.988200
R12151 n1_M2_33540_109140 n1_M2_34620_109140 0.988200
R12152 n1_M2_34620_109140 n1_M2_35700_109140 0.988200
R12153 n1_M2_35700_109140 n1_M2_36780_109140 0.988200
R12154 n1_M2_36780_109140 n1_M2_37860_109140 0.988200
R12155 n1_M2_37860_109140 n1_M2_38940_109140 0.988200
R12156 n1_M2_38940_109140 n1_M2_40020_109140 0.988200
R12157 n1_M2_40020_109140 n1_M2_41100_109140 0.988200
R12158 n1_M2_41100_109140 n1_M2_42180_109140 0.988200
R12159 n1_M2_42180_109140 n1_M2_43260_109140 0.988200
R12160 n1_M2_43260_109140 n1_M2_44340_109140 0.988200
R12161 n1_M2_44340_109140 n1_M2_45420_109140 0.988200
R12162 n1_M2_45420_109140 n1_M2_46500_109140 0.988200
R12163 n1_M2_46500_109140 n1_M2_47580_109140 0.988200
R12164 n1_M2_47580_109140 n1_M2_48660_109140 0.988200
R12165 n1_M2_48660_109140 n1_M2_49740_109140 0.988200
R12166 n1_M2_49740_109140 n1_M2_50820_109140 0.988200
R12167 n1_M2_50820_109140 n1_M2_51900_109140 0.988200
R12168 n1_M2_51900_109140 n1_M2_52980_109140 0.988200
R12169 n1_M2_52980_109140 n1_M2_54060_109140 0.988200
R12170 n1_M2_54060_109140 n1_M2_55140_109140 0.988200
R12171 n1_M2_55140_109140 n1_M2_56220_109140 0.988200
R12172 n1_M2_56220_109140 n1_M2_57300_109140 0.988200
R12173 n1_M2_57300_109140 n1_M2_58380_109140 0.988200
R12174 n1_M2_58380_109140 n1_M2_59460_109140 0.988200
R12175 n1_M2_59460_109140 n1_M2_60540_109140 0.988200
R12176 n1_M2_60540_109140 n1_M2_61620_109140 0.988200
R12177 n1_M2_61620_109140 n1_M2_62700_109140 0.988200
R12178 n1_M2_62700_109140 n1_M2_63780_109140 0.988200
R12179 n1_M2_63780_109140 n1_M2_64860_109140 0.988200
R12180 n1_M2_64860_109140 n1_M2_65940_109140 0.988200
R12181 n1_M2_65940_109140 n1_M2_67020_109140 0.988200
R12182 n1_M2_67020_109140 n1_M2_68100_109140 0.988200
R12183 n1_M2_68100_109140 n1_M2_69180_109140 0.988200
R12184 n1_M2_69180_109140 n1_M2_70260_109140 0.988200
R12185 n1_M2_70260_109140 n1_M2_71340_109140 0.988200
R12186 n1_M2_71340_109140 n1_M2_72420_109140 0.988200
R12187 n1_M2_72420_109140 n1_M2_73500_109140 0.988200
R12188 n1_M2_73500_109140 n1_M2_74580_109140 0.988200
R12189 n1_M2_74580_109140 n1_M2_75660_109140 0.988200
R12190 n1_M2_75660_109140 n1_M2_76740_109140 0.988200
R12191 n1_M2_76740_109140 n1_M2_77820_109140 0.988200
R12192 n1_M2_77820_109140 n1_M2_78900_109140 0.988200
R12193 n1_M2_78900_109140 n1_M2_79980_109140 0.988200
R12194 n1_M2_79980_109140 n1_M2_81060_109140 0.988200
R12195 n1_M2_81060_109140 n1_M2_82140_109140 0.988200
R12196 n1_M2_82140_109140 n1_M2_83220_109140 0.988200
R12197 n1_M2_83220_109140 n1_M2_84300_109140 0.988200
R12198 n1_M2_84300_109140 n1_M2_85380_109140 0.988200
R12199 n1_M2_85380_109140 n1_M2_86460_109140 0.988200
R12200 n1_M2_86460_109140 n1_M2_87540_109140 0.988200
R12201 n1_M2_87540_109140 n1_M2_88620_109140 0.988200
R12202 n1_M2_88620_109140 n1_M2_89700_109140 0.988200
R12203 n1_M2_89700_109140 n1_M2_90780_109140 0.988200
R12204 n1_M2_90780_109140 n1_M2_91860_109140 0.988200
R12205 n1_M2_91860_109140 n1_M2_92940_109140 0.988200
R12206 n1_M2_92940_109140 n1_M2_94020_109140 0.988200
R12207 n1_M2_94020_109140 n1_M2_95100_109140 0.988200
R12208 n1_M2_95100_109140 n1_M2_96180_109140 0.988200
R12209 n1_M2_96180_109140 n1_M2_97260_109140 0.988200
R12210 n1_M2_97260_109140 n1_M2_98340_109140 0.988200
R12211 n1_M2_98340_109140 n1_M2_99420_109140 0.988200
R12212 n1_M2_99420_109140 n1_M2_100500_109140 0.988200
R12213 n1_M2_100500_109140 n1_M2_101580_109140 0.988200
R12214 n1_M2_101580_109140 n1_M2_102660_109140 0.988200
R12215 n1_M2_102660_109140 n1_M2_103740_109140 0.988200
R12216 n1_M2_103740_109140 n1_M2_104820_109140 0.988200
R12217 n1_M2_104820_109140 n1_M2_105900_109140 0.988200
R12218 n1_M2_105900_109140 n1_M2_106980_109140 0.988200
R12219 n1_M2_106980_109140 n1_M2_108060_109140 0.988200
R12220 n1_M2_108060_109140 n1_M2_109140_109140 0.988200
R12221 n1_M2_109140_109140 n1_M2_110220_109140 0.988200
R12222 n1_M2_110220_109140 n1_M2_111300_109140 0.988200
R12223 n1_M2_111300_109140 n1_M2_112380_109140 0.988200
R12224 n1_M2_112380_109140 n1_M2_113460_109140 0.988200
R12225 n1_M2_113460_109140 n1_M2_114540_109140 0.988200
R12226 n1_M2_114540_109140 n1_M2_115620_109140 0.988200
R12227 n1_M2_115620_109140 n1_M2_116700_109140 0.988200
R12228 n1_M2_116700_109140 n1_M2_117780_109140 0.988200
R12229 n1_M2_117780_109140 n1_M2_118860_109140 0.988200
R12230 n1_M2_118860_109140 n1_M2_119940_109140 0.988200
R12231 n1_M2_119940_109140 n1_M2_121020_109140 0.988200
R12232 n1_M2_121020_109140 n1_M2_122100_109140 0.988200
R12233 n1_M2_122100_109140 n1_M2_123180_109140 0.988200
R12234 n1_M2_123180_109140 n1_M2_124260_109140 0.988200
R12235 n1_M2_124260_109140 n1_M2_125340_109140 0.988200
R12236 n1_M2_125340_109140 n1_M2_126420_109140 0.988200
R12237 n1_M2_126420_109140 n1_M2_127500_109140 0.988200
R12238 n1_M2_127500_109140 n1_M2_128580_109140 0.988200
R12239 n1_M2_128580_109140 n1_M2_129660_109140 0.988200
R12240 n1_M2_60_110220 n1_M2_1140_110220 0.988200
R12241 n1_M2_1140_110220 n1_M2_2220_110220 0.988200
R12242 n1_M2_2220_110220 n1_M2_3300_110220 0.988200
R12243 n1_M2_3300_110220 n1_M2_4380_110220 0.988200
R12244 n1_M2_4380_110220 n1_M2_5460_110220 0.988200
R12245 n1_M2_5460_110220 n1_M2_6540_110220 0.988200
R12246 n1_M2_6540_110220 n1_M2_7620_110220 0.988200
R12247 n1_M2_7620_110220 n1_M2_8700_110220 0.988200
R12248 n1_M2_8700_110220 n1_M2_9780_110220 0.988200
R12249 n1_M2_9780_110220 n1_M2_10860_110220 0.988200
R12250 n1_M2_10860_110220 n1_M2_11940_110220 0.988200
R12251 n1_M2_11940_110220 n1_M2_13020_110220 0.988200
R12252 n1_M2_13020_110220 n1_M2_14100_110220 0.988200
R12253 n1_M2_14100_110220 n1_M2_15180_110220 0.988200
R12254 n1_M2_15180_110220 n1_M2_16260_110220 0.988200
R12255 n1_M2_16260_110220 n1_M2_17340_110220 0.988200
R12256 n1_M2_17340_110220 n1_M2_18420_110220 0.988200
R12257 n1_M2_18420_110220 n1_M2_19500_110220 0.988200
R12258 n1_M2_19500_110220 n1_M2_20580_110220 0.988200
R12259 n1_M2_20580_110220 n1_M2_21660_110220 0.988200
R12260 n1_M2_21660_110220 n1_M2_22740_110220 0.988200
R12261 n1_M2_22740_110220 n1_M2_23820_110220 0.988200
R12262 n1_M2_23820_110220 n1_M2_24900_110220 0.988200
R12263 n1_M2_24900_110220 n1_M2_25980_110220 0.988200
R12264 n1_M2_25980_110220 n1_M2_27060_110220 0.988200
R12265 n1_M2_27060_110220 n1_M2_28140_110220 0.988200
R12266 n1_M2_28140_110220 n1_M2_29220_110220 0.988200
R12267 n1_M2_29220_110220 n1_M2_30300_110220 0.988200
R12268 n1_M2_30300_110220 n1_M2_31380_110220 0.988200
R12269 n1_M2_31380_110220 n1_M2_32460_110220 0.988200
R12270 n1_M2_32460_110220 n1_M2_33540_110220 0.988200
R12271 n1_M2_33540_110220 n1_M2_34620_110220 0.988200
R12272 n1_M2_34620_110220 n1_M2_35700_110220 0.988200
R12273 n1_M2_35700_110220 n1_M2_36780_110220 0.988200
R12274 n1_M2_36780_110220 n1_M2_37860_110220 0.988200
R12275 n1_M2_37860_110220 n1_M2_38940_110220 0.988200
R12276 n1_M2_38940_110220 n1_M2_40020_110220 0.988200
R12277 n1_M2_40020_110220 n1_M2_41100_110220 0.988200
R12278 n1_M2_41100_110220 n1_M2_42180_110220 0.988200
R12279 n1_M2_42180_110220 n1_M2_43260_110220 0.988200
R12280 n1_M2_43260_110220 n1_M2_44340_110220 0.988200
R12281 n1_M2_44340_110220 n1_M2_45420_110220 0.988200
R12282 n1_M2_45420_110220 n1_M2_46500_110220 0.988200
R12283 n1_M2_46500_110220 n1_M2_47580_110220 0.988200
R12284 n1_M2_47580_110220 n1_M2_48660_110220 0.988200
R12285 n1_M2_48660_110220 n1_M2_49740_110220 0.988200
R12286 n1_M2_49740_110220 n1_M2_50820_110220 0.988200
R12287 n1_M2_50820_110220 n1_M2_51900_110220 0.988200
R12288 n1_M2_51900_110220 n1_M2_52980_110220 0.988200
R12289 n1_M2_52980_110220 n1_M2_54060_110220 0.988200
R12290 n1_M2_54060_110220 n1_M2_55140_110220 0.988200
R12291 n1_M2_55140_110220 n1_M2_56220_110220 0.988200
R12292 n1_M2_56220_110220 n1_M2_57300_110220 0.988200
R12293 n1_M2_57300_110220 n1_M2_58380_110220 0.988200
R12294 n1_M2_58380_110220 n1_M2_59460_110220 0.988200
R12295 n1_M2_59460_110220 n1_M2_60540_110220 0.988200
R12296 n1_M2_60540_110220 n1_M2_61620_110220 0.988200
R12297 n1_M2_61620_110220 n1_M2_62700_110220 0.988200
R12298 n1_M2_62700_110220 n1_M2_63780_110220 0.988200
R12299 n1_M2_63780_110220 n1_M2_64860_110220 0.988200
R12300 n1_M2_64860_110220 n1_M2_65940_110220 0.988200
R12301 n1_M2_65940_110220 n1_M2_67020_110220 0.988200
R12302 n1_M2_67020_110220 n1_M2_68100_110220 0.988200
R12303 n1_M2_68100_110220 n1_M2_69180_110220 0.988200
R12304 n1_M2_69180_110220 n1_M2_70260_110220 0.988200
R12305 n1_M2_70260_110220 n1_M2_71340_110220 0.988200
R12306 n1_M2_71340_110220 n1_M2_72420_110220 0.988200
R12307 n1_M2_72420_110220 n1_M2_73500_110220 0.988200
R12308 n1_M2_73500_110220 n1_M2_74580_110220 0.988200
R12309 n1_M2_74580_110220 n1_M2_75660_110220 0.988200
R12310 n1_M2_75660_110220 n1_M2_76740_110220 0.988200
R12311 n1_M2_76740_110220 n1_M2_77820_110220 0.988200
R12312 n1_M2_77820_110220 n1_M2_78900_110220 0.988200
R12313 n1_M2_78900_110220 n1_M2_79980_110220 0.988200
R12314 n1_M2_79980_110220 n1_M2_81060_110220 0.988200
R12315 n1_M2_81060_110220 n1_M2_82140_110220 0.988200
R12316 n1_M2_82140_110220 n1_M2_83220_110220 0.988200
R12317 n1_M2_83220_110220 n1_M2_84300_110220 0.988200
R12318 n1_M2_84300_110220 n1_M2_85380_110220 0.988200
R12319 n1_M2_85380_110220 n1_M2_86460_110220 0.988200
R12320 n1_M2_86460_110220 n1_M2_87540_110220 0.988200
R12321 n1_M2_87540_110220 n1_M2_88620_110220 0.988200
R12322 n1_M2_88620_110220 n1_M2_89700_110220 0.988200
R12323 n1_M2_89700_110220 n1_M2_90780_110220 0.988200
R12324 n1_M2_90780_110220 n1_M2_91860_110220 0.988200
R12325 n1_M2_91860_110220 n1_M2_92940_110220 0.988200
R12326 n1_M2_92940_110220 n1_M2_94020_110220 0.988200
R12327 n1_M2_94020_110220 n1_M2_95100_110220 0.988200
R12328 n1_M2_95100_110220 n1_M2_96180_110220 0.988200
R12329 n1_M2_96180_110220 n1_M2_97260_110220 0.988200
R12330 n1_M2_97260_110220 n1_M2_98340_110220 0.988200
R12331 n1_M2_98340_110220 n1_M2_99420_110220 0.988200
R12332 n1_M2_99420_110220 n1_M2_100500_110220 0.988200
R12333 n1_M2_100500_110220 n1_M2_101580_110220 0.988200
R12334 n1_M2_101580_110220 n1_M2_102660_110220 0.988200
R12335 n1_M2_102660_110220 n1_M2_103740_110220 0.988200
R12336 n1_M2_103740_110220 n1_M2_104820_110220 0.988200
R12337 n1_M2_104820_110220 n1_M2_105900_110220 0.988200
R12338 n1_M2_105900_110220 n1_M2_106980_110220 0.988200
R12339 n1_M2_106980_110220 n1_M2_108060_110220 0.988200
R12340 n1_M2_108060_110220 n1_M2_109140_110220 0.988200
R12341 n1_M2_109140_110220 n1_M2_110220_110220 0.988200
R12342 n1_M2_110220_110220 n1_M2_111300_110220 0.988200
R12343 n1_M2_111300_110220 n1_M2_112380_110220 0.988200
R12344 n1_M2_112380_110220 n1_M2_113460_110220 0.988200
R12345 n1_M2_113460_110220 n1_M2_114540_110220 0.988200
R12346 n1_M2_114540_110220 n1_M2_115620_110220 0.988200
R12347 n1_M2_115620_110220 n1_M2_116700_110220 0.988200
R12348 n1_M2_116700_110220 n1_M2_117780_110220 0.988200
R12349 n1_M2_117780_110220 n1_M2_118860_110220 0.988200
R12350 n1_M2_118860_110220 n1_M2_119940_110220 0.988200
R12351 n1_M2_119940_110220 n1_M2_121020_110220 0.988200
R12352 n1_M2_121020_110220 n1_M2_122100_110220 0.988200
R12353 n1_M2_122100_110220 n1_M2_123180_110220 0.988200
R12354 n1_M2_123180_110220 n1_M2_124260_110220 0.988200
R12355 n1_M2_124260_110220 n1_M2_125340_110220 0.988200
R12356 n1_M2_125340_110220 n1_M2_126420_110220 0.988200
R12357 n1_M2_126420_110220 n1_M2_127500_110220 0.988200
R12358 n1_M2_127500_110220 n1_M2_128580_110220 0.988200
R12359 n1_M2_128580_110220 n1_M2_129660_110220 0.988200
R12360 n1_M2_60_111300 n1_M2_1140_111300 0.988200
R12361 n1_M2_1140_111300 n1_M2_2220_111300 0.988200
R12362 n1_M2_2220_111300 n1_M2_3300_111300 0.988200
R12363 n1_M2_3300_111300 n1_M2_4380_111300 0.988200
R12364 n1_M2_4380_111300 n1_M2_5460_111300 0.988200
R12365 n1_M2_5460_111300 n1_M2_6540_111300 0.988200
R12366 n1_M2_6540_111300 n1_M2_7620_111300 0.988200
R12367 n1_M2_7620_111300 n1_M2_8700_111300 0.988200
R12368 n1_M2_8700_111300 n1_M2_9780_111300 0.988200
R12369 n1_M2_9780_111300 n1_M2_10860_111300 0.988200
R12370 n1_M2_10860_111300 n1_M2_11940_111300 0.988200
R12371 n1_M2_11940_111300 n1_M2_13020_111300 0.988200
R12372 n1_M2_13020_111300 n1_M2_14100_111300 0.988200
R12373 n1_M2_14100_111300 n1_M2_15180_111300 0.988200
R12374 n1_M2_15180_111300 n1_M2_16260_111300 0.988200
R12375 n1_M2_16260_111300 n1_M2_17340_111300 0.988200
R12376 n1_M2_17340_111300 n1_M2_18420_111300 0.988200
R12377 n1_M2_18420_111300 n1_M2_19500_111300 0.988200
R12378 n1_M2_19500_111300 n1_M2_20580_111300 0.988200
R12379 n1_M2_20580_111300 n1_M2_21660_111300 0.988200
R12380 n1_M2_21660_111300 n1_M2_22740_111300 0.988200
R12381 n1_M2_22740_111300 n1_M2_23820_111300 0.988200
R12382 n1_M2_23820_111300 n1_M2_24900_111300 0.988200
R12383 n1_M2_24900_111300 n1_M2_25980_111300 0.988200
R12384 n1_M2_25980_111300 n1_M2_27060_111300 0.988200
R12385 n1_M2_27060_111300 n1_M2_28140_111300 0.988200
R12386 n1_M2_28140_111300 n1_M2_29220_111300 0.988200
R12387 n1_M2_29220_111300 n1_M2_30300_111300 0.988200
R12388 n1_M2_30300_111300 n1_M2_31380_111300 0.988200
R12389 n1_M2_31380_111300 n1_M2_32460_111300 0.988200
R12390 n1_M2_32460_111300 n1_M2_33540_111300 0.988200
R12391 n1_M2_33540_111300 n1_M2_34620_111300 0.988200
R12392 n1_M2_34620_111300 n1_M2_35700_111300 0.988200
R12393 n1_M2_35700_111300 n1_M2_36780_111300 0.988200
R12394 n1_M2_36780_111300 n1_M2_37860_111300 0.988200
R12395 n1_M2_37860_111300 n1_M2_38940_111300 0.988200
R12396 n1_M2_38940_111300 n1_M2_40020_111300 0.988200
R12397 n1_M2_40020_111300 n1_M2_41100_111300 0.988200
R12398 n1_M2_41100_111300 n1_M2_42180_111300 0.988200
R12399 n1_M2_42180_111300 n1_M2_43260_111300 0.988200
R12400 n1_M2_43260_111300 n1_M2_44340_111300 0.988200
R12401 n1_M2_44340_111300 n1_M2_45420_111300 0.988200
R12402 n1_M2_45420_111300 n1_M2_46500_111300 0.988200
R12403 n1_M2_46500_111300 n1_M2_47580_111300 0.988200
R12404 n1_M2_47580_111300 n1_M2_48660_111300 0.988200
R12405 n1_M2_48660_111300 n1_M2_49740_111300 0.988200
R12406 n1_M2_49740_111300 n1_M2_50820_111300 0.988200
R12407 n1_M2_50820_111300 n1_M2_51900_111300 0.988200
R12408 n1_M2_51900_111300 n1_M2_52980_111300 0.988200
R12409 n1_M2_52980_111300 n1_M2_54060_111300 0.988200
R12410 n1_M2_54060_111300 n1_M2_55140_111300 0.988200
R12411 n1_M2_55140_111300 n1_M2_56220_111300 0.988200
R12412 n1_M2_56220_111300 n1_M2_57300_111300 0.988200
R12413 n1_M2_57300_111300 n1_M2_58380_111300 0.988200
R12414 n1_M2_58380_111300 n1_M2_59460_111300 0.988200
R12415 n1_M2_59460_111300 n1_M2_60540_111300 0.988200
R12416 n1_M2_60540_111300 n1_M2_61620_111300 0.988200
R12417 n1_M2_61620_111300 n1_M2_62700_111300 0.988200
R12418 n1_M2_62700_111300 n1_M2_63780_111300 0.988200
R12419 n1_M2_63780_111300 n1_M2_64860_111300 0.988200
R12420 n1_M2_64860_111300 n1_M2_65940_111300 0.988200
R12421 n1_M2_65940_111300 n1_M2_67020_111300 0.988200
R12422 n1_M2_67020_111300 n1_M2_68100_111300 0.988200
R12423 n1_M2_68100_111300 n1_M2_69180_111300 0.988200
R12424 n1_M2_69180_111300 n1_M2_70260_111300 0.988200
R12425 n1_M2_70260_111300 n1_M2_71340_111300 0.988200
R12426 n1_M2_71340_111300 n1_M2_72420_111300 0.988200
R12427 n1_M2_72420_111300 n1_M2_73500_111300 0.988200
R12428 n1_M2_73500_111300 n1_M2_74580_111300 0.988200
R12429 n1_M2_74580_111300 n1_M2_75660_111300 0.988200
R12430 n1_M2_75660_111300 n1_M2_76740_111300 0.988200
R12431 n1_M2_76740_111300 n1_M2_77820_111300 0.988200
R12432 n1_M2_77820_111300 n1_M2_78900_111300 0.988200
R12433 n1_M2_78900_111300 n1_M2_79980_111300 0.988200
R12434 n1_M2_79980_111300 n1_M2_81060_111300 0.988200
R12435 n1_M2_81060_111300 n1_M2_82140_111300 0.988200
R12436 n1_M2_82140_111300 n1_M2_83220_111300 0.988200
R12437 n1_M2_83220_111300 n1_M2_84300_111300 0.988200
R12438 n1_M2_84300_111300 n1_M2_85380_111300 0.988200
R12439 n1_M2_85380_111300 n1_M2_86460_111300 0.988200
R12440 n1_M2_86460_111300 n1_M2_87540_111300 0.988200
R12441 n1_M2_87540_111300 n1_M2_88620_111300 0.988200
R12442 n1_M2_88620_111300 n1_M2_89700_111300 0.988200
R12443 n1_M2_89700_111300 n1_M2_90780_111300 0.988200
R12444 n1_M2_90780_111300 n1_M2_91860_111300 0.988200
R12445 n1_M2_91860_111300 n1_M2_92940_111300 0.988200
R12446 n1_M2_92940_111300 n1_M2_94020_111300 0.988200
R12447 n1_M2_94020_111300 n1_M2_95100_111300 0.988200
R12448 n1_M2_95100_111300 n1_M2_96180_111300 0.988200
R12449 n1_M2_96180_111300 n1_M2_97260_111300 0.988200
R12450 n1_M2_97260_111300 n1_M2_98340_111300 0.988200
R12451 n1_M2_98340_111300 n1_M2_99420_111300 0.988200
R12452 n1_M2_99420_111300 n1_M2_100500_111300 0.988200
R12453 n1_M2_100500_111300 n1_M2_101580_111300 0.988200
R12454 n1_M2_101580_111300 n1_M2_102660_111300 0.988200
R12455 n1_M2_102660_111300 n1_M2_103740_111300 0.988200
R12456 n1_M2_103740_111300 n1_M2_104820_111300 0.988200
R12457 n1_M2_104820_111300 n1_M2_105900_111300 0.988200
R12458 n1_M2_105900_111300 n1_M2_106980_111300 0.988200
R12459 n1_M2_106980_111300 n1_M2_108060_111300 0.988200
R12460 n1_M2_108060_111300 n1_M2_109140_111300 0.988200
R12461 n1_M2_109140_111300 n1_M2_110220_111300 0.988200
R12462 n1_M2_110220_111300 n1_M2_111300_111300 0.988200
R12463 n1_M2_111300_111300 n1_M2_112380_111300 0.988200
R12464 n1_M2_112380_111300 n1_M2_113460_111300 0.988200
R12465 n1_M2_113460_111300 n1_M2_114540_111300 0.988200
R12466 n1_M2_114540_111300 n1_M2_115620_111300 0.988200
R12467 n1_M2_115620_111300 n1_M2_116700_111300 0.988200
R12468 n1_M2_116700_111300 n1_M2_117780_111300 0.988200
R12469 n1_M2_117780_111300 n1_M2_118860_111300 0.988200
R12470 n1_M2_118860_111300 n1_M2_119940_111300 0.988200
R12471 n1_M2_119940_111300 n1_M2_121020_111300 0.988200
R12472 n1_M2_121020_111300 n1_M2_122100_111300 0.988200
R12473 n1_M2_122100_111300 n1_M2_123180_111300 0.988200
R12474 n1_M2_123180_111300 n1_M2_124260_111300 0.988200
R12475 n1_M2_124260_111300 n1_M2_125340_111300 0.988200
R12476 n1_M2_125340_111300 n1_M2_126420_111300 0.988200
R12477 n1_M2_126420_111300 n1_M2_127500_111300 0.988200
R12478 n1_M2_127500_111300 n1_M2_128580_111300 0.988200
R12479 n1_M2_128580_111300 n1_M2_129660_111300 0.988200
R12480 n1_M2_60_112380 n1_M2_1140_112380 0.988200
R12481 n1_M2_1140_112380 n1_M2_2220_112380 0.988200
R12482 n1_M2_2220_112380 n1_M2_3300_112380 0.988200
R12483 n1_M2_3300_112380 n1_M2_4380_112380 0.988200
R12484 n1_M2_4380_112380 n1_M2_5460_112380 0.988200
R12485 n1_M2_5460_112380 n1_M2_6540_112380 0.988200
R12486 n1_M2_6540_112380 n1_M2_7620_112380 0.988200
R12487 n1_M2_7620_112380 n1_M2_8700_112380 0.988200
R12488 n1_M2_8700_112380 n1_M2_9780_112380 0.988200
R12489 n1_M2_9780_112380 n1_M2_10860_112380 0.988200
R12490 n1_M2_10860_112380 n1_M2_11940_112380 0.988200
R12491 n1_M2_11940_112380 n1_M2_13020_112380 0.988200
R12492 n1_M2_13020_112380 n1_M2_14100_112380 0.988200
R12493 n1_M2_14100_112380 n1_M2_15180_112380 0.988200
R12494 n1_M2_15180_112380 n1_M2_16260_112380 0.988200
R12495 n1_M2_16260_112380 n1_M2_17340_112380 0.988200
R12496 n1_M2_17340_112380 n1_M2_18420_112380 0.988200
R12497 n1_M2_18420_112380 n1_M2_19500_112380 0.988200
R12498 n1_M2_19500_112380 n1_M2_20580_112380 0.988200
R12499 n1_M2_20580_112380 n1_M2_21660_112380 0.988200
R12500 n1_M2_21660_112380 n1_M2_22740_112380 0.988200
R12501 n1_M2_22740_112380 n1_M2_23820_112380 0.988200
R12502 n1_M2_23820_112380 n1_M2_24900_112380 0.988200
R12503 n1_M2_24900_112380 n1_M2_25980_112380 0.988200
R12504 n1_M2_25980_112380 n1_M2_27060_112380 0.988200
R12505 n1_M2_27060_112380 n1_M2_28140_112380 0.988200
R12506 n1_M2_28140_112380 n1_M2_29220_112380 0.988200
R12507 n1_M2_29220_112380 n1_M2_30300_112380 0.988200
R12508 n1_M2_30300_112380 n1_M2_31380_112380 0.988200
R12509 n1_M2_31380_112380 n1_M2_32460_112380 0.988200
R12510 n1_M2_32460_112380 n1_M2_33540_112380 0.988200
R12511 n1_M2_33540_112380 n1_M2_34620_112380 0.988200
R12512 n1_M2_34620_112380 n1_M2_35700_112380 0.988200
R12513 n1_M2_35700_112380 n1_M2_36780_112380 0.988200
R12514 n1_M2_36780_112380 n1_M2_37860_112380 0.988200
R12515 n1_M2_37860_112380 n1_M2_38940_112380 0.988200
R12516 n1_M2_38940_112380 n1_M2_40020_112380 0.988200
R12517 n1_M2_40020_112380 n1_M2_41100_112380 0.988200
R12518 n1_M2_41100_112380 n1_M2_42180_112380 0.988200
R12519 n1_M2_42180_112380 n1_M2_43260_112380 0.988200
R12520 n1_M2_43260_112380 n1_M2_44340_112380 0.988200
R12521 n1_M2_44340_112380 n1_M2_45420_112380 0.988200
R12522 n1_M2_45420_112380 n1_M2_46500_112380 0.988200
R12523 n1_M2_46500_112380 n1_M2_47580_112380 0.988200
R12524 n1_M2_47580_112380 n1_M2_48660_112380 0.988200
R12525 n1_M2_48660_112380 n1_M2_49740_112380 0.988200
R12526 n1_M2_49740_112380 n1_M2_50820_112380 0.988200
R12527 n1_M2_50820_112380 n1_M2_51900_112380 0.988200
R12528 n1_M2_51900_112380 n1_M2_52980_112380 0.988200
R12529 n1_M2_52980_112380 n1_M2_54060_112380 0.988200
R12530 n1_M2_54060_112380 n1_M2_55140_112380 0.988200
R12531 n1_M2_55140_112380 n1_M2_56220_112380 0.988200
R12532 n1_M2_56220_112380 n1_M2_57300_112380 0.988200
R12533 n1_M2_57300_112380 n1_M2_58380_112380 0.988200
R12534 n1_M2_58380_112380 n1_M2_59460_112380 0.988200
R12535 n1_M2_59460_112380 n1_M2_60540_112380 0.988200
R12536 n1_M2_60540_112380 n1_M2_61620_112380 0.988200
R12537 n1_M2_61620_112380 n1_M2_62700_112380 0.988200
R12538 n1_M2_62700_112380 n1_M2_63780_112380 0.988200
R12539 n1_M2_63780_112380 n1_M2_64860_112380 0.988200
R12540 n1_M2_64860_112380 n1_M2_65940_112380 0.988200
R12541 n1_M2_65940_112380 n1_M2_67020_112380 0.988200
R12542 n1_M2_67020_112380 n1_M2_68100_112380 0.988200
R12543 n1_M2_68100_112380 n1_M2_69180_112380 0.988200
R12544 n1_M2_69180_112380 n1_M2_70260_112380 0.988200
R12545 n1_M2_70260_112380 n1_M2_71340_112380 0.988200
R12546 n1_M2_71340_112380 n1_M2_72420_112380 0.988200
R12547 n1_M2_72420_112380 n1_M2_73500_112380 0.988200
R12548 n1_M2_73500_112380 n1_M2_74580_112380 0.988200
R12549 n1_M2_74580_112380 n1_M2_75660_112380 0.988200
R12550 n1_M2_75660_112380 n1_M2_76740_112380 0.988200
R12551 n1_M2_76740_112380 n1_M2_77820_112380 0.988200
R12552 n1_M2_77820_112380 n1_M2_78900_112380 0.988200
R12553 n1_M2_78900_112380 n1_M2_79980_112380 0.988200
R12554 n1_M2_79980_112380 n1_M2_81060_112380 0.988200
R12555 n1_M2_81060_112380 n1_M2_82140_112380 0.988200
R12556 n1_M2_82140_112380 n1_M2_83220_112380 0.988200
R12557 n1_M2_83220_112380 n1_M2_84300_112380 0.988200
R12558 n1_M2_84300_112380 n1_M2_85380_112380 0.988200
R12559 n1_M2_85380_112380 n1_M2_86460_112380 0.988200
R12560 n1_M2_86460_112380 n1_M2_87540_112380 0.988200
R12561 n1_M2_87540_112380 n1_M2_88620_112380 0.988200
R12562 n1_M2_88620_112380 n1_M2_89700_112380 0.988200
R12563 n1_M2_89700_112380 n1_M2_90780_112380 0.988200
R12564 n1_M2_90780_112380 n1_M2_91860_112380 0.988200
R12565 n1_M2_91860_112380 n1_M2_92940_112380 0.988200
R12566 n1_M2_92940_112380 n1_M2_94020_112380 0.988200
R12567 n1_M2_94020_112380 n1_M2_95100_112380 0.988200
R12568 n1_M2_95100_112380 n1_M2_96180_112380 0.988200
R12569 n1_M2_96180_112380 n1_M2_97260_112380 0.988200
R12570 n1_M2_97260_112380 n1_M2_98340_112380 0.988200
R12571 n1_M2_98340_112380 n1_M2_99420_112380 0.988200
R12572 n1_M2_99420_112380 n1_M2_100500_112380 0.988200
R12573 n1_M2_100500_112380 n1_M2_101580_112380 0.988200
R12574 n1_M2_101580_112380 n1_M2_102660_112380 0.988200
R12575 n1_M2_102660_112380 n1_M2_103740_112380 0.988200
R12576 n1_M2_103740_112380 n1_M2_104820_112380 0.988200
R12577 n1_M2_104820_112380 n1_M2_105900_112380 0.988200
R12578 n1_M2_105900_112380 n1_M2_106980_112380 0.988200
R12579 n1_M2_106980_112380 n1_M2_108060_112380 0.988200
R12580 n1_M2_108060_112380 n1_M2_109140_112380 0.988200
R12581 n1_M2_109140_112380 n1_M2_110220_112380 0.988200
R12582 n1_M2_110220_112380 n1_M2_111300_112380 0.988200
R12583 n1_M2_111300_112380 n1_M2_112380_112380 0.988200
R12584 n1_M2_112380_112380 n1_M2_113460_112380 0.988200
R12585 n1_M2_113460_112380 n1_M2_114540_112380 0.988200
R12586 n1_M2_114540_112380 n1_M2_115620_112380 0.988200
R12587 n1_M2_115620_112380 n1_M2_116700_112380 0.988200
R12588 n1_M2_116700_112380 n1_M2_117780_112380 0.988200
R12589 n1_M2_117780_112380 n1_M2_118860_112380 0.988200
R12590 n1_M2_118860_112380 n1_M2_119940_112380 0.988200
R12591 n1_M2_119940_112380 n1_M2_121020_112380 0.988200
R12592 n1_M2_121020_112380 n1_M2_122100_112380 0.988200
R12593 n1_M2_122100_112380 n1_M2_123180_112380 0.988200
R12594 n1_M2_123180_112380 n1_M2_124260_112380 0.988200
R12595 n1_M2_124260_112380 n1_M2_125340_112380 0.988200
R12596 n1_M2_125340_112380 n1_M2_126420_112380 0.988200
R12597 n1_M2_126420_112380 n1_M2_127500_112380 0.988200
R12598 n1_M2_127500_112380 n1_M2_128580_112380 0.988200
R12599 n1_M2_128580_112380 n1_M2_129660_112380 0.988200
R12600 n1_M2_60_113460 n1_M2_1140_113460 0.988200
R12601 n1_M2_1140_113460 n1_M2_2220_113460 0.988200
R12602 n1_M2_2220_113460 n1_M2_3300_113460 0.988200
R12603 n1_M2_3300_113460 n1_M2_4380_113460 0.988200
R12604 n1_M2_4380_113460 n1_M2_5460_113460 0.988200
R12605 n1_M2_5460_113460 n1_M2_6540_113460 0.988200
R12606 n1_M2_6540_113460 n1_M2_7620_113460 0.988200
R12607 n1_M2_7620_113460 n1_M2_8700_113460 0.988200
R12608 n1_M2_8700_113460 n1_M2_9780_113460 0.988200
R12609 n1_M2_9780_113460 n1_M2_10860_113460 0.988200
R12610 n1_M2_10860_113460 n1_M2_11940_113460 0.988200
R12611 n1_M2_11940_113460 n1_M2_13020_113460 0.988200
R12612 n1_M2_13020_113460 n1_M2_14100_113460 0.988200
R12613 n1_M2_14100_113460 n1_M2_15180_113460 0.988200
R12614 n1_M2_15180_113460 n1_M2_16260_113460 0.988200
R12615 n1_M2_16260_113460 n1_M2_17340_113460 0.988200
R12616 n1_M2_17340_113460 n1_M2_18420_113460 0.988200
R12617 n1_M2_18420_113460 n1_M2_19500_113460 0.988200
R12618 n1_M2_19500_113460 n1_M2_20580_113460 0.988200
R12619 n1_M2_20580_113460 n1_M2_21660_113460 0.988200
R12620 n1_M2_21660_113460 n1_M2_22740_113460 0.988200
R12621 n1_M2_22740_113460 n1_M2_23820_113460 0.988200
R12622 n1_M2_23820_113460 n1_M2_24900_113460 0.988200
R12623 n1_M2_24900_113460 n1_M2_25980_113460 0.988200
R12624 n1_M2_25980_113460 n1_M2_27060_113460 0.988200
R12625 n1_M2_27060_113460 n1_M2_28140_113460 0.988200
R12626 n1_M2_28140_113460 n1_M2_29220_113460 0.988200
R12627 n1_M2_29220_113460 n1_M2_30300_113460 0.988200
R12628 n1_M2_30300_113460 n1_M2_31380_113460 0.988200
R12629 n1_M2_31380_113460 n1_M2_32460_113460 0.988200
R12630 n1_M2_32460_113460 n1_M2_33540_113460 0.988200
R12631 n1_M2_33540_113460 n1_M2_34620_113460 0.988200
R12632 n1_M2_34620_113460 n1_M2_35700_113460 0.988200
R12633 n1_M2_35700_113460 n1_M2_36780_113460 0.988200
R12634 n1_M2_36780_113460 n1_M2_37860_113460 0.988200
R12635 n1_M2_37860_113460 n1_M2_38940_113460 0.988200
R12636 n1_M2_38940_113460 n1_M2_40020_113460 0.988200
R12637 n1_M2_40020_113460 n1_M2_41100_113460 0.988200
R12638 n1_M2_41100_113460 n1_M2_42180_113460 0.988200
R12639 n1_M2_42180_113460 n1_M2_43260_113460 0.988200
R12640 n1_M2_43260_113460 n1_M2_44340_113460 0.988200
R12641 n1_M2_44340_113460 n1_M2_45420_113460 0.988200
R12642 n1_M2_45420_113460 n1_M2_46500_113460 0.988200
R12643 n1_M2_46500_113460 n1_M2_47580_113460 0.988200
R12644 n1_M2_47580_113460 n1_M2_48660_113460 0.988200
R12645 n1_M2_48660_113460 n1_M2_49740_113460 0.988200
R12646 n1_M2_49740_113460 n1_M2_50820_113460 0.988200
R12647 n1_M2_50820_113460 n1_M2_51900_113460 0.988200
R12648 n1_M2_51900_113460 n1_M2_52980_113460 0.988200
R12649 n1_M2_52980_113460 n1_M2_54060_113460 0.988200
R12650 n1_M2_54060_113460 n1_M2_55140_113460 0.988200
R12651 n1_M2_55140_113460 n1_M2_56220_113460 0.988200
R12652 n1_M2_56220_113460 n1_M2_57300_113460 0.988200
R12653 n1_M2_57300_113460 n1_M2_58380_113460 0.988200
R12654 n1_M2_58380_113460 n1_M2_59460_113460 0.988200
R12655 n1_M2_59460_113460 n1_M2_60540_113460 0.988200
R12656 n1_M2_60540_113460 n1_M2_61620_113460 0.988200
R12657 n1_M2_61620_113460 n1_M2_62700_113460 0.988200
R12658 n1_M2_62700_113460 n1_M2_63780_113460 0.988200
R12659 n1_M2_63780_113460 n1_M2_64860_113460 0.988200
R12660 n1_M2_64860_113460 n1_M2_65940_113460 0.988200
R12661 n1_M2_65940_113460 n1_M2_67020_113460 0.988200
R12662 n1_M2_67020_113460 n1_M2_68100_113460 0.988200
R12663 n1_M2_68100_113460 n1_M2_69180_113460 0.988200
R12664 n1_M2_69180_113460 n1_M2_70260_113460 0.988200
R12665 n1_M2_70260_113460 n1_M2_71340_113460 0.988200
R12666 n1_M2_71340_113460 n1_M2_72420_113460 0.988200
R12667 n1_M2_72420_113460 n1_M2_73500_113460 0.988200
R12668 n1_M2_73500_113460 n1_M2_74580_113460 0.988200
R12669 n1_M2_74580_113460 n1_M2_75660_113460 0.988200
R12670 n1_M2_75660_113460 n1_M2_76740_113460 0.988200
R12671 n1_M2_76740_113460 n1_M2_77820_113460 0.988200
R12672 n1_M2_77820_113460 n1_M2_78900_113460 0.988200
R12673 n1_M2_78900_113460 n1_M2_79980_113460 0.988200
R12674 n1_M2_79980_113460 n1_M2_81060_113460 0.988200
R12675 n1_M2_81060_113460 n1_M2_82140_113460 0.988200
R12676 n1_M2_82140_113460 n1_M2_83220_113460 0.988200
R12677 n1_M2_83220_113460 n1_M2_84300_113460 0.988200
R12678 n1_M2_84300_113460 n1_M2_85380_113460 0.988200
R12679 n1_M2_85380_113460 n1_M2_86460_113460 0.988200
R12680 n1_M2_86460_113460 n1_M2_87540_113460 0.988200
R12681 n1_M2_87540_113460 n1_M2_88620_113460 0.988200
R12682 n1_M2_88620_113460 n1_M2_89700_113460 0.988200
R12683 n1_M2_89700_113460 n1_M2_90780_113460 0.988200
R12684 n1_M2_90780_113460 n1_M2_91860_113460 0.988200
R12685 n1_M2_91860_113460 n1_M2_92940_113460 0.988200
R12686 n1_M2_92940_113460 n1_M2_94020_113460 0.988200
R12687 n1_M2_94020_113460 n1_M2_95100_113460 0.988200
R12688 n1_M2_95100_113460 n1_M2_96180_113460 0.988200
R12689 n1_M2_96180_113460 n1_M2_97260_113460 0.988200
R12690 n1_M2_97260_113460 n1_M2_98340_113460 0.988200
R12691 n1_M2_98340_113460 n1_M2_99420_113460 0.988200
R12692 n1_M2_99420_113460 n1_M2_100500_113460 0.988200
R12693 n1_M2_100500_113460 n1_M2_101580_113460 0.988200
R12694 n1_M2_101580_113460 n1_M2_102660_113460 0.988200
R12695 n1_M2_102660_113460 n1_M2_103740_113460 0.988200
R12696 n1_M2_103740_113460 n1_M2_104820_113460 0.988200
R12697 n1_M2_104820_113460 n1_M2_105900_113460 0.988200
R12698 n1_M2_105900_113460 n1_M2_106980_113460 0.988200
R12699 n1_M2_106980_113460 n1_M2_108060_113460 0.988200
R12700 n1_M2_108060_113460 n1_M2_109140_113460 0.988200
R12701 n1_M2_109140_113460 n1_M2_110220_113460 0.988200
R12702 n1_M2_110220_113460 n1_M2_111300_113460 0.988200
R12703 n1_M2_111300_113460 n1_M2_112380_113460 0.988200
R12704 n1_M2_112380_113460 n1_M2_113460_113460 0.988200
R12705 n1_M2_113460_113460 n1_M2_114540_113460 0.988200
R12706 n1_M2_114540_113460 n1_M2_115620_113460 0.988200
R12707 n1_M2_115620_113460 n1_M2_116700_113460 0.988200
R12708 n1_M2_116700_113460 n1_M2_117780_113460 0.988200
R12709 n1_M2_117780_113460 n1_M2_118860_113460 0.988200
R12710 n1_M2_118860_113460 n1_M2_119940_113460 0.988200
R12711 n1_M2_119940_113460 n1_M2_121020_113460 0.988200
R12712 n1_M2_121020_113460 n1_M2_122100_113460 0.988200
R12713 n1_M2_122100_113460 n1_M2_123180_113460 0.988200
R12714 n1_M2_123180_113460 n1_M2_124260_113460 0.988200
R12715 n1_M2_124260_113460 n1_M2_125340_113460 0.988200
R12716 n1_M2_125340_113460 n1_M2_126420_113460 0.988200
R12717 n1_M2_126420_113460 n1_M2_127500_113460 0.988200
R12718 n1_M2_127500_113460 n1_M2_128580_113460 0.988200
R12719 n1_M2_128580_113460 n1_M2_129660_113460 0.988200
R12720 n1_M2_60_114540 n1_M2_1140_114540 0.988200
R12721 n1_M2_1140_114540 n1_M2_2220_114540 0.988200
R12722 n1_M2_2220_114540 n1_M2_3300_114540 0.988200
R12723 n1_M2_3300_114540 n1_M2_4380_114540 0.988200
R12724 n1_M2_4380_114540 n1_M2_5460_114540 0.988200
R12725 n1_M2_5460_114540 n1_M2_6540_114540 0.988200
R12726 n1_M2_6540_114540 n1_M2_7620_114540 0.988200
R12727 n1_M2_7620_114540 n1_M2_8700_114540 0.988200
R12728 n1_M2_8700_114540 n1_M2_9780_114540 0.988200
R12729 n1_M2_9780_114540 n1_M2_10860_114540 0.988200
R12730 n1_M2_10860_114540 n1_M2_11940_114540 0.988200
R12731 n1_M2_11940_114540 n1_M2_13020_114540 0.988200
R12732 n1_M2_13020_114540 n1_M2_14100_114540 0.988200
R12733 n1_M2_14100_114540 n1_M2_15180_114540 0.988200
R12734 n1_M2_15180_114540 n1_M2_16260_114540 0.988200
R12735 n1_M2_16260_114540 n1_M2_17340_114540 0.988200
R12736 n1_M2_17340_114540 n1_M2_18420_114540 0.988200
R12737 n1_M2_18420_114540 n1_M2_19500_114540 0.988200
R12738 n1_M2_19500_114540 n1_M2_20580_114540 0.988200
R12739 n1_M2_20580_114540 n1_M2_21660_114540 0.988200
R12740 n1_M2_21660_114540 n1_M2_22740_114540 0.988200
R12741 n1_M2_22740_114540 n1_M2_23820_114540 0.988200
R12742 n1_M2_23820_114540 n1_M2_24900_114540 0.988200
R12743 n1_M2_24900_114540 n1_M2_25980_114540 0.988200
R12744 n1_M2_25980_114540 n1_M2_27060_114540 0.988200
R12745 n1_M2_27060_114540 n1_M2_28140_114540 0.988200
R12746 n1_M2_28140_114540 n1_M2_29220_114540 0.988200
R12747 n1_M2_29220_114540 n1_M2_30300_114540 0.988200
R12748 n1_M2_30300_114540 n1_M2_31380_114540 0.988200
R12749 n1_M2_31380_114540 n1_M2_32460_114540 0.988200
R12750 n1_M2_32460_114540 n1_M2_33540_114540 0.988200
R12751 n1_M2_33540_114540 n1_M2_34620_114540 0.988200
R12752 n1_M2_34620_114540 n1_M2_35700_114540 0.988200
R12753 n1_M2_35700_114540 n1_M2_36780_114540 0.988200
R12754 n1_M2_36780_114540 n1_M2_37860_114540 0.988200
R12755 n1_M2_37860_114540 n1_M2_38940_114540 0.988200
R12756 n1_M2_38940_114540 n1_M2_40020_114540 0.988200
R12757 n1_M2_40020_114540 n1_M2_41100_114540 0.988200
R12758 n1_M2_41100_114540 n1_M2_42180_114540 0.988200
R12759 n1_M2_42180_114540 n1_M2_43260_114540 0.988200
R12760 n1_M2_43260_114540 n1_M2_44340_114540 0.988200
R12761 n1_M2_44340_114540 n1_M2_45420_114540 0.988200
R12762 n1_M2_45420_114540 n1_M2_46500_114540 0.988200
R12763 n1_M2_46500_114540 n1_M2_47580_114540 0.988200
R12764 n1_M2_47580_114540 n1_M2_48660_114540 0.988200
R12765 n1_M2_48660_114540 n1_M2_49740_114540 0.988200
R12766 n1_M2_49740_114540 n1_M2_50820_114540 0.988200
R12767 n1_M2_50820_114540 n1_M2_51900_114540 0.988200
R12768 n1_M2_51900_114540 n1_M2_52980_114540 0.988200
R12769 n1_M2_52980_114540 n1_M2_54060_114540 0.988200
R12770 n1_M2_54060_114540 n1_M2_55140_114540 0.988200
R12771 n1_M2_55140_114540 n1_M2_56220_114540 0.988200
R12772 n1_M2_56220_114540 n1_M2_57300_114540 0.988200
R12773 n1_M2_57300_114540 n1_M2_58380_114540 0.988200
R12774 n1_M2_58380_114540 n1_M2_59460_114540 0.988200
R12775 n1_M2_59460_114540 n1_M2_60540_114540 0.988200
R12776 n1_M2_60540_114540 n1_M2_61620_114540 0.988200
R12777 n1_M2_61620_114540 n1_M2_62700_114540 0.988200
R12778 n1_M2_62700_114540 n1_M2_63780_114540 0.988200
R12779 n1_M2_63780_114540 n1_M2_64860_114540 0.988200
R12780 n1_M2_64860_114540 n1_M2_65940_114540 0.988200
R12781 n1_M2_65940_114540 n1_M2_67020_114540 0.988200
R12782 n1_M2_67020_114540 n1_M2_68100_114540 0.988200
R12783 n1_M2_68100_114540 n1_M2_69180_114540 0.988200
R12784 n1_M2_69180_114540 n1_M2_70260_114540 0.988200
R12785 n1_M2_70260_114540 n1_M2_71340_114540 0.988200
R12786 n1_M2_71340_114540 n1_M2_72420_114540 0.988200
R12787 n1_M2_72420_114540 n1_M2_73500_114540 0.988200
R12788 n1_M2_73500_114540 n1_M2_74580_114540 0.988200
R12789 n1_M2_74580_114540 n1_M2_75660_114540 0.988200
R12790 n1_M2_75660_114540 n1_M2_76740_114540 0.988200
R12791 n1_M2_76740_114540 n1_M2_77820_114540 0.988200
R12792 n1_M2_77820_114540 n1_M2_78900_114540 0.988200
R12793 n1_M2_78900_114540 n1_M2_79980_114540 0.988200
R12794 n1_M2_79980_114540 n1_M2_81060_114540 0.988200
R12795 n1_M2_81060_114540 n1_M2_82140_114540 0.988200
R12796 n1_M2_82140_114540 n1_M2_83220_114540 0.988200
R12797 n1_M2_83220_114540 n1_M2_84300_114540 0.988200
R12798 n1_M2_84300_114540 n1_M2_85380_114540 0.988200
R12799 n1_M2_85380_114540 n1_M2_86460_114540 0.988200
R12800 n1_M2_86460_114540 n1_M2_87540_114540 0.988200
R12801 n1_M2_87540_114540 n1_M2_88620_114540 0.988200
R12802 n1_M2_88620_114540 n1_M2_89700_114540 0.988200
R12803 n1_M2_89700_114540 n1_M2_90780_114540 0.988200
R12804 n1_M2_90780_114540 n1_M2_91860_114540 0.988200
R12805 n1_M2_91860_114540 n1_M2_92940_114540 0.988200
R12806 n1_M2_92940_114540 n1_M2_94020_114540 0.988200
R12807 n1_M2_94020_114540 n1_M2_95100_114540 0.988200
R12808 n1_M2_95100_114540 n1_M2_96180_114540 0.988200
R12809 n1_M2_96180_114540 n1_M2_97260_114540 0.988200
R12810 n1_M2_97260_114540 n1_M2_98340_114540 0.988200
R12811 n1_M2_98340_114540 n1_M2_99420_114540 0.988200
R12812 n1_M2_99420_114540 n1_M2_100500_114540 0.988200
R12813 n1_M2_100500_114540 n1_M2_101580_114540 0.988200
R12814 n1_M2_101580_114540 n1_M2_102660_114540 0.988200
R12815 n1_M2_102660_114540 n1_M2_103740_114540 0.988200
R12816 n1_M2_103740_114540 n1_M2_104820_114540 0.988200
R12817 n1_M2_104820_114540 n1_M2_105900_114540 0.988200
R12818 n1_M2_105900_114540 n1_M2_106980_114540 0.988200
R12819 n1_M2_106980_114540 n1_M2_108060_114540 0.988200
R12820 n1_M2_108060_114540 n1_M2_109140_114540 0.988200
R12821 n1_M2_109140_114540 n1_M2_110220_114540 0.988200
R12822 n1_M2_110220_114540 n1_M2_111300_114540 0.988200
R12823 n1_M2_111300_114540 n1_M2_112380_114540 0.988200
R12824 n1_M2_112380_114540 n1_M2_113460_114540 0.988200
R12825 n1_M2_113460_114540 n1_M2_114540_114540 0.988200
R12826 n1_M2_114540_114540 n1_M2_115620_114540 0.988200
R12827 n1_M2_115620_114540 n1_M2_116700_114540 0.988200
R12828 n1_M2_116700_114540 n1_M2_117780_114540 0.988200
R12829 n1_M2_117780_114540 n1_M2_118860_114540 0.988200
R12830 n1_M2_118860_114540 n1_M2_119940_114540 0.988200
R12831 n1_M2_119940_114540 n1_M2_121020_114540 0.988200
R12832 n1_M2_121020_114540 n1_M2_122100_114540 0.988200
R12833 n1_M2_122100_114540 n1_M2_123180_114540 0.988200
R12834 n1_M2_123180_114540 n1_M2_124260_114540 0.988200
R12835 n1_M2_124260_114540 n1_M2_125340_114540 0.988200
R12836 n1_M2_125340_114540 n1_M2_126420_114540 0.988200
R12837 n1_M2_126420_114540 n1_M2_127500_114540 0.988200
R12838 n1_M2_127500_114540 n1_M2_128580_114540 0.988200
R12839 n1_M2_128580_114540 n1_M2_129660_114540 0.988200
R12840 n1_M2_60_115620 n1_M2_1140_115620 0.988200
R12841 n1_M2_1140_115620 n1_M2_2220_115620 0.988200
R12842 n1_M2_2220_115620 n1_M2_3300_115620 0.988200
R12843 n1_M2_3300_115620 n1_M2_4380_115620 0.988200
R12844 n1_M2_4380_115620 n1_M2_5460_115620 0.988200
R12845 n1_M2_5460_115620 n1_M2_6540_115620 0.988200
R12846 n1_M2_6540_115620 n1_M2_7620_115620 0.988200
R12847 n1_M2_7620_115620 n1_M2_8700_115620 0.988200
R12848 n1_M2_8700_115620 n1_M2_9780_115620 0.988200
R12849 n1_M2_9780_115620 n1_M2_10860_115620 0.988200
R12850 n1_M2_10860_115620 n1_M2_11940_115620 0.988200
R12851 n1_M2_11940_115620 n1_M2_13020_115620 0.988200
R12852 n1_M2_13020_115620 n1_M2_14100_115620 0.988200
R12853 n1_M2_14100_115620 n1_M2_15180_115620 0.988200
R12854 n1_M2_15180_115620 n1_M2_16260_115620 0.988200
R12855 n1_M2_16260_115620 n1_M2_17340_115620 0.988200
R12856 n1_M2_17340_115620 n1_M2_18420_115620 0.988200
R12857 n1_M2_18420_115620 n1_M2_19500_115620 0.988200
R12858 n1_M2_19500_115620 n1_M2_20580_115620 0.988200
R12859 n1_M2_20580_115620 n1_M2_21660_115620 0.988200
R12860 n1_M2_21660_115620 n1_M2_22740_115620 0.988200
R12861 n1_M2_22740_115620 n1_M2_23820_115620 0.988200
R12862 n1_M2_23820_115620 n1_M2_24900_115620 0.988200
R12863 n1_M2_24900_115620 n1_M2_25980_115620 0.988200
R12864 n1_M2_25980_115620 n1_M2_27060_115620 0.988200
R12865 n1_M2_27060_115620 n1_M2_28140_115620 0.988200
R12866 n1_M2_28140_115620 n1_M2_29220_115620 0.988200
R12867 n1_M2_29220_115620 n1_M2_30300_115620 0.988200
R12868 n1_M2_30300_115620 n1_M2_31380_115620 0.988200
R12869 n1_M2_31380_115620 n1_M2_32460_115620 0.988200
R12870 n1_M2_32460_115620 n1_M2_33540_115620 0.988200
R12871 n1_M2_33540_115620 n1_M2_34620_115620 0.988200
R12872 n1_M2_34620_115620 n1_M2_35700_115620 0.988200
R12873 n1_M2_35700_115620 n1_M2_36780_115620 0.988200
R12874 n1_M2_36780_115620 n1_M2_37860_115620 0.988200
R12875 n1_M2_37860_115620 n1_M2_38940_115620 0.988200
R12876 n1_M2_38940_115620 n1_M2_40020_115620 0.988200
R12877 n1_M2_40020_115620 n1_M2_41100_115620 0.988200
R12878 n1_M2_41100_115620 n1_M2_42180_115620 0.988200
R12879 n1_M2_42180_115620 n1_M2_43260_115620 0.988200
R12880 n1_M2_43260_115620 n1_M2_44340_115620 0.988200
R12881 n1_M2_44340_115620 n1_M2_45420_115620 0.988200
R12882 n1_M2_45420_115620 n1_M2_46500_115620 0.988200
R12883 n1_M2_46500_115620 n1_M2_47580_115620 0.988200
R12884 n1_M2_47580_115620 n1_M2_48660_115620 0.988200
R12885 n1_M2_48660_115620 n1_M2_49740_115620 0.988200
R12886 n1_M2_49740_115620 n1_M2_50820_115620 0.988200
R12887 n1_M2_50820_115620 n1_M2_51900_115620 0.988200
R12888 n1_M2_51900_115620 n1_M2_52980_115620 0.988200
R12889 n1_M2_52980_115620 n1_M2_54060_115620 0.988200
R12890 n1_M2_54060_115620 n1_M2_55140_115620 0.988200
R12891 n1_M2_55140_115620 n1_M2_56220_115620 0.988200
R12892 n1_M2_56220_115620 n1_M2_57300_115620 0.988200
R12893 n1_M2_57300_115620 n1_M2_58380_115620 0.988200
R12894 n1_M2_58380_115620 n1_M2_59460_115620 0.988200
R12895 n1_M2_59460_115620 n1_M2_60540_115620 0.988200
R12896 n1_M2_60540_115620 n1_M2_61620_115620 0.988200
R12897 n1_M2_61620_115620 n1_M2_62700_115620 0.988200
R12898 n1_M2_62700_115620 n1_M2_63780_115620 0.988200
R12899 n1_M2_63780_115620 n1_M2_64860_115620 0.988200
R12900 n1_M2_64860_115620 n1_M2_65940_115620 0.988200
R12901 n1_M2_65940_115620 n1_M2_67020_115620 0.988200
R12902 n1_M2_67020_115620 n1_M2_68100_115620 0.988200
R12903 n1_M2_68100_115620 n1_M2_69180_115620 0.988200
R12904 n1_M2_69180_115620 n1_M2_70260_115620 0.988200
R12905 n1_M2_70260_115620 n1_M2_71340_115620 0.988200
R12906 n1_M2_71340_115620 n1_M2_72420_115620 0.988200
R12907 n1_M2_72420_115620 n1_M2_73500_115620 0.988200
R12908 n1_M2_73500_115620 n1_M2_74580_115620 0.988200
R12909 n1_M2_74580_115620 n1_M2_75660_115620 0.988200
R12910 n1_M2_75660_115620 n1_M2_76740_115620 0.988200
R12911 n1_M2_76740_115620 n1_M2_77820_115620 0.988200
R12912 n1_M2_77820_115620 n1_M2_78900_115620 0.988200
R12913 n1_M2_78900_115620 n1_M2_79980_115620 0.988200
R12914 n1_M2_79980_115620 n1_M2_81060_115620 0.988200
R12915 n1_M2_81060_115620 n1_M2_82140_115620 0.988200
R12916 n1_M2_82140_115620 n1_M2_83220_115620 0.988200
R12917 n1_M2_83220_115620 n1_M2_84300_115620 0.988200
R12918 n1_M2_84300_115620 n1_M2_85380_115620 0.988200
R12919 n1_M2_85380_115620 n1_M2_86460_115620 0.988200
R12920 n1_M2_86460_115620 n1_M2_87540_115620 0.988200
R12921 n1_M2_87540_115620 n1_M2_88620_115620 0.988200
R12922 n1_M2_88620_115620 n1_M2_89700_115620 0.988200
R12923 n1_M2_89700_115620 n1_M2_90780_115620 0.988200
R12924 n1_M2_90780_115620 n1_M2_91860_115620 0.988200
R12925 n1_M2_91860_115620 n1_M2_92940_115620 0.988200
R12926 n1_M2_92940_115620 n1_M2_94020_115620 0.988200
R12927 n1_M2_94020_115620 n1_M2_95100_115620 0.988200
R12928 n1_M2_95100_115620 n1_M2_96180_115620 0.988200
R12929 n1_M2_96180_115620 n1_M2_97260_115620 0.988200
R12930 n1_M2_97260_115620 n1_M2_98340_115620 0.988200
R12931 n1_M2_98340_115620 n1_M2_99420_115620 0.988200
R12932 n1_M2_99420_115620 n1_M2_100500_115620 0.988200
R12933 n1_M2_100500_115620 n1_M2_101580_115620 0.988200
R12934 n1_M2_101580_115620 n1_M2_102660_115620 0.988200
R12935 n1_M2_102660_115620 n1_M2_103740_115620 0.988200
R12936 n1_M2_103740_115620 n1_M2_104820_115620 0.988200
R12937 n1_M2_104820_115620 n1_M2_105900_115620 0.988200
R12938 n1_M2_105900_115620 n1_M2_106980_115620 0.988200
R12939 n1_M2_106980_115620 n1_M2_108060_115620 0.988200
R12940 n1_M2_108060_115620 n1_M2_109140_115620 0.988200
R12941 n1_M2_109140_115620 n1_M2_110220_115620 0.988200
R12942 n1_M2_110220_115620 n1_M2_111300_115620 0.988200
R12943 n1_M2_111300_115620 n1_M2_112380_115620 0.988200
R12944 n1_M2_112380_115620 n1_M2_113460_115620 0.988200
R12945 n1_M2_113460_115620 n1_M2_114540_115620 0.988200
R12946 n1_M2_114540_115620 n1_M2_115620_115620 0.988200
R12947 n1_M2_115620_115620 n1_M2_116700_115620 0.988200
R12948 n1_M2_116700_115620 n1_M2_117780_115620 0.988200
R12949 n1_M2_117780_115620 n1_M2_118860_115620 0.988200
R12950 n1_M2_118860_115620 n1_M2_119940_115620 0.988200
R12951 n1_M2_119940_115620 n1_M2_121020_115620 0.988200
R12952 n1_M2_121020_115620 n1_M2_122100_115620 0.988200
R12953 n1_M2_122100_115620 n1_M2_123180_115620 0.988200
R12954 n1_M2_123180_115620 n1_M2_124260_115620 0.988200
R12955 n1_M2_124260_115620 n1_M2_125340_115620 0.988200
R12956 n1_M2_125340_115620 n1_M2_126420_115620 0.988200
R12957 n1_M2_126420_115620 n1_M2_127500_115620 0.988200
R12958 n1_M2_127500_115620 n1_M2_128580_115620 0.988200
R12959 n1_M2_128580_115620 n1_M2_129660_115620 0.988200
R12960 n1_M2_60_116700 n1_M2_1140_116700 0.988200
R12961 n1_M2_1140_116700 n1_M2_2220_116700 0.988200
R12962 n1_M2_2220_116700 n1_M2_3300_116700 0.988200
R12963 n1_M2_3300_116700 n1_M2_4380_116700 0.988200
R12964 n1_M2_4380_116700 n1_M2_5460_116700 0.988200
R12965 n1_M2_5460_116700 n1_M2_6540_116700 0.988200
R12966 n1_M2_6540_116700 n1_M2_7620_116700 0.988200
R12967 n1_M2_7620_116700 n1_M2_8700_116700 0.988200
R12968 n1_M2_8700_116700 n1_M2_9780_116700 0.988200
R12969 n1_M2_9780_116700 n1_M2_10860_116700 0.988200
R12970 n1_M2_10860_116700 n1_M2_11940_116700 0.988200
R12971 n1_M2_11940_116700 n1_M2_13020_116700 0.988200
R12972 n1_M2_13020_116700 n1_M2_14100_116700 0.988200
R12973 n1_M2_14100_116700 n1_M2_15180_116700 0.988200
R12974 n1_M2_15180_116700 n1_M2_16260_116700 0.988200
R12975 n1_M2_16260_116700 n1_M2_17340_116700 0.988200
R12976 n1_M2_17340_116700 n1_M2_18420_116700 0.988200
R12977 n1_M2_18420_116700 n1_M2_19500_116700 0.988200
R12978 n1_M2_19500_116700 n1_M2_20580_116700 0.988200
R12979 n1_M2_20580_116700 n1_M2_21660_116700 0.988200
R12980 n1_M2_21660_116700 n1_M2_22740_116700 0.988200
R12981 n1_M2_22740_116700 n1_M2_23820_116700 0.988200
R12982 n1_M2_23820_116700 n1_M2_24900_116700 0.988200
R12983 n1_M2_24900_116700 n1_M2_25980_116700 0.988200
R12984 n1_M2_25980_116700 n1_M2_27060_116700 0.988200
R12985 n1_M2_27060_116700 n1_M2_28140_116700 0.988200
R12986 n1_M2_28140_116700 n1_M2_29220_116700 0.988200
R12987 n1_M2_29220_116700 n1_M2_30300_116700 0.988200
R12988 n1_M2_30300_116700 n1_M2_31380_116700 0.988200
R12989 n1_M2_31380_116700 n1_M2_32460_116700 0.988200
R12990 n1_M2_32460_116700 n1_M2_33540_116700 0.988200
R12991 n1_M2_33540_116700 n1_M2_34620_116700 0.988200
R12992 n1_M2_34620_116700 n1_M2_35700_116700 0.988200
R12993 n1_M2_35700_116700 n1_M2_36780_116700 0.988200
R12994 n1_M2_36780_116700 n1_M2_37860_116700 0.988200
R12995 n1_M2_37860_116700 n1_M2_38940_116700 0.988200
R12996 n1_M2_38940_116700 n1_M2_40020_116700 0.988200
R12997 n1_M2_40020_116700 n1_M2_41100_116700 0.988200
R12998 n1_M2_41100_116700 n1_M2_42180_116700 0.988200
R12999 n1_M2_42180_116700 n1_M2_43260_116700 0.988200
R13000 n1_M2_43260_116700 n1_M2_44340_116700 0.988200
R13001 n1_M2_44340_116700 n1_M2_45420_116700 0.988200
R13002 n1_M2_45420_116700 n1_M2_46500_116700 0.988200
R13003 n1_M2_46500_116700 n1_M2_47580_116700 0.988200
R13004 n1_M2_47580_116700 n1_M2_48660_116700 0.988200
R13005 n1_M2_48660_116700 n1_M2_49740_116700 0.988200
R13006 n1_M2_49740_116700 n1_M2_50820_116700 0.988200
R13007 n1_M2_50820_116700 n1_M2_51900_116700 0.988200
R13008 n1_M2_51900_116700 n1_M2_52980_116700 0.988200
R13009 n1_M2_52980_116700 n1_M2_54060_116700 0.988200
R13010 n1_M2_54060_116700 n1_M2_55140_116700 0.988200
R13011 n1_M2_55140_116700 n1_M2_56220_116700 0.988200
R13012 n1_M2_56220_116700 n1_M2_57300_116700 0.988200
R13013 n1_M2_57300_116700 n1_M2_58380_116700 0.988200
R13014 n1_M2_58380_116700 n1_M2_59460_116700 0.988200
R13015 n1_M2_59460_116700 n1_M2_60540_116700 0.988200
R13016 n1_M2_60540_116700 n1_M2_61620_116700 0.988200
R13017 n1_M2_61620_116700 n1_M2_62700_116700 0.988200
R13018 n1_M2_62700_116700 n1_M2_63780_116700 0.988200
R13019 n1_M2_63780_116700 n1_M2_64860_116700 0.988200
R13020 n1_M2_64860_116700 n1_M2_65940_116700 0.988200
R13021 n1_M2_65940_116700 n1_M2_67020_116700 0.988200
R13022 n1_M2_67020_116700 n1_M2_68100_116700 0.988200
R13023 n1_M2_68100_116700 n1_M2_69180_116700 0.988200
R13024 n1_M2_69180_116700 n1_M2_70260_116700 0.988200
R13025 n1_M2_70260_116700 n1_M2_71340_116700 0.988200
R13026 n1_M2_71340_116700 n1_M2_72420_116700 0.988200
R13027 n1_M2_72420_116700 n1_M2_73500_116700 0.988200
R13028 n1_M2_73500_116700 n1_M2_74580_116700 0.988200
R13029 n1_M2_74580_116700 n1_M2_75660_116700 0.988200
R13030 n1_M2_75660_116700 n1_M2_76740_116700 0.988200
R13031 n1_M2_76740_116700 n1_M2_77820_116700 0.988200
R13032 n1_M2_77820_116700 n1_M2_78900_116700 0.988200
R13033 n1_M2_78900_116700 n1_M2_79980_116700 0.988200
R13034 n1_M2_79980_116700 n1_M2_81060_116700 0.988200
R13035 n1_M2_81060_116700 n1_M2_82140_116700 0.988200
R13036 n1_M2_82140_116700 n1_M2_83220_116700 0.988200
R13037 n1_M2_83220_116700 n1_M2_84300_116700 0.988200
R13038 n1_M2_84300_116700 n1_M2_85380_116700 0.988200
R13039 n1_M2_85380_116700 n1_M2_86460_116700 0.988200
R13040 n1_M2_86460_116700 n1_M2_87540_116700 0.988200
R13041 n1_M2_87540_116700 n1_M2_88620_116700 0.988200
R13042 n1_M2_88620_116700 n1_M2_89700_116700 0.988200
R13043 n1_M2_89700_116700 n1_M2_90780_116700 0.988200
R13044 n1_M2_90780_116700 n1_M2_91860_116700 0.988200
R13045 n1_M2_91860_116700 n1_M2_92940_116700 0.988200
R13046 n1_M2_92940_116700 n1_M2_94020_116700 0.988200
R13047 n1_M2_94020_116700 n1_M2_95100_116700 0.988200
R13048 n1_M2_95100_116700 n1_M2_96180_116700 0.988200
R13049 n1_M2_96180_116700 n1_M2_97260_116700 0.988200
R13050 n1_M2_97260_116700 n1_M2_98340_116700 0.988200
R13051 n1_M2_98340_116700 n1_M2_99420_116700 0.988200
R13052 n1_M2_99420_116700 n1_M2_100500_116700 0.988200
R13053 n1_M2_100500_116700 n1_M2_101580_116700 0.988200
R13054 n1_M2_101580_116700 n1_M2_102660_116700 0.988200
R13055 n1_M2_102660_116700 n1_M2_103740_116700 0.988200
R13056 n1_M2_103740_116700 n1_M2_104820_116700 0.988200
R13057 n1_M2_104820_116700 n1_M2_105900_116700 0.988200
R13058 n1_M2_105900_116700 n1_M2_106980_116700 0.988200
R13059 n1_M2_106980_116700 n1_M2_108060_116700 0.988200
R13060 n1_M2_108060_116700 n1_M2_109140_116700 0.988200
R13061 n1_M2_109140_116700 n1_M2_110220_116700 0.988200
R13062 n1_M2_110220_116700 n1_M2_111300_116700 0.988200
R13063 n1_M2_111300_116700 n1_M2_112380_116700 0.988200
R13064 n1_M2_112380_116700 n1_M2_113460_116700 0.988200
R13065 n1_M2_113460_116700 n1_M2_114540_116700 0.988200
R13066 n1_M2_114540_116700 n1_M2_115620_116700 0.988200
R13067 n1_M2_115620_116700 n1_M2_116700_116700 0.988200
R13068 n1_M2_116700_116700 n1_M2_117780_116700 0.988200
R13069 n1_M2_117780_116700 n1_M2_118860_116700 0.988200
R13070 n1_M2_118860_116700 n1_M2_119940_116700 0.988200
R13071 n1_M2_119940_116700 n1_M2_121020_116700 0.988200
R13072 n1_M2_121020_116700 n1_M2_122100_116700 0.988200
R13073 n1_M2_122100_116700 n1_M2_123180_116700 0.988200
R13074 n1_M2_123180_116700 n1_M2_124260_116700 0.988200
R13075 n1_M2_124260_116700 n1_M2_125340_116700 0.988200
R13076 n1_M2_125340_116700 n1_M2_126420_116700 0.988200
R13077 n1_M2_126420_116700 n1_M2_127500_116700 0.988200
R13078 n1_M2_127500_116700 n1_M2_128580_116700 0.988200
R13079 n1_M2_128580_116700 n1_M2_129660_116700 0.988200
R13080 n1_M2_60_117780 n1_M2_1140_117780 0.988200
R13081 n1_M2_1140_117780 n1_M2_2220_117780 0.988200
R13082 n1_M2_2220_117780 n1_M2_3300_117780 0.988200
R13083 n1_M2_3300_117780 n1_M2_4380_117780 0.988200
R13084 n1_M2_4380_117780 n1_M2_5460_117780 0.988200
R13085 n1_M2_5460_117780 n1_M2_6540_117780 0.988200
R13086 n1_M2_6540_117780 n1_M2_7620_117780 0.988200
R13087 n1_M2_7620_117780 n1_M2_8700_117780 0.988200
R13088 n1_M2_8700_117780 n1_M2_9780_117780 0.988200
R13089 n1_M2_9780_117780 n1_M2_10860_117780 0.988200
R13090 n1_M2_10860_117780 n1_M2_11940_117780 0.988200
R13091 n1_M2_11940_117780 n1_M2_13020_117780 0.988200
R13092 n1_M2_13020_117780 n1_M2_14100_117780 0.988200
R13093 n1_M2_14100_117780 n1_M2_15180_117780 0.988200
R13094 n1_M2_15180_117780 n1_M2_16260_117780 0.988200
R13095 n1_M2_16260_117780 n1_M2_17340_117780 0.988200
R13096 n1_M2_17340_117780 n1_M2_18420_117780 0.988200
R13097 n1_M2_18420_117780 n1_M2_19500_117780 0.988200
R13098 n1_M2_19500_117780 n1_M2_20580_117780 0.988200
R13099 n1_M2_20580_117780 n1_M2_21660_117780 0.988200
R13100 n1_M2_21660_117780 n1_M2_22740_117780 0.988200
R13101 n1_M2_22740_117780 n1_M2_23820_117780 0.988200
R13102 n1_M2_23820_117780 n1_M2_24900_117780 0.988200
R13103 n1_M2_24900_117780 n1_M2_25980_117780 0.988200
R13104 n1_M2_25980_117780 n1_M2_27060_117780 0.988200
R13105 n1_M2_27060_117780 n1_M2_28140_117780 0.988200
R13106 n1_M2_28140_117780 n1_M2_29220_117780 0.988200
R13107 n1_M2_29220_117780 n1_M2_30300_117780 0.988200
R13108 n1_M2_30300_117780 n1_M2_31380_117780 0.988200
R13109 n1_M2_31380_117780 n1_M2_32460_117780 0.988200
R13110 n1_M2_32460_117780 n1_M2_33540_117780 0.988200
R13111 n1_M2_33540_117780 n1_M2_34620_117780 0.988200
R13112 n1_M2_34620_117780 n1_M2_35700_117780 0.988200
R13113 n1_M2_35700_117780 n1_M2_36780_117780 0.988200
R13114 n1_M2_36780_117780 n1_M2_37860_117780 0.988200
R13115 n1_M2_37860_117780 n1_M2_38940_117780 0.988200
R13116 n1_M2_38940_117780 n1_M2_40020_117780 0.988200
R13117 n1_M2_40020_117780 n1_M2_41100_117780 0.988200
R13118 n1_M2_41100_117780 n1_M2_42180_117780 0.988200
R13119 n1_M2_42180_117780 n1_M2_43260_117780 0.988200
R13120 n1_M2_43260_117780 n1_M2_44340_117780 0.988200
R13121 n1_M2_44340_117780 n1_M2_45420_117780 0.988200
R13122 n1_M2_45420_117780 n1_M2_46500_117780 0.988200
R13123 n1_M2_46500_117780 n1_M2_47580_117780 0.988200
R13124 n1_M2_47580_117780 n1_M2_48660_117780 0.988200
R13125 n1_M2_48660_117780 n1_M2_49740_117780 0.988200
R13126 n1_M2_49740_117780 n1_M2_50820_117780 0.988200
R13127 n1_M2_50820_117780 n1_M2_51900_117780 0.988200
R13128 n1_M2_51900_117780 n1_M2_52980_117780 0.988200
R13129 n1_M2_52980_117780 n1_M2_54060_117780 0.988200
R13130 n1_M2_54060_117780 n1_M2_55140_117780 0.988200
R13131 n1_M2_55140_117780 n1_M2_56220_117780 0.988200
R13132 n1_M2_56220_117780 n1_M2_57300_117780 0.988200
R13133 n1_M2_57300_117780 n1_M2_58380_117780 0.988200
R13134 n1_M2_58380_117780 n1_M2_59460_117780 0.988200
R13135 n1_M2_59460_117780 n1_M2_60540_117780 0.988200
R13136 n1_M2_60540_117780 n1_M2_61620_117780 0.988200
R13137 n1_M2_61620_117780 n1_M2_62700_117780 0.988200
R13138 n1_M2_62700_117780 n1_M2_63780_117780 0.988200
R13139 n1_M2_63780_117780 n1_M2_64860_117780 0.988200
R13140 n1_M2_64860_117780 n1_M2_65940_117780 0.988200
R13141 n1_M2_65940_117780 n1_M2_67020_117780 0.988200
R13142 n1_M2_67020_117780 n1_M2_68100_117780 0.988200
R13143 n1_M2_68100_117780 n1_M2_69180_117780 0.988200
R13144 n1_M2_69180_117780 n1_M2_70260_117780 0.988200
R13145 n1_M2_70260_117780 n1_M2_71340_117780 0.988200
R13146 n1_M2_71340_117780 n1_M2_72420_117780 0.988200
R13147 n1_M2_72420_117780 n1_M2_73500_117780 0.988200
R13148 n1_M2_73500_117780 n1_M2_74580_117780 0.988200
R13149 n1_M2_74580_117780 n1_M2_75660_117780 0.988200
R13150 n1_M2_75660_117780 n1_M2_76740_117780 0.988200
R13151 n1_M2_76740_117780 n1_M2_77820_117780 0.988200
R13152 n1_M2_77820_117780 n1_M2_78900_117780 0.988200
R13153 n1_M2_78900_117780 n1_M2_79980_117780 0.988200
R13154 n1_M2_79980_117780 n1_M2_81060_117780 0.988200
R13155 n1_M2_81060_117780 n1_M2_82140_117780 0.988200
R13156 n1_M2_82140_117780 n1_M2_83220_117780 0.988200
R13157 n1_M2_83220_117780 n1_M2_84300_117780 0.988200
R13158 n1_M2_84300_117780 n1_M2_85380_117780 0.988200
R13159 n1_M2_85380_117780 n1_M2_86460_117780 0.988200
R13160 n1_M2_86460_117780 n1_M2_87540_117780 0.988200
R13161 n1_M2_87540_117780 n1_M2_88620_117780 0.988200
R13162 n1_M2_88620_117780 n1_M2_89700_117780 0.988200
R13163 n1_M2_89700_117780 n1_M2_90780_117780 0.988200
R13164 n1_M2_90780_117780 n1_M2_91860_117780 0.988200
R13165 n1_M2_91860_117780 n1_M2_92940_117780 0.988200
R13166 n1_M2_92940_117780 n1_M2_94020_117780 0.988200
R13167 n1_M2_94020_117780 n1_M2_95100_117780 0.988200
R13168 n1_M2_95100_117780 n1_M2_96180_117780 0.988200
R13169 n1_M2_96180_117780 n1_M2_97260_117780 0.988200
R13170 n1_M2_97260_117780 n1_M2_98340_117780 0.988200
R13171 n1_M2_98340_117780 n1_M2_99420_117780 0.988200
R13172 n1_M2_99420_117780 n1_M2_100500_117780 0.988200
R13173 n1_M2_100500_117780 n1_M2_101580_117780 0.988200
R13174 n1_M2_101580_117780 n1_M2_102660_117780 0.988200
R13175 n1_M2_102660_117780 n1_M2_103740_117780 0.988200
R13176 n1_M2_103740_117780 n1_M2_104820_117780 0.988200
R13177 n1_M2_104820_117780 n1_M2_105900_117780 0.988200
R13178 n1_M2_105900_117780 n1_M2_106980_117780 0.988200
R13179 n1_M2_106980_117780 n1_M2_108060_117780 0.988200
R13180 n1_M2_108060_117780 n1_M2_109140_117780 0.988200
R13181 n1_M2_109140_117780 n1_M2_110220_117780 0.988200
R13182 n1_M2_110220_117780 n1_M2_111300_117780 0.988200
R13183 n1_M2_111300_117780 n1_M2_112380_117780 0.988200
R13184 n1_M2_112380_117780 n1_M2_113460_117780 0.988200
R13185 n1_M2_113460_117780 n1_M2_114540_117780 0.988200
R13186 n1_M2_114540_117780 n1_M2_115620_117780 0.988200
R13187 n1_M2_115620_117780 n1_M2_116700_117780 0.988200
R13188 n1_M2_116700_117780 n1_M2_117780_117780 0.988200
R13189 n1_M2_117780_117780 n1_M2_118860_117780 0.988200
R13190 n1_M2_118860_117780 n1_M2_119940_117780 0.988200
R13191 n1_M2_119940_117780 n1_M2_121020_117780 0.988200
R13192 n1_M2_121020_117780 n1_M2_122100_117780 0.988200
R13193 n1_M2_122100_117780 n1_M2_123180_117780 0.988200
R13194 n1_M2_123180_117780 n1_M2_124260_117780 0.988200
R13195 n1_M2_124260_117780 n1_M2_125340_117780 0.988200
R13196 n1_M2_125340_117780 n1_M2_126420_117780 0.988200
R13197 n1_M2_126420_117780 n1_M2_127500_117780 0.988200
R13198 n1_M2_127500_117780 n1_M2_128580_117780 0.988200
R13199 n1_M2_128580_117780 n1_M2_129660_117780 0.988200
R13200 n1_M2_60_118860 n1_M2_1140_118860 0.988200
R13201 n1_M2_1140_118860 n1_M2_2220_118860 0.988200
R13202 n1_M2_2220_118860 n1_M2_3300_118860 0.988200
R13203 n1_M2_3300_118860 n1_M2_4380_118860 0.988200
R13204 n1_M2_4380_118860 n1_M2_5460_118860 0.988200
R13205 n1_M2_5460_118860 n1_M2_6540_118860 0.988200
R13206 n1_M2_6540_118860 n1_M2_7620_118860 0.988200
R13207 n1_M2_7620_118860 n1_M2_8700_118860 0.988200
R13208 n1_M2_8700_118860 n1_M2_9780_118860 0.988200
R13209 n1_M2_9780_118860 n1_M2_10860_118860 0.988200
R13210 n1_M2_10860_118860 n1_M2_11940_118860 0.988200
R13211 n1_M2_11940_118860 n1_M2_13020_118860 0.988200
R13212 n1_M2_13020_118860 n1_M2_14100_118860 0.988200
R13213 n1_M2_14100_118860 n1_M2_15180_118860 0.988200
R13214 n1_M2_15180_118860 n1_M2_16260_118860 0.988200
R13215 n1_M2_16260_118860 n1_M2_17340_118860 0.988200
R13216 n1_M2_17340_118860 n1_M2_18420_118860 0.988200
R13217 n1_M2_18420_118860 n1_M2_19500_118860 0.988200
R13218 n1_M2_19500_118860 n1_M2_20580_118860 0.988200
R13219 n1_M2_20580_118860 n1_M2_21660_118860 0.988200
R13220 n1_M2_21660_118860 n1_M2_22740_118860 0.988200
R13221 n1_M2_22740_118860 n1_M2_23820_118860 0.988200
R13222 n1_M2_23820_118860 n1_M2_24900_118860 0.988200
R13223 n1_M2_24900_118860 n1_M2_25980_118860 0.988200
R13224 n1_M2_25980_118860 n1_M2_27060_118860 0.988200
R13225 n1_M2_27060_118860 n1_M2_28140_118860 0.988200
R13226 n1_M2_28140_118860 n1_M2_29220_118860 0.988200
R13227 n1_M2_29220_118860 n1_M2_30300_118860 0.988200
R13228 n1_M2_30300_118860 n1_M2_31380_118860 0.988200
R13229 n1_M2_31380_118860 n1_M2_32460_118860 0.988200
R13230 n1_M2_32460_118860 n1_M2_33540_118860 0.988200
R13231 n1_M2_33540_118860 n1_M2_34620_118860 0.988200
R13232 n1_M2_34620_118860 n1_M2_35700_118860 0.988200
R13233 n1_M2_35700_118860 n1_M2_36780_118860 0.988200
R13234 n1_M2_36780_118860 n1_M2_37860_118860 0.988200
R13235 n1_M2_37860_118860 n1_M2_38940_118860 0.988200
R13236 n1_M2_38940_118860 n1_M2_40020_118860 0.988200
R13237 n1_M2_40020_118860 n1_M2_41100_118860 0.988200
R13238 n1_M2_41100_118860 n1_M2_42180_118860 0.988200
R13239 n1_M2_42180_118860 n1_M2_43260_118860 0.988200
R13240 n1_M2_43260_118860 n1_M2_44340_118860 0.988200
R13241 n1_M2_44340_118860 n1_M2_45420_118860 0.988200
R13242 n1_M2_45420_118860 n1_M2_46500_118860 0.988200
R13243 n1_M2_46500_118860 n1_M2_47580_118860 0.988200
R13244 n1_M2_47580_118860 n1_M2_48660_118860 0.988200
R13245 n1_M2_48660_118860 n1_M2_49740_118860 0.988200
R13246 n1_M2_49740_118860 n1_M2_50820_118860 0.988200
R13247 n1_M2_50820_118860 n1_M2_51900_118860 0.988200
R13248 n1_M2_51900_118860 n1_M2_52980_118860 0.988200
R13249 n1_M2_52980_118860 n1_M2_54060_118860 0.988200
R13250 n1_M2_54060_118860 n1_M2_55140_118860 0.988200
R13251 n1_M2_55140_118860 n1_M2_56220_118860 0.988200
R13252 n1_M2_56220_118860 n1_M2_57300_118860 0.988200
R13253 n1_M2_57300_118860 n1_M2_58380_118860 0.988200
R13254 n1_M2_58380_118860 n1_M2_59460_118860 0.988200
R13255 n1_M2_59460_118860 n1_M2_60540_118860 0.988200
R13256 n1_M2_60540_118860 n1_M2_61620_118860 0.988200
R13257 n1_M2_61620_118860 n1_M2_62700_118860 0.988200
R13258 n1_M2_62700_118860 n1_M2_63780_118860 0.988200
R13259 n1_M2_63780_118860 n1_M2_64860_118860 0.988200
R13260 n1_M2_64860_118860 n1_M2_65940_118860 0.988200
R13261 n1_M2_65940_118860 n1_M2_67020_118860 0.988200
R13262 n1_M2_67020_118860 n1_M2_68100_118860 0.988200
R13263 n1_M2_68100_118860 n1_M2_69180_118860 0.988200
R13264 n1_M2_69180_118860 n1_M2_70260_118860 0.988200
R13265 n1_M2_70260_118860 n1_M2_71340_118860 0.988200
R13266 n1_M2_71340_118860 n1_M2_72420_118860 0.988200
R13267 n1_M2_72420_118860 n1_M2_73500_118860 0.988200
R13268 n1_M2_73500_118860 n1_M2_74580_118860 0.988200
R13269 n1_M2_74580_118860 n1_M2_75660_118860 0.988200
R13270 n1_M2_75660_118860 n1_M2_76740_118860 0.988200
R13271 n1_M2_76740_118860 n1_M2_77820_118860 0.988200
R13272 n1_M2_77820_118860 n1_M2_78900_118860 0.988200
R13273 n1_M2_78900_118860 n1_M2_79980_118860 0.988200
R13274 n1_M2_79980_118860 n1_M2_81060_118860 0.988200
R13275 n1_M2_81060_118860 n1_M2_82140_118860 0.988200
R13276 n1_M2_82140_118860 n1_M2_83220_118860 0.988200
R13277 n1_M2_83220_118860 n1_M2_84300_118860 0.988200
R13278 n1_M2_84300_118860 n1_M2_85380_118860 0.988200
R13279 n1_M2_85380_118860 n1_M2_86460_118860 0.988200
R13280 n1_M2_86460_118860 n1_M2_87540_118860 0.988200
R13281 n1_M2_87540_118860 n1_M2_88620_118860 0.988200
R13282 n1_M2_88620_118860 n1_M2_89700_118860 0.988200
R13283 n1_M2_89700_118860 n1_M2_90780_118860 0.988200
R13284 n1_M2_90780_118860 n1_M2_91860_118860 0.988200
R13285 n1_M2_91860_118860 n1_M2_92940_118860 0.988200
R13286 n1_M2_92940_118860 n1_M2_94020_118860 0.988200
R13287 n1_M2_94020_118860 n1_M2_95100_118860 0.988200
R13288 n1_M2_95100_118860 n1_M2_96180_118860 0.988200
R13289 n1_M2_96180_118860 n1_M2_97260_118860 0.988200
R13290 n1_M2_97260_118860 n1_M2_98340_118860 0.988200
R13291 n1_M2_98340_118860 n1_M2_99420_118860 0.988200
R13292 n1_M2_99420_118860 n1_M2_100500_118860 0.988200
R13293 n1_M2_100500_118860 n1_M2_101580_118860 0.988200
R13294 n1_M2_101580_118860 n1_M2_102660_118860 0.988200
R13295 n1_M2_102660_118860 n1_M2_103740_118860 0.988200
R13296 n1_M2_103740_118860 n1_M2_104820_118860 0.988200
R13297 n1_M2_104820_118860 n1_M2_105900_118860 0.988200
R13298 n1_M2_105900_118860 n1_M2_106980_118860 0.988200
R13299 n1_M2_106980_118860 n1_M2_108060_118860 0.988200
R13300 n1_M2_108060_118860 n1_M2_109140_118860 0.988200
R13301 n1_M2_109140_118860 n1_M2_110220_118860 0.988200
R13302 n1_M2_110220_118860 n1_M2_111300_118860 0.988200
R13303 n1_M2_111300_118860 n1_M2_112380_118860 0.988200
R13304 n1_M2_112380_118860 n1_M2_113460_118860 0.988200
R13305 n1_M2_113460_118860 n1_M2_114540_118860 0.988200
R13306 n1_M2_114540_118860 n1_M2_115620_118860 0.988200
R13307 n1_M2_115620_118860 n1_M2_116700_118860 0.988200
R13308 n1_M2_116700_118860 n1_M2_117780_118860 0.988200
R13309 n1_M2_117780_118860 n1_M2_118860_118860 0.988200
R13310 n1_M2_118860_118860 n1_M2_119940_118860 0.988200
R13311 n1_M2_119940_118860 n1_M2_121020_118860 0.988200
R13312 n1_M2_121020_118860 n1_M2_122100_118860 0.988200
R13313 n1_M2_122100_118860 n1_M2_123180_118860 0.988200
R13314 n1_M2_123180_118860 n1_M2_124260_118860 0.988200
R13315 n1_M2_124260_118860 n1_M2_125340_118860 0.988200
R13316 n1_M2_125340_118860 n1_M2_126420_118860 0.988200
R13317 n1_M2_126420_118860 n1_M2_127500_118860 0.988200
R13318 n1_M2_127500_118860 n1_M2_128580_118860 0.988200
R13319 n1_M2_128580_118860 n1_M2_129660_118860 0.988200
R13320 n1_M2_60_119940 n1_M2_1140_119940 0.988200
R13321 n1_M2_1140_119940 n1_M2_2220_119940 0.988200
R13322 n1_M2_2220_119940 n1_M2_3300_119940 0.988200
R13323 n1_M2_3300_119940 n1_M2_4380_119940 0.988200
R13324 n1_M2_4380_119940 n1_M2_5460_119940 0.988200
R13325 n1_M2_5460_119940 n1_M2_6540_119940 0.988200
R13326 n1_M2_6540_119940 n1_M2_7620_119940 0.988200
R13327 n1_M2_7620_119940 n1_M2_8700_119940 0.988200
R13328 n1_M2_8700_119940 n1_M2_9780_119940 0.988200
R13329 n1_M2_9780_119940 n1_M2_10860_119940 0.988200
R13330 n1_M2_10860_119940 n1_M2_11940_119940 0.988200
R13331 n1_M2_11940_119940 n1_M2_13020_119940 0.988200
R13332 n1_M2_13020_119940 n1_M2_14100_119940 0.988200
R13333 n1_M2_14100_119940 n1_M2_15180_119940 0.988200
R13334 n1_M2_15180_119940 n1_M2_16260_119940 0.988200
R13335 n1_M2_16260_119940 n1_M2_17340_119940 0.988200
R13336 n1_M2_17340_119940 n1_M2_18420_119940 0.988200
R13337 n1_M2_18420_119940 n1_M2_19500_119940 0.988200
R13338 n1_M2_19500_119940 n1_M2_20580_119940 0.988200
R13339 n1_M2_20580_119940 n1_M2_21660_119940 0.988200
R13340 n1_M2_21660_119940 n1_M2_22740_119940 0.988200
R13341 n1_M2_22740_119940 n1_M2_23820_119940 0.988200
R13342 n1_M2_23820_119940 n1_M2_24900_119940 0.988200
R13343 n1_M2_24900_119940 n1_M2_25980_119940 0.988200
R13344 n1_M2_25980_119940 n1_M2_27060_119940 0.988200
R13345 n1_M2_27060_119940 n1_M2_28140_119940 0.988200
R13346 n1_M2_28140_119940 n1_M2_29220_119940 0.988200
R13347 n1_M2_29220_119940 n1_M2_30300_119940 0.988200
R13348 n1_M2_30300_119940 n1_M2_31380_119940 0.988200
R13349 n1_M2_31380_119940 n1_M2_32460_119940 0.988200
R13350 n1_M2_32460_119940 n1_M2_33540_119940 0.988200
R13351 n1_M2_33540_119940 n1_M2_34620_119940 0.988200
R13352 n1_M2_34620_119940 n1_M2_35700_119940 0.988200
R13353 n1_M2_35700_119940 n1_M2_36780_119940 0.988200
R13354 n1_M2_36780_119940 n1_M2_37860_119940 0.988200
R13355 n1_M2_37860_119940 n1_M2_38940_119940 0.988200
R13356 n1_M2_38940_119940 n1_M2_40020_119940 0.988200
R13357 n1_M2_40020_119940 n1_M2_41100_119940 0.988200
R13358 n1_M2_41100_119940 n1_M2_42180_119940 0.988200
R13359 n1_M2_42180_119940 n1_M2_43260_119940 0.988200
R13360 n1_M2_43260_119940 n1_M2_44340_119940 0.988200
R13361 n1_M2_44340_119940 n1_M2_45420_119940 0.988200
R13362 n1_M2_45420_119940 n1_M2_46500_119940 0.988200
R13363 n1_M2_46500_119940 n1_M2_47580_119940 0.988200
R13364 n1_M2_47580_119940 n1_M2_48660_119940 0.988200
R13365 n1_M2_48660_119940 n1_M2_49740_119940 0.988200
R13366 n1_M2_49740_119940 n1_M2_50820_119940 0.988200
R13367 n1_M2_50820_119940 n1_M2_51900_119940 0.988200
R13368 n1_M2_51900_119940 n1_M2_52980_119940 0.988200
R13369 n1_M2_52980_119940 n1_M2_54060_119940 0.988200
R13370 n1_M2_54060_119940 n1_M2_55140_119940 0.988200
R13371 n1_M2_55140_119940 n1_M2_56220_119940 0.988200
R13372 n1_M2_56220_119940 n1_M2_57300_119940 0.988200
R13373 n1_M2_57300_119940 n1_M2_58380_119940 0.988200
R13374 n1_M2_58380_119940 n1_M2_59460_119940 0.988200
R13375 n1_M2_59460_119940 n1_M2_60540_119940 0.988200
R13376 n1_M2_60540_119940 n1_M2_61620_119940 0.988200
R13377 n1_M2_61620_119940 n1_M2_62700_119940 0.988200
R13378 n1_M2_62700_119940 n1_M2_63780_119940 0.988200
R13379 n1_M2_63780_119940 n1_M2_64860_119940 0.988200
R13380 n1_M2_64860_119940 n1_M2_65940_119940 0.988200
R13381 n1_M2_65940_119940 n1_M2_67020_119940 0.988200
R13382 n1_M2_67020_119940 n1_M2_68100_119940 0.988200
R13383 n1_M2_68100_119940 n1_M2_69180_119940 0.988200
R13384 n1_M2_69180_119940 n1_M2_70260_119940 0.988200
R13385 n1_M2_70260_119940 n1_M2_71340_119940 0.988200
R13386 n1_M2_71340_119940 n1_M2_72420_119940 0.988200
R13387 n1_M2_72420_119940 n1_M2_73500_119940 0.988200
R13388 n1_M2_73500_119940 n1_M2_74580_119940 0.988200
R13389 n1_M2_74580_119940 n1_M2_75660_119940 0.988200
R13390 n1_M2_75660_119940 n1_M2_76740_119940 0.988200
R13391 n1_M2_76740_119940 n1_M2_77820_119940 0.988200
R13392 n1_M2_77820_119940 n1_M2_78900_119940 0.988200
R13393 n1_M2_78900_119940 n1_M2_79980_119940 0.988200
R13394 n1_M2_79980_119940 n1_M2_81060_119940 0.988200
R13395 n1_M2_81060_119940 n1_M2_82140_119940 0.988200
R13396 n1_M2_82140_119940 n1_M2_83220_119940 0.988200
R13397 n1_M2_83220_119940 n1_M2_84300_119940 0.988200
R13398 n1_M2_84300_119940 n1_M2_85380_119940 0.988200
R13399 n1_M2_85380_119940 n1_M2_86460_119940 0.988200
R13400 n1_M2_86460_119940 n1_M2_87540_119940 0.988200
R13401 n1_M2_87540_119940 n1_M2_88620_119940 0.988200
R13402 n1_M2_88620_119940 n1_M2_89700_119940 0.988200
R13403 n1_M2_89700_119940 n1_M2_90780_119940 0.988200
R13404 n1_M2_90780_119940 n1_M2_91860_119940 0.988200
R13405 n1_M2_91860_119940 n1_M2_92940_119940 0.988200
R13406 n1_M2_92940_119940 n1_M2_94020_119940 0.988200
R13407 n1_M2_94020_119940 n1_M2_95100_119940 0.988200
R13408 n1_M2_95100_119940 n1_M2_96180_119940 0.988200
R13409 n1_M2_96180_119940 n1_M2_97260_119940 0.988200
R13410 n1_M2_97260_119940 n1_M2_98340_119940 0.988200
R13411 n1_M2_98340_119940 n1_M2_99420_119940 0.988200
R13412 n1_M2_99420_119940 n1_M2_100500_119940 0.988200
R13413 n1_M2_100500_119940 n1_M2_101580_119940 0.988200
R13414 n1_M2_101580_119940 n1_M2_102660_119940 0.988200
R13415 n1_M2_102660_119940 n1_M2_103740_119940 0.988200
R13416 n1_M2_103740_119940 n1_M2_104820_119940 0.988200
R13417 n1_M2_104820_119940 n1_M2_105900_119940 0.988200
R13418 n1_M2_105900_119940 n1_M2_106980_119940 0.988200
R13419 n1_M2_106980_119940 n1_M2_108060_119940 0.988200
R13420 n1_M2_108060_119940 n1_M2_109140_119940 0.988200
R13421 n1_M2_109140_119940 n1_M2_110220_119940 0.988200
R13422 n1_M2_110220_119940 n1_M2_111300_119940 0.988200
R13423 n1_M2_111300_119940 n1_M2_112380_119940 0.988200
R13424 n1_M2_112380_119940 n1_M2_113460_119940 0.988200
R13425 n1_M2_113460_119940 n1_M2_114540_119940 0.988200
R13426 n1_M2_114540_119940 n1_M2_115620_119940 0.988200
R13427 n1_M2_115620_119940 n1_M2_116700_119940 0.988200
R13428 n1_M2_116700_119940 n1_M2_117780_119940 0.988200
R13429 n1_M2_117780_119940 n1_M2_118860_119940 0.988200
R13430 n1_M2_118860_119940 n1_M2_119940_119940 0.988200
R13431 n1_M2_119940_119940 n1_M2_121020_119940 0.988200
R13432 n1_M2_121020_119940 n1_M2_122100_119940 0.988200
R13433 n1_M2_122100_119940 n1_M2_123180_119940 0.988200
R13434 n1_M2_123180_119940 n1_M2_124260_119940 0.988200
R13435 n1_M2_124260_119940 n1_M2_125340_119940 0.988200
R13436 n1_M2_125340_119940 n1_M2_126420_119940 0.988200
R13437 n1_M2_126420_119940 n1_M2_127500_119940 0.988200
R13438 n1_M2_127500_119940 n1_M2_128580_119940 0.988200
R13439 n1_M2_128580_119940 n1_M2_129660_119940 0.988200
R13440 n1_M2_60_121020 n1_M2_1140_121020 0.988200
R13441 n1_M2_1140_121020 n1_M2_2220_121020 0.988200
R13442 n1_M2_2220_121020 n1_M2_3300_121020 0.988200
R13443 n1_M2_3300_121020 n1_M2_4380_121020 0.988200
R13444 n1_M2_4380_121020 n1_M2_5460_121020 0.988200
R13445 n1_M2_5460_121020 n1_M2_6540_121020 0.988200
R13446 n1_M2_6540_121020 n1_M2_7620_121020 0.988200
R13447 n1_M2_7620_121020 n1_M2_8700_121020 0.988200
R13448 n1_M2_8700_121020 n1_M2_9780_121020 0.988200
R13449 n1_M2_9780_121020 n1_M2_10860_121020 0.988200
R13450 n1_M2_10860_121020 n1_M2_11940_121020 0.988200
R13451 n1_M2_11940_121020 n1_M2_13020_121020 0.988200
R13452 n1_M2_13020_121020 n1_M2_14100_121020 0.988200
R13453 n1_M2_14100_121020 n1_M2_15180_121020 0.988200
R13454 n1_M2_15180_121020 n1_M2_16260_121020 0.988200
R13455 n1_M2_16260_121020 n1_M2_17340_121020 0.988200
R13456 n1_M2_17340_121020 n1_M2_18420_121020 0.988200
R13457 n1_M2_18420_121020 n1_M2_19500_121020 0.988200
R13458 n1_M2_19500_121020 n1_M2_20580_121020 0.988200
R13459 n1_M2_20580_121020 n1_M2_21660_121020 0.988200
R13460 n1_M2_21660_121020 n1_M2_22740_121020 0.988200
R13461 n1_M2_22740_121020 n1_M2_23820_121020 0.988200
R13462 n1_M2_23820_121020 n1_M2_24900_121020 0.988200
R13463 n1_M2_24900_121020 n1_M2_25980_121020 0.988200
R13464 n1_M2_25980_121020 n1_M2_27060_121020 0.988200
R13465 n1_M2_27060_121020 n1_M2_28140_121020 0.988200
R13466 n1_M2_28140_121020 n1_M2_29220_121020 0.988200
R13467 n1_M2_29220_121020 n1_M2_30300_121020 0.988200
R13468 n1_M2_30300_121020 n1_M2_31380_121020 0.988200
R13469 n1_M2_31380_121020 n1_M2_32460_121020 0.988200
R13470 n1_M2_32460_121020 n1_M2_33540_121020 0.988200
R13471 n1_M2_33540_121020 n1_M2_34620_121020 0.988200
R13472 n1_M2_34620_121020 n1_M2_35700_121020 0.988200
R13473 n1_M2_35700_121020 n1_M2_36780_121020 0.988200
R13474 n1_M2_36780_121020 n1_M2_37860_121020 0.988200
R13475 n1_M2_37860_121020 n1_M2_38940_121020 0.988200
R13476 n1_M2_38940_121020 n1_M2_40020_121020 0.988200
R13477 n1_M2_40020_121020 n1_M2_41100_121020 0.988200
R13478 n1_M2_41100_121020 n1_M2_42180_121020 0.988200
R13479 n1_M2_42180_121020 n1_M2_43260_121020 0.988200
R13480 n1_M2_43260_121020 n1_M2_44340_121020 0.988200
R13481 n1_M2_44340_121020 n1_M2_45420_121020 0.988200
R13482 n1_M2_45420_121020 n1_M2_46500_121020 0.988200
R13483 n1_M2_46500_121020 n1_M2_47580_121020 0.988200
R13484 n1_M2_47580_121020 n1_M2_48660_121020 0.988200
R13485 n1_M2_48660_121020 n1_M2_49740_121020 0.988200
R13486 n1_M2_49740_121020 n1_M2_50820_121020 0.988200
R13487 n1_M2_50820_121020 n1_M2_51900_121020 0.988200
R13488 n1_M2_51900_121020 n1_M2_52980_121020 0.988200
R13489 n1_M2_52980_121020 n1_M2_54060_121020 0.988200
R13490 n1_M2_54060_121020 n1_M2_55140_121020 0.988200
R13491 n1_M2_55140_121020 n1_M2_56220_121020 0.988200
R13492 n1_M2_56220_121020 n1_M2_57300_121020 0.988200
R13493 n1_M2_57300_121020 n1_M2_58380_121020 0.988200
R13494 n1_M2_58380_121020 n1_M2_59460_121020 0.988200
R13495 n1_M2_59460_121020 n1_M2_60540_121020 0.988200
R13496 n1_M2_60540_121020 n1_M2_61620_121020 0.988200
R13497 n1_M2_61620_121020 n1_M2_62700_121020 0.988200
R13498 n1_M2_62700_121020 n1_M2_63780_121020 0.988200
R13499 n1_M2_63780_121020 n1_M2_64860_121020 0.988200
R13500 n1_M2_64860_121020 n1_M2_65940_121020 0.988200
R13501 n1_M2_65940_121020 n1_M2_67020_121020 0.988200
R13502 n1_M2_67020_121020 n1_M2_68100_121020 0.988200
R13503 n1_M2_68100_121020 n1_M2_69180_121020 0.988200
R13504 n1_M2_69180_121020 n1_M2_70260_121020 0.988200
R13505 n1_M2_70260_121020 n1_M2_71340_121020 0.988200
R13506 n1_M2_71340_121020 n1_M2_72420_121020 0.988200
R13507 n1_M2_72420_121020 n1_M2_73500_121020 0.988200
R13508 n1_M2_73500_121020 n1_M2_74580_121020 0.988200
R13509 n1_M2_74580_121020 n1_M2_75660_121020 0.988200
R13510 n1_M2_75660_121020 n1_M2_76740_121020 0.988200
R13511 n1_M2_76740_121020 n1_M2_77820_121020 0.988200
R13512 n1_M2_77820_121020 n1_M2_78900_121020 0.988200
R13513 n1_M2_78900_121020 n1_M2_79980_121020 0.988200
R13514 n1_M2_79980_121020 n1_M2_81060_121020 0.988200
R13515 n1_M2_81060_121020 n1_M2_82140_121020 0.988200
R13516 n1_M2_82140_121020 n1_M2_83220_121020 0.988200
R13517 n1_M2_83220_121020 n1_M2_84300_121020 0.988200
R13518 n1_M2_84300_121020 n1_M2_85380_121020 0.988200
R13519 n1_M2_85380_121020 n1_M2_86460_121020 0.988200
R13520 n1_M2_86460_121020 n1_M2_87540_121020 0.988200
R13521 n1_M2_87540_121020 n1_M2_88620_121020 0.988200
R13522 n1_M2_88620_121020 n1_M2_89700_121020 0.988200
R13523 n1_M2_89700_121020 n1_M2_90780_121020 0.988200
R13524 n1_M2_90780_121020 n1_M2_91860_121020 0.988200
R13525 n1_M2_91860_121020 n1_M2_92940_121020 0.988200
R13526 n1_M2_92940_121020 n1_M2_94020_121020 0.988200
R13527 n1_M2_94020_121020 n1_M2_95100_121020 0.988200
R13528 n1_M2_95100_121020 n1_M2_96180_121020 0.988200
R13529 n1_M2_96180_121020 n1_M2_97260_121020 0.988200
R13530 n1_M2_97260_121020 n1_M2_98340_121020 0.988200
R13531 n1_M2_98340_121020 n1_M2_99420_121020 0.988200
R13532 n1_M2_99420_121020 n1_M2_100500_121020 0.988200
R13533 n1_M2_100500_121020 n1_M2_101580_121020 0.988200
R13534 n1_M2_101580_121020 n1_M2_102660_121020 0.988200
R13535 n1_M2_102660_121020 n1_M2_103740_121020 0.988200
R13536 n1_M2_103740_121020 n1_M2_104820_121020 0.988200
R13537 n1_M2_104820_121020 n1_M2_105900_121020 0.988200
R13538 n1_M2_105900_121020 n1_M2_106980_121020 0.988200
R13539 n1_M2_106980_121020 n1_M2_108060_121020 0.988200
R13540 n1_M2_108060_121020 n1_M2_109140_121020 0.988200
R13541 n1_M2_109140_121020 n1_M2_110220_121020 0.988200
R13542 n1_M2_110220_121020 n1_M2_111300_121020 0.988200
R13543 n1_M2_111300_121020 n1_M2_112380_121020 0.988200
R13544 n1_M2_112380_121020 n1_M2_113460_121020 0.988200
R13545 n1_M2_113460_121020 n1_M2_114540_121020 0.988200
R13546 n1_M2_114540_121020 n1_M2_115620_121020 0.988200
R13547 n1_M2_115620_121020 n1_M2_116700_121020 0.988200
R13548 n1_M2_116700_121020 n1_M2_117780_121020 0.988200
R13549 n1_M2_117780_121020 n1_M2_118860_121020 0.988200
R13550 n1_M2_118860_121020 n1_M2_119940_121020 0.988200
R13551 n1_M2_119940_121020 n1_M2_121020_121020 0.988200
R13552 n1_M2_121020_121020 n1_M2_122100_121020 0.988200
R13553 n1_M2_122100_121020 n1_M2_123180_121020 0.988200
R13554 n1_M2_123180_121020 n1_M2_124260_121020 0.988200
R13555 n1_M2_124260_121020 n1_M2_125340_121020 0.988200
R13556 n1_M2_125340_121020 n1_M2_126420_121020 0.988200
R13557 n1_M2_126420_121020 n1_M2_127500_121020 0.988200
R13558 n1_M2_127500_121020 n1_M2_128580_121020 0.988200
R13559 n1_M2_128580_121020 n1_M2_129660_121020 0.988200
R13560 n1_M2_60_122100 n1_M2_1140_122100 0.988200
R13561 n1_M2_1140_122100 n1_M2_2220_122100 0.988200
R13562 n1_M2_2220_122100 n1_M2_3300_122100 0.988200
R13563 n1_M2_3300_122100 n1_M2_4380_122100 0.988200
R13564 n1_M2_4380_122100 n1_M2_5460_122100 0.988200
R13565 n1_M2_5460_122100 n1_M2_6540_122100 0.988200
R13566 n1_M2_6540_122100 n1_M2_7620_122100 0.988200
R13567 n1_M2_7620_122100 n1_M2_8700_122100 0.988200
R13568 n1_M2_8700_122100 n1_M2_9780_122100 0.988200
R13569 n1_M2_9780_122100 n1_M2_10860_122100 0.988200
R13570 n1_M2_10860_122100 n1_M2_11940_122100 0.988200
R13571 n1_M2_11940_122100 n1_M2_13020_122100 0.988200
R13572 n1_M2_13020_122100 n1_M2_14100_122100 0.988200
R13573 n1_M2_14100_122100 n1_M2_15180_122100 0.988200
R13574 n1_M2_15180_122100 n1_M2_16260_122100 0.988200
R13575 n1_M2_16260_122100 n1_M2_17340_122100 0.988200
R13576 n1_M2_17340_122100 n1_M2_18420_122100 0.988200
R13577 n1_M2_18420_122100 n1_M2_19500_122100 0.988200
R13578 n1_M2_19500_122100 n1_M2_20580_122100 0.988200
R13579 n1_M2_20580_122100 n1_M2_21660_122100 0.988200
R13580 n1_M2_21660_122100 n1_M2_22740_122100 0.988200
R13581 n1_M2_22740_122100 n1_M2_23820_122100 0.988200
R13582 n1_M2_23820_122100 n1_M2_24900_122100 0.988200
R13583 n1_M2_24900_122100 n1_M2_25980_122100 0.988200
R13584 n1_M2_25980_122100 n1_M2_27060_122100 0.988200
R13585 n1_M2_27060_122100 n1_M2_28140_122100 0.988200
R13586 n1_M2_28140_122100 n1_M2_29220_122100 0.988200
R13587 n1_M2_29220_122100 n1_M2_30300_122100 0.988200
R13588 n1_M2_30300_122100 n1_M2_31380_122100 0.988200
R13589 n1_M2_31380_122100 n1_M2_32460_122100 0.988200
R13590 n1_M2_32460_122100 n1_M2_33540_122100 0.988200
R13591 n1_M2_33540_122100 n1_M2_34620_122100 0.988200
R13592 n1_M2_34620_122100 n1_M2_35700_122100 0.988200
R13593 n1_M2_35700_122100 n1_M2_36780_122100 0.988200
R13594 n1_M2_36780_122100 n1_M2_37860_122100 0.988200
R13595 n1_M2_37860_122100 n1_M2_38940_122100 0.988200
R13596 n1_M2_38940_122100 n1_M2_40020_122100 0.988200
R13597 n1_M2_40020_122100 n1_M2_41100_122100 0.988200
R13598 n1_M2_41100_122100 n1_M2_42180_122100 0.988200
R13599 n1_M2_42180_122100 n1_M2_43260_122100 0.988200
R13600 n1_M2_43260_122100 n1_M2_44340_122100 0.988200
R13601 n1_M2_44340_122100 n1_M2_45420_122100 0.988200
R13602 n1_M2_45420_122100 n1_M2_46500_122100 0.988200
R13603 n1_M2_46500_122100 n1_M2_47580_122100 0.988200
R13604 n1_M2_47580_122100 n1_M2_48660_122100 0.988200
R13605 n1_M2_48660_122100 n1_M2_49740_122100 0.988200
R13606 n1_M2_49740_122100 n1_M2_50820_122100 0.988200
R13607 n1_M2_50820_122100 n1_M2_51900_122100 0.988200
R13608 n1_M2_51900_122100 n1_M2_52980_122100 0.988200
R13609 n1_M2_52980_122100 n1_M2_54060_122100 0.988200
R13610 n1_M2_54060_122100 n1_M2_55140_122100 0.988200
R13611 n1_M2_55140_122100 n1_M2_56220_122100 0.988200
R13612 n1_M2_56220_122100 n1_M2_57300_122100 0.988200
R13613 n1_M2_57300_122100 n1_M2_58380_122100 0.988200
R13614 n1_M2_58380_122100 n1_M2_59460_122100 0.988200
R13615 n1_M2_59460_122100 n1_M2_60540_122100 0.988200
R13616 n1_M2_60540_122100 n1_M2_61620_122100 0.988200
R13617 n1_M2_61620_122100 n1_M2_62700_122100 0.988200
R13618 n1_M2_62700_122100 n1_M2_63780_122100 0.988200
R13619 n1_M2_63780_122100 n1_M2_64860_122100 0.988200
R13620 n1_M2_64860_122100 n1_M2_65940_122100 0.988200
R13621 n1_M2_65940_122100 n1_M2_67020_122100 0.988200
R13622 n1_M2_67020_122100 n1_M2_68100_122100 0.988200
R13623 n1_M2_68100_122100 n1_M2_69180_122100 0.988200
R13624 n1_M2_69180_122100 n1_M2_70260_122100 0.988200
R13625 n1_M2_70260_122100 n1_M2_71340_122100 0.988200
R13626 n1_M2_71340_122100 n1_M2_72420_122100 0.988200
R13627 n1_M2_72420_122100 n1_M2_73500_122100 0.988200
R13628 n1_M2_73500_122100 n1_M2_74580_122100 0.988200
R13629 n1_M2_74580_122100 n1_M2_75660_122100 0.988200
R13630 n1_M2_75660_122100 n1_M2_76740_122100 0.988200
R13631 n1_M2_76740_122100 n1_M2_77820_122100 0.988200
R13632 n1_M2_77820_122100 n1_M2_78900_122100 0.988200
R13633 n1_M2_78900_122100 n1_M2_79980_122100 0.988200
R13634 n1_M2_79980_122100 n1_M2_81060_122100 0.988200
R13635 n1_M2_81060_122100 n1_M2_82140_122100 0.988200
R13636 n1_M2_82140_122100 n1_M2_83220_122100 0.988200
R13637 n1_M2_83220_122100 n1_M2_84300_122100 0.988200
R13638 n1_M2_84300_122100 n1_M2_85380_122100 0.988200
R13639 n1_M2_85380_122100 n1_M2_86460_122100 0.988200
R13640 n1_M2_86460_122100 n1_M2_87540_122100 0.988200
R13641 n1_M2_87540_122100 n1_M2_88620_122100 0.988200
R13642 n1_M2_88620_122100 n1_M2_89700_122100 0.988200
R13643 n1_M2_89700_122100 n1_M2_90780_122100 0.988200
R13644 n1_M2_90780_122100 n1_M2_91860_122100 0.988200
R13645 n1_M2_91860_122100 n1_M2_92940_122100 0.988200
R13646 n1_M2_92940_122100 n1_M2_94020_122100 0.988200
R13647 n1_M2_94020_122100 n1_M2_95100_122100 0.988200
R13648 n1_M2_95100_122100 n1_M2_96180_122100 0.988200
R13649 n1_M2_96180_122100 n1_M2_97260_122100 0.988200
R13650 n1_M2_97260_122100 n1_M2_98340_122100 0.988200
R13651 n1_M2_98340_122100 n1_M2_99420_122100 0.988200
R13652 n1_M2_99420_122100 n1_M2_100500_122100 0.988200
R13653 n1_M2_100500_122100 n1_M2_101580_122100 0.988200
R13654 n1_M2_101580_122100 n1_M2_102660_122100 0.988200
R13655 n1_M2_102660_122100 n1_M2_103740_122100 0.988200
R13656 n1_M2_103740_122100 n1_M2_104820_122100 0.988200
R13657 n1_M2_104820_122100 n1_M2_105900_122100 0.988200
R13658 n1_M2_105900_122100 n1_M2_106980_122100 0.988200
R13659 n1_M2_106980_122100 n1_M2_108060_122100 0.988200
R13660 n1_M2_108060_122100 n1_M2_109140_122100 0.988200
R13661 n1_M2_109140_122100 n1_M2_110220_122100 0.988200
R13662 n1_M2_110220_122100 n1_M2_111300_122100 0.988200
R13663 n1_M2_111300_122100 n1_M2_112380_122100 0.988200
R13664 n1_M2_112380_122100 n1_M2_113460_122100 0.988200
R13665 n1_M2_113460_122100 n1_M2_114540_122100 0.988200
R13666 n1_M2_114540_122100 n1_M2_115620_122100 0.988200
R13667 n1_M2_115620_122100 n1_M2_116700_122100 0.988200
R13668 n1_M2_116700_122100 n1_M2_117780_122100 0.988200
R13669 n1_M2_117780_122100 n1_M2_118860_122100 0.988200
R13670 n1_M2_118860_122100 n1_M2_119940_122100 0.988200
R13671 n1_M2_119940_122100 n1_M2_121020_122100 0.988200
R13672 n1_M2_121020_122100 n1_M2_122100_122100 0.988200
R13673 n1_M2_122100_122100 n1_M2_123180_122100 0.988200
R13674 n1_M2_123180_122100 n1_M2_124260_122100 0.988200
R13675 n1_M2_124260_122100 n1_M2_125340_122100 0.988200
R13676 n1_M2_125340_122100 n1_M2_126420_122100 0.988200
R13677 n1_M2_126420_122100 n1_M2_127500_122100 0.988200
R13678 n1_M2_127500_122100 n1_M2_128580_122100 0.988200
R13679 n1_M2_128580_122100 n1_M2_129660_122100 0.988200
R13680 n1_M2_60_123180 n1_M2_1140_123180 0.988200
R13681 n1_M2_1140_123180 n1_M2_2220_123180 0.988200
R13682 n1_M2_2220_123180 n1_M2_3300_123180 0.988200
R13683 n1_M2_3300_123180 n1_M2_4380_123180 0.988200
R13684 n1_M2_4380_123180 n1_M2_5460_123180 0.988200
R13685 n1_M2_5460_123180 n1_M2_6540_123180 0.988200
R13686 n1_M2_6540_123180 n1_M2_7620_123180 0.988200
R13687 n1_M2_7620_123180 n1_M2_8700_123180 0.988200
R13688 n1_M2_8700_123180 n1_M2_9780_123180 0.988200
R13689 n1_M2_9780_123180 n1_M2_10860_123180 0.988200
R13690 n1_M2_10860_123180 n1_M2_11940_123180 0.988200
R13691 n1_M2_11940_123180 n1_M2_13020_123180 0.988200
R13692 n1_M2_13020_123180 n1_M2_14100_123180 0.988200
R13693 n1_M2_14100_123180 n1_M2_15180_123180 0.988200
R13694 n1_M2_15180_123180 n1_M2_16260_123180 0.988200
R13695 n1_M2_16260_123180 n1_M2_17340_123180 0.988200
R13696 n1_M2_17340_123180 n1_M2_18420_123180 0.988200
R13697 n1_M2_18420_123180 n1_M2_19500_123180 0.988200
R13698 n1_M2_19500_123180 n1_M2_20580_123180 0.988200
R13699 n1_M2_20580_123180 n1_M2_21660_123180 0.988200
R13700 n1_M2_21660_123180 n1_M2_22740_123180 0.988200
R13701 n1_M2_22740_123180 n1_M2_23820_123180 0.988200
R13702 n1_M2_23820_123180 n1_M2_24900_123180 0.988200
R13703 n1_M2_24900_123180 n1_M2_25980_123180 0.988200
R13704 n1_M2_25980_123180 n1_M2_27060_123180 0.988200
R13705 n1_M2_27060_123180 n1_M2_28140_123180 0.988200
R13706 n1_M2_28140_123180 n1_M2_29220_123180 0.988200
R13707 n1_M2_29220_123180 n1_M2_30300_123180 0.988200
R13708 n1_M2_30300_123180 n1_M2_31380_123180 0.988200
R13709 n1_M2_31380_123180 n1_M2_32460_123180 0.988200
R13710 n1_M2_32460_123180 n1_M2_33540_123180 0.988200
R13711 n1_M2_33540_123180 n1_M2_34620_123180 0.988200
R13712 n1_M2_34620_123180 n1_M2_35700_123180 0.988200
R13713 n1_M2_35700_123180 n1_M2_36780_123180 0.988200
R13714 n1_M2_36780_123180 n1_M2_37860_123180 0.988200
R13715 n1_M2_37860_123180 n1_M2_38940_123180 0.988200
R13716 n1_M2_38940_123180 n1_M2_40020_123180 0.988200
R13717 n1_M2_40020_123180 n1_M2_41100_123180 0.988200
R13718 n1_M2_41100_123180 n1_M2_42180_123180 0.988200
R13719 n1_M2_42180_123180 n1_M2_43260_123180 0.988200
R13720 n1_M2_43260_123180 n1_M2_44340_123180 0.988200
R13721 n1_M2_44340_123180 n1_M2_45420_123180 0.988200
R13722 n1_M2_45420_123180 n1_M2_46500_123180 0.988200
R13723 n1_M2_46500_123180 n1_M2_47580_123180 0.988200
R13724 n1_M2_47580_123180 n1_M2_48660_123180 0.988200
R13725 n1_M2_48660_123180 n1_M2_49740_123180 0.988200
R13726 n1_M2_49740_123180 n1_M2_50820_123180 0.988200
R13727 n1_M2_50820_123180 n1_M2_51900_123180 0.988200
R13728 n1_M2_51900_123180 n1_M2_52980_123180 0.988200
R13729 n1_M2_52980_123180 n1_M2_54060_123180 0.988200
R13730 n1_M2_54060_123180 n1_M2_55140_123180 0.988200
R13731 n1_M2_55140_123180 n1_M2_56220_123180 0.988200
R13732 n1_M2_56220_123180 n1_M2_57300_123180 0.988200
R13733 n1_M2_57300_123180 n1_M2_58380_123180 0.988200
R13734 n1_M2_58380_123180 n1_M2_59460_123180 0.988200
R13735 n1_M2_59460_123180 n1_M2_60540_123180 0.988200
R13736 n1_M2_60540_123180 n1_M2_61620_123180 0.988200
R13737 n1_M2_61620_123180 n1_M2_62700_123180 0.988200
R13738 n1_M2_62700_123180 n1_M2_63780_123180 0.988200
R13739 n1_M2_63780_123180 n1_M2_64860_123180 0.988200
R13740 n1_M2_64860_123180 n1_M2_65940_123180 0.988200
R13741 n1_M2_65940_123180 n1_M2_67020_123180 0.988200
R13742 n1_M2_67020_123180 n1_M2_68100_123180 0.988200
R13743 n1_M2_68100_123180 n1_M2_69180_123180 0.988200
R13744 n1_M2_69180_123180 n1_M2_70260_123180 0.988200
R13745 n1_M2_70260_123180 n1_M2_71340_123180 0.988200
R13746 n1_M2_71340_123180 n1_M2_72420_123180 0.988200
R13747 n1_M2_72420_123180 n1_M2_73500_123180 0.988200
R13748 n1_M2_73500_123180 n1_M2_74580_123180 0.988200
R13749 n1_M2_74580_123180 n1_M2_75660_123180 0.988200
R13750 n1_M2_75660_123180 n1_M2_76740_123180 0.988200
R13751 n1_M2_76740_123180 n1_M2_77820_123180 0.988200
R13752 n1_M2_77820_123180 n1_M2_78900_123180 0.988200
R13753 n1_M2_78900_123180 n1_M2_79980_123180 0.988200
R13754 n1_M2_79980_123180 n1_M2_81060_123180 0.988200
R13755 n1_M2_81060_123180 n1_M2_82140_123180 0.988200
R13756 n1_M2_82140_123180 n1_M2_83220_123180 0.988200
R13757 n1_M2_83220_123180 n1_M2_84300_123180 0.988200
R13758 n1_M2_84300_123180 n1_M2_85380_123180 0.988200
R13759 n1_M2_85380_123180 n1_M2_86460_123180 0.988200
R13760 n1_M2_86460_123180 n1_M2_87540_123180 0.988200
R13761 n1_M2_87540_123180 n1_M2_88620_123180 0.988200
R13762 n1_M2_88620_123180 n1_M2_89700_123180 0.988200
R13763 n1_M2_89700_123180 n1_M2_90780_123180 0.988200
R13764 n1_M2_90780_123180 n1_M2_91860_123180 0.988200
R13765 n1_M2_91860_123180 n1_M2_92940_123180 0.988200
R13766 n1_M2_92940_123180 n1_M2_94020_123180 0.988200
R13767 n1_M2_94020_123180 n1_M2_95100_123180 0.988200
R13768 n1_M2_95100_123180 n1_M2_96180_123180 0.988200
R13769 n1_M2_96180_123180 n1_M2_97260_123180 0.988200
R13770 n1_M2_97260_123180 n1_M2_98340_123180 0.988200
R13771 n1_M2_98340_123180 n1_M2_99420_123180 0.988200
R13772 n1_M2_99420_123180 n1_M2_100500_123180 0.988200
R13773 n1_M2_100500_123180 n1_M2_101580_123180 0.988200
R13774 n1_M2_101580_123180 n1_M2_102660_123180 0.988200
R13775 n1_M2_102660_123180 n1_M2_103740_123180 0.988200
R13776 n1_M2_103740_123180 n1_M2_104820_123180 0.988200
R13777 n1_M2_104820_123180 n1_M2_105900_123180 0.988200
R13778 n1_M2_105900_123180 n1_M2_106980_123180 0.988200
R13779 n1_M2_106980_123180 n1_M2_108060_123180 0.988200
R13780 n1_M2_108060_123180 n1_M2_109140_123180 0.988200
R13781 n1_M2_109140_123180 n1_M2_110220_123180 0.988200
R13782 n1_M2_110220_123180 n1_M2_111300_123180 0.988200
R13783 n1_M2_111300_123180 n1_M2_112380_123180 0.988200
R13784 n1_M2_112380_123180 n1_M2_113460_123180 0.988200
R13785 n1_M2_113460_123180 n1_M2_114540_123180 0.988200
R13786 n1_M2_114540_123180 n1_M2_115620_123180 0.988200
R13787 n1_M2_115620_123180 n1_M2_116700_123180 0.988200
R13788 n1_M2_116700_123180 n1_M2_117780_123180 0.988200
R13789 n1_M2_117780_123180 n1_M2_118860_123180 0.988200
R13790 n1_M2_118860_123180 n1_M2_119940_123180 0.988200
R13791 n1_M2_119940_123180 n1_M2_121020_123180 0.988200
R13792 n1_M2_121020_123180 n1_M2_122100_123180 0.988200
R13793 n1_M2_122100_123180 n1_M2_123180_123180 0.988200
R13794 n1_M2_123180_123180 n1_M2_124260_123180 0.988200
R13795 n1_M2_124260_123180 n1_M2_125340_123180 0.988200
R13796 n1_M2_125340_123180 n1_M2_126420_123180 0.988200
R13797 n1_M2_126420_123180 n1_M2_127500_123180 0.988200
R13798 n1_M2_127500_123180 n1_M2_128580_123180 0.988200
R13799 n1_M2_128580_123180 n1_M2_129660_123180 0.988200
R13800 n1_M2_60_124260 n1_M2_1140_124260 0.988200
R13801 n1_M2_1140_124260 n1_M2_2220_124260 0.988200
R13802 n1_M2_2220_124260 n1_M2_3300_124260 0.988200
R13803 n1_M2_3300_124260 n1_M2_4380_124260 0.988200
R13804 n1_M2_4380_124260 n1_M2_5460_124260 0.988200
R13805 n1_M2_5460_124260 n1_M2_6540_124260 0.988200
R13806 n1_M2_6540_124260 n1_M2_7620_124260 0.988200
R13807 n1_M2_7620_124260 n1_M2_8700_124260 0.988200
R13808 n1_M2_8700_124260 n1_M2_9780_124260 0.988200
R13809 n1_M2_9780_124260 n1_M2_10860_124260 0.988200
R13810 n1_M2_10860_124260 n1_M2_11940_124260 0.988200
R13811 n1_M2_11940_124260 n1_M2_13020_124260 0.988200
R13812 n1_M2_13020_124260 n1_M2_14100_124260 0.988200
R13813 n1_M2_14100_124260 n1_M2_15180_124260 0.988200
R13814 n1_M2_15180_124260 n1_M2_16260_124260 0.988200
R13815 n1_M2_16260_124260 n1_M2_17340_124260 0.988200
R13816 n1_M2_17340_124260 n1_M2_18420_124260 0.988200
R13817 n1_M2_18420_124260 n1_M2_19500_124260 0.988200
R13818 n1_M2_19500_124260 n1_M2_20580_124260 0.988200
R13819 n1_M2_20580_124260 n1_M2_21660_124260 0.988200
R13820 n1_M2_21660_124260 n1_M2_22740_124260 0.988200
R13821 n1_M2_22740_124260 n1_M2_23820_124260 0.988200
R13822 n1_M2_23820_124260 n1_M2_24900_124260 0.988200
R13823 n1_M2_24900_124260 n1_M2_25980_124260 0.988200
R13824 n1_M2_25980_124260 n1_M2_27060_124260 0.988200
R13825 n1_M2_27060_124260 n1_M2_28140_124260 0.988200
R13826 n1_M2_28140_124260 n1_M2_29220_124260 0.988200
R13827 n1_M2_29220_124260 n1_M2_30300_124260 0.988200
R13828 n1_M2_30300_124260 n1_M2_31380_124260 0.988200
R13829 n1_M2_31380_124260 n1_M2_32460_124260 0.988200
R13830 n1_M2_32460_124260 n1_M2_33540_124260 0.988200
R13831 n1_M2_33540_124260 n1_M2_34620_124260 0.988200
R13832 n1_M2_34620_124260 n1_M2_35700_124260 0.988200
R13833 n1_M2_35700_124260 n1_M2_36780_124260 0.988200
R13834 n1_M2_36780_124260 n1_M2_37860_124260 0.988200
R13835 n1_M2_37860_124260 n1_M2_38940_124260 0.988200
R13836 n1_M2_38940_124260 n1_M2_40020_124260 0.988200
R13837 n1_M2_40020_124260 n1_M2_41100_124260 0.988200
R13838 n1_M2_41100_124260 n1_M2_42180_124260 0.988200
R13839 n1_M2_42180_124260 n1_M2_43260_124260 0.988200
R13840 n1_M2_43260_124260 n1_M2_44340_124260 0.988200
R13841 n1_M2_44340_124260 n1_M2_45420_124260 0.988200
R13842 n1_M2_45420_124260 n1_M2_46500_124260 0.988200
R13843 n1_M2_46500_124260 n1_M2_47580_124260 0.988200
R13844 n1_M2_47580_124260 n1_M2_48660_124260 0.988200
R13845 n1_M2_48660_124260 n1_M2_49740_124260 0.988200
R13846 n1_M2_49740_124260 n1_M2_50820_124260 0.988200
R13847 n1_M2_50820_124260 n1_M2_51900_124260 0.988200
R13848 n1_M2_51900_124260 n1_M2_52980_124260 0.988200
R13849 n1_M2_52980_124260 n1_M2_54060_124260 0.988200
R13850 n1_M2_54060_124260 n1_M2_55140_124260 0.988200
R13851 n1_M2_55140_124260 n1_M2_56220_124260 0.988200
R13852 n1_M2_56220_124260 n1_M2_57300_124260 0.988200
R13853 n1_M2_57300_124260 n1_M2_58380_124260 0.988200
R13854 n1_M2_58380_124260 n1_M2_59460_124260 0.988200
R13855 n1_M2_59460_124260 n1_M2_60540_124260 0.988200
R13856 n1_M2_60540_124260 n1_M2_61620_124260 0.988200
R13857 n1_M2_61620_124260 n1_M2_62700_124260 0.988200
R13858 n1_M2_62700_124260 n1_M2_63780_124260 0.988200
R13859 n1_M2_63780_124260 n1_M2_64860_124260 0.988200
R13860 n1_M2_64860_124260 n1_M2_65940_124260 0.988200
R13861 n1_M2_65940_124260 n1_M2_67020_124260 0.988200
R13862 n1_M2_67020_124260 n1_M2_68100_124260 0.988200
R13863 n1_M2_68100_124260 n1_M2_69180_124260 0.988200
R13864 n1_M2_69180_124260 n1_M2_70260_124260 0.988200
R13865 n1_M2_70260_124260 n1_M2_71340_124260 0.988200
R13866 n1_M2_71340_124260 n1_M2_72420_124260 0.988200
R13867 n1_M2_72420_124260 n1_M2_73500_124260 0.988200
R13868 n1_M2_73500_124260 n1_M2_74580_124260 0.988200
R13869 n1_M2_74580_124260 n1_M2_75660_124260 0.988200
R13870 n1_M2_75660_124260 n1_M2_76740_124260 0.988200
R13871 n1_M2_76740_124260 n1_M2_77820_124260 0.988200
R13872 n1_M2_77820_124260 n1_M2_78900_124260 0.988200
R13873 n1_M2_78900_124260 n1_M2_79980_124260 0.988200
R13874 n1_M2_79980_124260 n1_M2_81060_124260 0.988200
R13875 n1_M2_81060_124260 n1_M2_82140_124260 0.988200
R13876 n1_M2_82140_124260 n1_M2_83220_124260 0.988200
R13877 n1_M2_83220_124260 n1_M2_84300_124260 0.988200
R13878 n1_M2_84300_124260 n1_M2_85380_124260 0.988200
R13879 n1_M2_85380_124260 n1_M2_86460_124260 0.988200
R13880 n1_M2_86460_124260 n1_M2_87540_124260 0.988200
R13881 n1_M2_87540_124260 n1_M2_88620_124260 0.988200
R13882 n1_M2_88620_124260 n1_M2_89700_124260 0.988200
R13883 n1_M2_89700_124260 n1_M2_90780_124260 0.988200
R13884 n1_M2_90780_124260 n1_M2_91860_124260 0.988200
R13885 n1_M2_91860_124260 n1_M2_92940_124260 0.988200
R13886 n1_M2_92940_124260 n1_M2_94020_124260 0.988200
R13887 n1_M2_94020_124260 n1_M2_95100_124260 0.988200
R13888 n1_M2_95100_124260 n1_M2_96180_124260 0.988200
R13889 n1_M2_96180_124260 n1_M2_97260_124260 0.988200
R13890 n1_M2_97260_124260 n1_M2_98340_124260 0.988200
R13891 n1_M2_98340_124260 n1_M2_99420_124260 0.988200
R13892 n1_M2_99420_124260 n1_M2_100500_124260 0.988200
R13893 n1_M2_100500_124260 n1_M2_101580_124260 0.988200
R13894 n1_M2_101580_124260 n1_M2_102660_124260 0.988200
R13895 n1_M2_102660_124260 n1_M2_103740_124260 0.988200
R13896 n1_M2_103740_124260 n1_M2_104820_124260 0.988200
R13897 n1_M2_104820_124260 n1_M2_105900_124260 0.988200
R13898 n1_M2_105900_124260 n1_M2_106980_124260 0.988200
R13899 n1_M2_106980_124260 n1_M2_108060_124260 0.988200
R13900 n1_M2_108060_124260 n1_M2_109140_124260 0.988200
R13901 n1_M2_109140_124260 n1_M2_110220_124260 0.988200
R13902 n1_M2_110220_124260 n1_M2_111300_124260 0.988200
R13903 n1_M2_111300_124260 n1_M2_112380_124260 0.988200
R13904 n1_M2_112380_124260 n1_M2_113460_124260 0.988200
R13905 n1_M2_113460_124260 n1_M2_114540_124260 0.988200
R13906 n1_M2_114540_124260 n1_M2_115620_124260 0.988200
R13907 n1_M2_115620_124260 n1_M2_116700_124260 0.988200
R13908 n1_M2_116700_124260 n1_M2_117780_124260 0.988200
R13909 n1_M2_117780_124260 n1_M2_118860_124260 0.988200
R13910 n1_M2_118860_124260 n1_M2_119940_124260 0.988200
R13911 n1_M2_119940_124260 n1_M2_121020_124260 0.988200
R13912 n1_M2_121020_124260 n1_M2_122100_124260 0.988200
R13913 n1_M2_122100_124260 n1_M2_123180_124260 0.988200
R13914 n1_M2_123180_124260 n1_M2_124260_124260 0.988200
R13915 n1_M2_124260_124260 n1_M2_125340_124260 0.988200
R13916 n1_M2_125340_124260 n1_M2_126420_124260 0.988200
R13917 n1_M2_126420_124260 n1_M2_127500_124260 0.988200
R13918 n1_M2_127500_124260 n1_M2_128580_124260 0.988200
R13919 n1_M2_128580_124260 n1_M2_129660_124260 0.988200
R13920 n1_M2_60_125340 n1_M2_1140_125340 0.988200
R13921 n1_M2_1140_125340 n1_M2_2220_125340 0.988200
R13922 n1_M2_2220_125340 n1_M2_3300_125340 0.988200
R13923 n1_M2_3300_125340 n1_M2_4380_125340 0.988200
R13924 n1_M2_4380_125340 n1_M2_5460_125340 0.988200
R13925 n1_M2_5460_125340 n1_M2_6540_125340 0.988200
R13926 n1_M2_6540_125340 n1_M2_7620_125340 0.988200
R13927 n1_M2_7620_125340 n1_M2_8700_125340 0.988200
R13928 n1_M2_8700_125340 n1_M2_9780_125340 0.988200
R13929 n1_M2_9780_125340 n1_M2_10860_125340 0.988200
R13930 n1_M2_10860_125340 n1_M2_11940_125340 0.988200
R13931 n1_M2_11940_125340 n1_M2_13020_125340 0.988200
R13932 n1_M2_13020_125340 n1_M2_14100_125340 0.988200
R13933 n1_M2_14100_125340 n1_M2_15180_125340 0.988200
R13934 n1_M2_15180_125340 n1_M2_16260_125340 0.988200
R13935 n1_M2_16260_125340 n1_M2_17340_125340 0.988200
R13936 n1_M2_17340_125340 n1_M2_18420_125340 0.988200
R13937 n1_M2_18420_125340 n1_M2_19500_125340 0.988200
R13938 n1_M2_19500_125340 n1_M2_20580_125340 0.988200
R13939 n1_M2_20580_125340 n1_M2_21660_125340 0.988200
R13940 n1_M2_21660_125340 n1_M2_22740_125340 0.988200
R13941 n1_M2_22740_125340 n1_M2_23820_125340 0.988200
R13942 n1_M2_23820_125340 n1_M2_24900_125340 0.988200
R13943 n1_M2_24900_125340 n1_M2_25980_125340 0.988200
R13944 n1_M2_25980_125340 n1_M2_27060_125340 0.988200
R13945 n1_M2_27060_125340 n1_M2_28140_125340 0.988200
R13946 n1_M2_28140_125340 n1_M2_29220_125340 0.988200
R13947 n1_M2_29220_125340 n1_M2_30300_125340 0.988200
R13948 n1_M2_30300_125340 n1_M2_31380_125340 0.988200
R13949 n1_M2_31380_125340 n1_M2_32460_125340 0.988200
R13950 n1_M2_32460_125340 n1_M2_33540_125340 0.988200
R13951 n1_M2_33540_125340 n1_M2_34620_125340 0.988200
R13952 n1_M2_34620_125340 n1_M2_35700_125340 0.988200
R13953 n1_M2_35700_125340 n1_M2_36780_125340 0.988200
R13954 n1_M2_36780_125340 n1_M2_37860_125340 0.988200
R13955 n1_M2_37860_125340 n1_M2_38940_125340 0.988200
R13956 n1_M2_38940_125340 n1_M2_40020_125340 0.988200
R13957 n1_M2_40020_125340 n1_M2_41100_125340 0.988200
R13958 n1_M2_41100_125340 n1_M2_42180_125340 0.988200
R13959 n1_M2_42180_125340 n1_M2_43260_125340 0.988200
R13960 n1_M2_43260_125340 n1_M2_44340_125340 0.988200
R13961 n1_M2_44340_125340 n1_M2_45420_125340 0.988200
R13962 n1_M2_45420_125340 n1_M2_46500_125340 0.988200
R13963 n1_M2_46500_125340 n1_M2_47580_125340 0.988200
R13964 n1_M2_47580_125340 n1_M2_48660_125340 0.988200
R13965 n1_M2_48660_125340 n1_M2_49740_125340 0.988200
R13966 n1_M2_49740_125340 n1_M2_50820_125340 0.988200
R13967 n1_M2_50820_125340 n1_M2_51900_125340 0.988200
R13968 n1_M2_51900_125340 n1_M2_52980_125340 0.988200
R13969 n1_M2_52980_125340 n1_M2_54060_125340 0.988200
R13970 n1_M2_54060_125340 n1_M2_55140_125340 0.988200
R13971 n1_M2_55140_125340 n1_M2_56220_125340 0.988200
R13972 n1_M2_56220_125340 n1_M2_57300_125340 0.988200
R13973 n1_M2_57300_125340 n1_M2_58380_125340 0.988200
R13974 n1_M2_58380_125340 n1_M2_59460_125340 0.988200
R13975 n1_M2_59460_125340 n1_M2_60540_125340 0.988200
R13976 n1_M2_60540_125340 n1_M2_61620_125340 0.988200
R13977 n1_M2_61620_125340 n1_M2_62700_125340 0.988200
R13978 n1_M2_62700_125340 n1_M2_63780_125340 0.988200
R13979 n1_M2_63780_125340 n1_M2_64860_125340 0.988200
R13980 n1_M2_64860_125340 n1_M2_65940_125340 0.988200
R13981 n1_M2_65940_125340 n1_M2_67020_125340 0.988200
R13982 n1_M2_67020_125340 n1_M2_68100_125340 0.988200
R13983 n1_M2_68100_125340 n1_M2_69180_125340 0.988200
R13984 n1_M2_69180_125340 n1_M2_70260_125340 0.988200
R13985 n1_M2_70260_125340 n1_M2_71340_125340 0.988200
R13986 n1_M2_71340_125340 n1_M2_72420_125340 0.988200
R13987 n1_M2_72420_125340 n1_M2_73500_125340 0.988200
R13988 n1_M2_73500_125340 n1_M2_74580_125340 0.988200
R13989 n1_M2_74580_125340 n1_M2_75660_125340 0.988200
R13990 n1_M2_75660_125340 n1_M2_76740_125340 0.988200
R13991 n1_M2_76740_125340 n1_M2_77820_125340 0.988200
R13992 n1_M2_77820_125340 n1_M2_78900_125340 0.988200
R13993 n1_M2_78900_125340 n1_M2_79980_125340 0.988200
R13994 n1_M2_79980_125340 n1_M2_81060_125340 0.988200
R13995 n1_M2_81060_125340 n1_M2_82140_125340 0.988200
R13996 n1_M2_82140_125340 n1_M2_83220_125340 0.988200
R13997 n1_M2_83220_125340 n1_M2_84300_125340 0.988200
R13998 n1_M2_84300_125340 n1_M2_85380_125340 0.988200
R13999 n1_M2_85380_125340 n1_M2_86460_125340 0.988200
R14000 n1_M2_86460_125340 n1_M2_87540_125340 0.988200
R14001 n1_M2_87540_125340 n1_M2_88620_125340 0.988200
R14002 n1_M2_88620_125340 n1_M2_89700_125340 0.988200
R14003 n1_M2_89700_125340 n1_M2_90780_125340 0.988200
R14004 n1_M2_90780_125340 n1_M2_91860_125340 0.988200
R14005 n1_M2_91860_125340 n1_M2_92940_125340 0.988200
R14006 n1_M2_92940_125340 n1_M2_94020_125340 0.988200
R14007 n1_M2_94020_125340 n1_M2_95100_125340 0.988200
R14008 n1_M2_95100_125340 n1_M2_96180_125340 0.988200
R14009 n1_M2_96180_125340 n1_M2_97260_125340 0.988200
R14010 n1_M2_97260_125340 n1_M2_98340_125340 0.988200
R14011 n1_M2_98340_125340 n1_M2_99420_125340 0.988200
R14012 n1_M2_99420_125340 n1_M2_100500_125340 0.988200
R14013 n1_M2_100500_125340 n1_M2_101580_125340 0.988200
R14014 n1_M2_101580_125340 n1_M2_102660_125340 0.988200
R14015 n1_M2_102660_125340 n1_M2_103740_125340 0.988200
R14016 n1_M2_103740_125340 n1_M2_104820_125340 0.988200
R14017 n1_M2_104820_125340 n1_M2_105900_125340 0.988200
R14018 n1_M2_105900_125340 n1_M2_106980_125340 0.988200
R14019 n1_M2_106980_125340 n1_M2_108060_125340 0.988200
R14020 n1_M2_108060_125340 n1_M2_109140_125340 0.988200
R14021 n1_M2_109140_125340 n1_M2_110220_125340 0.988200
R14022 n1_M2_110220_125340 n1_M2_111300_125340 0.988200
R14023 n1_M2_111300_125340 n1_M2_112380_125340 0.988200
R14024 n1_M2_112380_125340 n1_M2_113460_125340 0.988200
R14025 n1_M2_113460_125340 n1_M2_114540_125340 0.988200
R14026 n1_M2_114540_125340 n1_M2_115620_125340 0.988200
R14027 n1_M2_115620_125340 n1_M2_116700_125340 0.988200
R14028 n1_M2_116700_125340 n1_M2_117780_125340 0.988200
R14029 n1_M2_117780_125340 n1_M2_118860_125340 0.988200
R14030 n1_M2_118860_125340 n1_M2_119940_125340 0.988200
R14031 n1_M2_119940_125340 n1_M2_121020_125340 0.988200
R14032 n1_M2_121020_125340 n1_M2_122100_125340 0.988200
R14033 n1_M2_122100_125340 n1_M2_123180_125340 0.988200
R14034 n1_M2_123180_125340 n1_M2_124260_125340 0.988200
R14035 n1_M2_124260_125340 n1_M2_125340_125340 0.988200
R14036 n1_M2_125340_125340 n1_M2_126420_125340 0.988200
R14037 n1_M2_126420_125340 n1_M2_127500_125340 0.988200
R14038 n1_M2_127500_125340 n1_M2_128580_125340 0.988200
R14039 n1_M2_128580_125340 n1_M2_129660_125340 0.988200
R14040 n1_M2_60_126420 n1_M2_1140_126420 0.988200
R14041 n1_M2_1140_126420 n1_M2_2220_126420 0.988200
R14042 n1_M2_2220_126420 n1_M2_3300_126420 0.988200
R14043 n1_M2_3300_126420 n1_M2_4380_126420 0.988200
R14044 n1_M2_4380_126420 n1_M2_5460_126420 0.988200
R14045 n1_M2_5460_126420 n1_M2_6540_126420 0.988200
R14046 n1_M2_6540_126420 n1_M2_7620_126420 0.988200
R14047 n1_M2_7620_126420 n1_M2_8700_126420 0.988200
R14048 n1_M2_8700_126420 n1_M2_9780_126420 0.988200
R14049 n1_M2_9780_126420 n1_M2_10860_126420 0.988200
R14050 n1_M2_10860_126420 n1_M2_11940_126420 0.988200
R14051 n1_M2_11940_126420 n1_M2_13020_126420 0.988200
R14052 n1_M2_13020_126420 n1_M2_14100_126420 0.988200
R14053 n1_M2_14100_126420 n1_M2_15180_126420 0.988200
R14054 n1_M2_15180_126420 n1_M2_16260_126420 0.988200
R14055 n1_M2_16260_126420 n1_M2_17340_126420 0.988200
R14056 n1_M2_17340_126420 n1_M2_18420_126420 0.988200
R14057 n1_M2_18420_126420 n1_M2_19500_126420 0.988200
R14058 n1_M2_19500_126420 n1_M2_20580_126420 0.988200
R14059 n1_M2_20580_126420 n1_M2_21660_126420 0.988200
R14060 n1_M2_21660_126420 n1_M2_22740_126420 0.988200
R14061 n1_M2_22740_126420 n1_M2_23820_126420 0.988200
R14062 n1_M2_23820_126420 n1_M2_24900_126420 0.988200
R14063 n1_M2_24900_126420 n1_M2_25980_126420 0.988200
R14064 n1_M2_25980_126420 n1_M2_27060_126420 0.988200
R14065 n1_M2_27060_126420 n1_M2_28140_126420 0.988200
R14066 n1_M2_28140_126420 n1_M2_29220_126420 0.988200
R14067 n1_M2_29220_126420 n1_M2_30300_126420 0.988200
R14068 n1_M2_30300_126420 n1_M2_31380_126420 0.988200
R14069 n1_M2_31380_126420 n1_M2_32460_126420 0.988200
R14070 n1_M2_32460_126420 n1_M2_33540_126420 0.988200
R14071 n1_M2_33540_126420 n1_M2_34620_126420 0.988200
R14072 n1_M2_34620_126420 n1_M2_35700_126420 0.988200
R14073 n1_M2_35700_126420 n1_M2_36780_126420 0.988200
R14074 n1_M2_36780_126420 n1_M2_37860_126420 0.988200
R14075 n1_M2_37860_126420 n1_M2_38940_126420 0.988200
R14076 n1_M2_38940_126420 n1_M2_40020_126420 0.988200
R14077 n1_M2_40020_126420 n1_M2_41100_126420 0.988200
R14078 n1_M2_41100_126420 n1_M2_42180_126420 0.988200
R14079 n1_M2_42180_126420 n1_M2_43260_126420 0.988200
R14080 n1_M2_43260_126420 n1_M2_44340_126420 0.988200
R14081 n1_M2_44340_126420 n1_M2_45420_126420 0.988200
R14082 n1_M2_45420_126420 n1_M2_46500_126420 0.988200
R14083 n1_M2_46500_126420 n1_M2_47580_126420 0.988200
R14084 n1_M2_47580_126420 n1_M2_48660_126420 0.988200
R14085 n1_M2_48660_126420 n1_M2_49740_126420 0.988200
R14086 n1_M2_49740_126420 n1_M2_50820_126420 0.988200
R14087 n1_M2_50820_126420 n1_M2_51900_126420 0.988200
R14088 n1_M2_51900_126420 n1_M2_52980_126420 0.988200
R14089 n1_M2_52980_126420 n1_M2_54060_126420 0.988200
R14090 n1_M2_54060_126420 n1_M2_55140_126420 0.988200
R14091 n1_M2_55140_126420 n1_M2_56220_126420 0.988200
R14092 n1_M2_56220_126420 n1_M2_57300_126420 0.988200
R14093 n1_M2_57300_126420 n1_M2_58380_126420 0.988200
R14094 n1_M2_58380_126420 n1_M2_59460_126420 0.988200
R14095 n1_M2_59460_126420 n1_M2_60540_126420 0.988200
R14096 n1_M2_60540_126420 n1_M2_61620_126420 0.988200
R14097 n1_M2_61620_126420 n1_M2_62700_126420 0.988200
R14098 n1_M2_62700_126420 n1_M2_63780_126420 0.988200
R14099 n1_M2_63780_126420 n1_M2_64860_126420 0.988200
R14100 n1_M2_64860_126420 n1_M2_65940_126420 0.988200
R14101 n1_M2_65940_126420 n1_M2_67020_126420 0.988200
R14102 n1_M2_67020_126420 n1_M2_68100_126420 0.988200
R14103 n1_M2_68100_126420 n1_M2_69180_126420 0.988200
R14104 n1_M2_69180_126420 n1_M2_70260_126420 0.988200
R14105 n1_M2_70260_126420 n1_M2_71340_126420 0.988200
R14106 n1_M2_71340_126420 n1_M2_72420_126420 0.988200
R14107 n1_M2_72420_126420 n1_M2_73500_126420 0.988200
R14108 n1_M2_73500_126420 n1_M2_74580_126420 0.988200
R14109 n1_M2_74580_126420 n1_M2_75660_126420 0.988200
R14110 n1_M2_75660_126420 n1_M2_76740_126420 0.988200
R14111 n1_M2_76740_126420 n1_M2_77820_126420 0.988200
R14112 n1_M2_77820_126420 n1_M2_78900_126420 0.988200
R14113 n1_M2_78900_126420 n1_M2_79980_126420 0.988200
R14114 n1_M2_79980_126420 n1_M2_81060_126420 0.988200
R14115 n1_M2_81060_126420 n1_M2_82140_126420 0.988200
R14116 n1_M2_82140_126420 n1_M2_83220_126420 0.988200
R14117 n1_M2_83220_126420 n1_M2_84300_126420 0.988200
R14118 n1_M2_84300_126420 n1_M2_85380_126420 0.988200
R14119 n1_M2_85380_126420 n1_M2_86460_126420 0.988200
R14120 n1_M2_86460_126420 n1_M2_87540_126420 0.988200
R14121 n1_M2_87540_126420 n1_M2_88620_126420 0.988200
R14122 n1_M2_88620_126420 n1_M2_89700_126420 0.988200
R14123 n1_M2_89700_126420 n1_M2_90780_126420 0.988200
R14124 n1_M2_90780_126420 n1_M2_91860_126420 0.988200
R14125 n1_M2_91860_126420 n1_M2_92940_126420 0.988200
R14126 n1_M2_92940_126420 n1_M2_94020_126420 0.988200
R14127 n1_M2_94020_126420 n1_M2_95100_126420 0.988200
R14128 n1_M2_95100_126420 n1_M2_96180_126420 0.988200
R14129 n1_M2_96180_126420 n1_M2_97260_126420 0.988200
R14130 n1_M2_97260_126420 n1_M2_98340_126420 0.988200
R14131 n1_M2_98340_126420 n1_M2_99420_126420 0.988200
R14132 n1_M2_99420_126420 n1_M2_100500_126420 0.988200
R14133 n1_M2_100500_126420 n1_M2_101580_126420 0.988200
R14134 n1_M2_101580_126420 n1_M2_102660_126420 0.988200
R14135 n1_M2_102660_126420 n1_M2_103740_126420 0.988200
R14136 n1_M2_103740_126420 n1_M2_104820_126420 0.988200
R14137 n1_M2_104820_126420 n1_M2_105900_126420 0.988200
R14138 n1_M2_105900_126420 n1_M2_106980_126420 0.988200
R14139 n1_M2_106980_126420 n1_M2_108060_126420 0.988200
R14140 n1_M2_108060_126420 n1_M2_109140_126420 0.988200
R14141 n1_M2_109140_126420 n1_M2_110220_126420 0.988200
R14142 n1_M2_110220_126420 n1_M2_111300_126420 0.988200
R14143 n1_M2_111300_126420 n1_M2_112380_126420 0.988200
R14144 n1_M2_112380_126420 n1_M2_113460_126420 0.988200
R14145 n1_M2_113460_126420 n1_M2_114540_126420 0.988200
R14146 n1_M2_114540_126420 n1_M2_115620_126420 0.988200
R14147 n1_M2_115620_126420 n1_M2_116700_126420 0.988200
R14148 n1_M2_116700_126420 n1_M2_117780_126420 0.988200
R14149 n1_M2_117780_126420 n1_M2_118860_126420 0.988200
R14150 n1_M2_118860_126420 n1_M2_119940_126420 0.988200
R14151 n1_M2_119940_126420 n1_M2_121020_126420 0.988200
R14152 n1_M2_121020_126420 n1_M2_122100_126420 0.988200
R14153 n1_M2_122100_126420 n1_M2_123180_126420 0.988200
R14154 n1_M2_123180_126420 n1_M2_124260_126420 0.988200
R14155 n1_M2_124260_126420 n1_M2_125340_126420 0.988200
R14156 n1_M2_125340_126420 n1_M2_126420_126420 0.988200
R14157 n1_M2_126420_126420 n1_M2_127500_126420 0.988200
R14158 n1_M2_127500_126420 n1_M2_128580_126420 0.988200
R14159 n1_M2_128580_126420 n1_M2_129660_126420 0.988200
R14160 n1_M2_60_127500 n1_M2_1140_127500 0.988200
R14161 n1_M2_1140_127500 n1_M2_2220_127500 0.988200
R14162 n1_M2_2220_127500 n1_M2_3300_127500 0.988200
R14163 n1_M2_3300_127500 n1_M2_4380_127500 0.988200
R14164 n1_M2_4380_127500 n1_M2_5460_127500 0.988200
R14165 n1_M2_5460_127500 n1_M2_6540_127500 0.988200
R14166 n1_M2_6540_127500 n1_M2_7620_127500 0.988200
R14167 n1_M2_7620_127500 n1_M2_8700_127500 0.988200
R14168 n1_M2_8700_127500 n1_M2_9780_127500 0.988200
R14169 n1_M2_9780_127500 n1_M2_10860_127500 0.988200
R14170 n1_M2_10860_127500 n1_M2_11940_127500 0.988200
R14171 n1_M2_11940_127500 n1_M2_13020_127500 0.988200
R14172 n1_M2_13020_127500 n1_M2_14100_127500 0.988200
R14173 n1_M2_14100_127500 n1_M2_15180_127500 0.988200
R14174 n1_M2_15180_127500 n1_M2_16260_127500 0.988200
R14175 n1_M2_16260_127500 n1_M2_17340_127500 0.988200
R14176 n1_M2_17340_127500 n1_M2_18420_127500 0.988200
R14177 n1_M2_18420_127500 n1_M2_19500_127500 0.988200
R14178 n1_M2_19500_127500 n1_M2_20580_127500 0.988200
R14179 n1_M2_20580_127500 n1_M2_21660_127500 0.988200
R14180 n1_M2_21660_127500 n1_M2_22740_127500 0.988200
R14181 n1_M2_22740_127500 n1_M2_23820_127500 0.988200
R14182 n1_M2_23820_127500 n1_M2_24900_127500 0.988200
R14183 n1_M2_24900_127500 n1_M2_25980_127500 0.988200
R14184 n1_M2_25980_127500 n1_M2_27060_127500 0.988200
R14185 n1_M2_27060_127500 n1_M2_28140_127500 0.988200
R14186 n1_M2_28140_127500 n1_M2_29220_127500 0.988200
R14187 n1_M2_29220_127500 n1_M2_30300_127500 0.988200
R14188 n1_M2_30300_127500 n1_M2_31380_127500 0.988200
R14189 n1_M2_31380_127500 n1_M2_32460_127500 0.988200
R14190 n1_M2_32460_127500 n1_M2_33540_127500 0.988200
R14191 n1_M2_33540_127500 n1_M2_34620_127500 0.988200
R14192 n1_M2_34620_127500 n1_M2_35700_127500 0.988200
R14193 n1_M2_35700_127500 n1_M2_36780_127500 0.988200
R14194 n1_M2_36780_127500 n1_M2_37860_127500 0.988200
R14195 n1_M2_37860_127500 n1_M2_38940_127500 0.988200
R14196 n1_M2_38940_127500 n1_M2_40020_127500 0.988200
R14197 n1_M2_40020_127500 n1_M2_41100_127500 0.988200
R14198 n1_M2_41100_127500 n1_M2_42180_127500 0.988200
R14199 n1_M2_42180_127500 n1_M2_43260_127500 0.988200
R14200 n1_M2_43260_127500 n1_M2_44340_127500 0.988200
R14201 n1_M2_44340_127500 n1_M2_45420_127500 0.988200
R14202 n1_M2_45420_127500 n1_M2_46500_127500 0.988200
R14203 n1_M2_46500_127500 n1_M2_47580_127500 0.988200
R14204 n1_M2_47580_127500 n1_M2_48660_127500 0.988200
R14205 n1_M2_48660_127500 n1_M2_49740_127500 0.988200
R14206 n1_M2_49740_127500 n1_M2_50820_127500 0.988200
R14207 n1_M2_50820_127500 n1_M2_51900_127500 0.988200
R14208 n1_M2_51900_127500 n1_M2_52980_127500 0.988200
R14209 n1_M2_52980_127500 n1_M2_54060_127500 0.988200
R14210 n1_M2_54060_127500 n1_M2_55140_127500 0.988200
R14211 n1_M2_55140_127500 n1_M2_56220_127500 0.988200
R14212 n1_M2_56220_127500 n1_M2_57300_127500 0.988200
R14213 n1_M2_57300_127500 n1_M2_58380_127500 0.988200
R14214 n1_M2_58380_127500 n1_M2_59460_127500 0.988200
R14215 n1_M2_59460_127500 n1_M2_60540_127500 0.988200
R14216 n1_M2_60540_127500 n1_M2_61620_127500 0.988200
R14217 n1_M2_61620_127500 n1_M2_62700_127500 0.988200
R14218 n1_M2_62700_127500 n1_M2_63780_127500 0.988200
R14219 n1_M2_63780_127500 n1_M2_64860_127500 0.988200
R14220 n1_M2_64860_127500 n1_M2_65940_127500 0.988200
R14221 n1_M2_65940_127500 n1_M2_67020_127500 0.988200
R14222 n1_M2_67020_127500 n1_M2_68100_127500 0.988200
R14223 n1_M2_68100_127500 n1_M2_69180_127500 0.988200
R14224 n1_M2_69180_127500 n1_M2_70260_127500 0.988200
R14225 n1_M2_70260_127500 n1_M2_71340_127500 0.988200
R14226 n1_M2_71340_127500 n1_M2_72420_127500 0.988200
R14227 n1_M2_72420_127500 n1_M2_73500_127500 0.988200
R14228 n1_M2_73500_127500 n1_M2_74580_127500 0.988200
R14229 n1_M2_74580_127500 n1_M2_75660_127500 0.988200
R14230 n1_M2_75660_127500 n1_M2_76740_127500 0.988200
R14231 n1_M2_76740_127500 n1_M2_77820_127500 0.988200
R14232 n1_M2_77820_127500 n1_M2_78900_127500 0.988200
R14233 n1_M2_78900_127500 n1_M2_79980_127500 0.988200
R14234 n1_M2_79980_127500 n1_M2_81060_127500 0.988200
R14235 n1_M2_81060_127500 n1_M2_82140_127500 0.988200
R14236 n1_M2_82140_127500 n1_M2_83220_127500 0.988200
R14237 n1_M2_83220_127500 n1_M2_84300_127500 0.988200
R14238 n1_M2_84300_127500 n1_M2_85380_127500 0.988200
R14239 n1_M2_85380_127500 n1_M2_86460_127500 0.988200
R14240 n1_M2_86460_127500 n1_M2_87540_127500 0.988200
R14241 n1_M2_87540_127500 n1_M2_88620_127500 0.988200
R14242 n1_M2_88620_127500 n1_M2_89700_127500 0.988200
R14243 n1_M2_89700_127500 n1_M2_90780_127500 0.988200
R14244 n1_M2_90780_127500 n1_M2_91860_127500 0.988200
R14245 n1_M2_91860_127500 n1_M2_92940_127500 0.988200
R14246 n1_M2_92940_127500 n1_M2_94020_127500 0.988200
R14247 n1_M2_94020_127500 n1_M2_95100_127500 0.988200
R14248 n1_M2_95100_127500 n1_M2_96180_127500 0.988200
R14249 n1_M2_96180_127500 n1_M2_97260_127500 0.988200
R14250 n1_M2_97260_127500 n1_M2_98340_127500 0.988200
R14251 n1_M2_98340_127500 n1_M2_99420_127500 0.988200
R14252 n1_M2_99420_127500 n1_M2_100500_127500 0.988200
R14253 n1_M2_100500_127500 n1_M2_101580_127500 0.988200
R14254 n1_M2_101580_127500 n1_M2_102660_127500 0.988200
R14255 n1_M2_102660_127500 n1_M2_103740_127500 0.988200
R14256 n1_M2_103740_127500 n1_M2_104820_127500 0.988200
R14257 n1_M2_104820_127500 n1_M2_105900_127500 0.988200
R14258 n1_M2_105900_127500 n1_M2_106980_127500 0.988200
R14259 n1_M2_106980_127500 n1_M2_108060_127500 0.988200
R14260 n1_M2_108060_127500 n1_M2_109140_127500 0.988200
R14261 n1_M2_109140_127500 n1_M2_110220_127500 0.988200
R14262 n1_M2_110220_127500 n1_M2_111300_127500 0.988200
R14263 n1_M2_111300_127500 n1_M2_112380_127500 0.988200
R14264 n1_M2_112380_127500 n1_M2_113460_127500 0.988200
R14265 n1_M2_113460_127500 n1_M2_114540_127500 0.988200
R14266 n1_M2_114540_127500 n1_M2_115620_127500 0.988200
R14267 n1_M2_115620_127500 n1_M2_116700_127500 0.988200
R14268 n1_M2_116700_127500 n1_M2_117780_127500 0.988200
R14269 n1_M2_117780_127500 n1_M2_118860_127500 0.988200
R14270 n1_M2_118860_127500 n1_M2_119940_127500 0.988200
R14271 n1_M2_119940_127500 n1_M2_121020_127500 0.988200
R14272 n1_M2_121020_127500 n1_M2_122100_127500 0.988200
R14273 n1_M2_122100_127500 n1_M2_123180_127500 0.988200
R14274 n1_M2_123180_127500 n1_M2_124260_127500 0.988200
R14275 n1_M2_124260_127500 n1_M2_125340_127500 0.988200
R14276 n1_M2_125340_127500 n1_M2_126420_127500 0.988200
R14277 n1_M2_126420_127500 n1_M2_127500_127500 0.988200
R14278 n1_M2_127500_127500 n1_M2_128580_127500 0.988200
R14279 n1_M2_128580_127500 n1_M2_129660_127500 0.988200
R14280 n1_M2_60_128580 n1_M2_1140_128580 0.988200
R14281 n1_M2_1140_128580 n1_M2_2220_128580 0.988200
R14282 n1_M2_2220_128580 n1_M2_3300_128580 0.988200
R14283 n1_M2_3300_128580 n1_M2_4380_128580 0.988200
R14284 n1_M2_4380_128580 n1_M2_5460_128580 0.988200
R14285 n1_M2_5460_128580 n1_M2_6540_128580 0.988200
R14286 n1_M2_6540_128580 n1_M2_7620_128580 0.988200
R14287 n1_M2_7620_128580 n1_M2_8700_128580 0.988200
R14288 n1_M2_8700_128580 n1_M2_9780_128580 0.988200
R14289 n1_M2_9780_128580 n1_M2_10860_128580 0.988200
R14290 n1_M2_10860_128580 n1_M2_11940_128580 0.988200
R14291 n1_M2_11940_128580 n1_M2_13020_128580 0.988200
R14292 n1_M2_13020_128580 n1_M2_14100_128580 0.988200
R14293 n1_M2_14100_128580 n1_M2_15180_128580 0.988200
R14294 n1_M2_15180_128580 n1_M2_16260_128580 0.988200
R14295 n1_M2_16260_128580 n1_M2_17340_128580 0.988200
R14296 n1_M2_17340_128580 n1_M2_18420_128580 0.988200
R14297 n1_M2_18420_128580 n1_M2_19500_128580 0.988200
R14298 n1_M2_19500_128580 n1_M2_20580_128580 0.988200
R14299 n1_M2_20580_128580 n1_M2_21660_128580 0.988200
R14300 n1_M2_21660_128580 n1_M2_22740_128580 0.988200
R14301 n1_M2_22740_128580 n1_M2_23820_128580 0.988200
R14302 n1_M2_23820_128580 n1_M2_24900_128580 0.988200
R14303 n1_M2_24900_128580 n1_M2_25980_128580 0.988200
R14304 n1_M2_25980_128580 n1_M2_27060_128580 0.988200
R14305 n1_M2_27060_128580 n1_M2_28140_128580 0.988200
R14306 n1_M2_28140_128580 n1_M2_29220_128580 0.988200
R14307 n1_M2_29220_128580 n1_M2_30300_128580 0.988200
R14308 n1_M2_30300_128580 n1_M2_31380_128580 0.988200
R14309 n1_M2_31380_128580 n1_M2_32460_128580 0.988200
R14310 n1_M2_32460_128580 n1_M2_33540_128580 0.988200
R14311 n1_M2_33540_128580 n1_M2_34620_128580 0.988200
R14312 n1_M2_34620_128580 n1_M2_35700_128580 0.988200
R14313 n1_M2_35700_128580 n1_M2_36780_128580 0.988200
R14314 n1_M2_36780_128580 n1_M2_37860_128580 0.988200
R14315 n1_M2_37860_128580 n1_M2_38940_128580 0.988200
R14316 n1_M2_38940_128580 n1_M2_40020_128580 0.988200
R14317 n1_M2_40020_128580 n1_M2_41100_128580 0.988200
R14318 n1_M2_41100_128580 n1_M2_42180_128580 0.988200
R14319 n1_M2_42180_128580 n1_M2_43260_128580 0.988200
R14320 n1_M2_43260_128580 n1_M2_44340_128580 0.988200
R14321 n1_M2_44340_128580 n1_M2_45420_128580 0.988200
R14322 n1_M2_45420_128580 n1_M2_46500_128580 0.988200
R14323 n1_M2_46500_128580 n1_M2_47580_128580 0.988200
R14324 n1_M2_47580_128580 n1_M2_48660_128580 0.988200
R14325 n1_M2_48660_128580 n1_M2_49740_128580 0.988200
R14326 n1_M2_49740_128580 n1_M2_50820_128580 0.988200
R14327 n1_M2_50820_128580 n1_M2_51900_128580 0.988200
R14328 n1_M2_51900_128580 n1_M2_52980_128580 0.988200
R14329 n1_M2_52980_128580 n1_M2_54060_128580 0.988200
R14330 n1_M2_54060_128580 n1_M2_55140_128580 0.988200
R14331 n1_M2_55140_128580 n1_M2_56220_128580 0.988200
R14332 n1_M2_56220_128580 n1_M2_57300_128580 0.988200
R14333 n1_M2_57300_128580 n1_M2_58380_128580 0.988200
R14334 n1_M2_58380_128580 n1_M2_59460_128580 0.988200
R14335 n1_M2_59460_128580 n1_M2_60540_128580 0.988200
R14336 n1_M2_60540_128580 n1_M2_61620_128580 0.988200
R14337 n1_M2_61620_128580 n1_M2_62700_128580 0.988200
R14338 n1_M2_62700_128580 n1_M2_63780_128580 0.988200
R14339 n1_M2_63780_128580 n1_M2_64860_128580 0.988200
R14340 n1_M2_64860_128580 n1_M2_65940_128580 0.988200
R14341 n1_M2_65940_128580 n1_M2_67020_128580 0.988200
R14342 n1_M2_67020_128580 n1_M2_68100_128580 0.988200
R14343 n1_M2_68100_128580 n1_M2_69180_128580 0.988200
R14344 n1_M2_69180_128580 n1_M2_70260_128580 0.988200
R14345 n1_M2_70260_128580 n1_M2_71340_128580 0.988200
R14346 n1_M2_71340_128580 n1_M2_72420_128580 0.988200
R14347 n1_M2_72420_128580 n1_M2_73500_128580 0.988200
R14348 n1_M2_73500_128580 n1_M2_74580_128580 0.988200
R14349 n1_M2_74580_128580 n1_M2_75660_128580 0.988200
R14350 n1_M2_75660_128580 n1_M2_76740_128580 0.988200
R14351 n1_M2_76740_128580 n1_M2_77820_128580 0.988200
R14352 n1_M2_77820_128580 n1_M2_78900_128580 0.988200
R14353 n1_M2_78900_128580 n1_M2_79980_128580 0.988200
R14354 n1_M2_79980_128580 n1_M2_81060_128580 0.988200
R14355 n1_M2_81060_128580 n1_M2_82140_128580 0.988200
R14356 n1_M2_82140_128580 n1_M2_83220_128580 0.988200
R14357 n1_M2_83220_128580 n1_M2_84300_128580 0.988200
R14358 n1_M2_84300_128580 n1_M2_85380_128580 0.988200
R14359 n1_M2_85380_128580 n1_M2_86460_128580 0.988200
R14360 n1_M2_86460_128580 n1_M2_87540_128580 0.988200
R14361 n1_M2_87540_128580 n1_M2_88620_128580 0.988200
R14362 n1_M2_88620_128580 n1_M2_89700_128580 0.988200
R14363 n1_M2_89700_128580 n1_M2_90780_128580 0.988200
R14364 n1_M2_90780_128580 n1_M2_91860_128580 0.988200
R14365 n1_M2_91860_128580 n1_M2_92940_128580 0.988200
R14366 n1_M2_92940_128580 n1_M2_94020_128580 0.988200
R14367 n1_M2_94020_128580 n1_M2_95100_128580 0.988200
R14368 n1_M2_95100_128580 n1_M2_96180_128580 0.988200
R14369 n1_M2_96180_128580 n1_M2_97260_128580 0.988200
R14370 n1_M2_97260_128580 n1_M2_98340_128580 0.988200
R14371 n1_M2_98340_128580 n1_M2_99420_128580 0.988200
R14372 n1_M2_99420_128580 n1_M2_100500_128580 0.988200
R14373 n1_M2_100500_128580 n1_M2_101580_128580 0.988200
R14374 n1_M2_101580_128580 n1_M2_102660_128580 0.988200
R14375 n1_M2_102660_128580 n1_M2_103740_128580 0.988200
R14376 n1_M2_103740_128580 n1_M2_104820_128580 0.988200
R14377 n1_M2_104820_128580 n1_M2_105900_128580 0.988200
R14378 n1_M2_105900_128580 n1_M2_106980_128580 0.988200
R14379 n1_M2_106980_128580 n1_M2_108060_128580 0.988200
R14380 n1_M2_108060_128580 n1_M2_109140_128580 0.988200
R14381 n1_M2_109140_128580 n1_M2_110220_128580 0.988200
R14382 n1_M2_110220_128580 n1_M2_111300_128580 0.988200
R14383 n1_M2_111300_128580 n1_M2_112380_128580 0.988200
R14384 n1_M2_112380_128580 n1_M2_113460_128580 0.988200
R14385 n1_M2_113460_128580 n1_M2_114540_128580 0.988200
R14386 n1_M2_114540_128580 n1_M2_115620_128580 0.988200
R14387 n1_M2_115620_128580 n1_M2_116700_128580 0.988200
R14388 n1_M2_116700_128580 n1_M2_117780_128580 0.988200
R14389 n1_M2_117780_128580 n1_M2_118860_128580 0.988200
R14390 n1_M2_118860_128580 n1_M2_119940_128580 0.988200
R14391 n1_M2_119940_128580 n1_M2_121020_128580 0.988200
R14392 n1_M2_121020_128580 n1_M2_122100_128580 0.988200
R14393 n1_M2_122100_128580 n1_M2_123180_128580 0.988200
R14394 n1_M2_123180_128580 n1_M2_124260_128580 0.988200
R14395 n1_M2_124260_128580 n1_M2_125340_128580 0.988200
R14396 n1_M2_125340_128580 n1_M2_126420_128580 0.988200
R14397 n1_M2_126420_128580 n1_M2_127500_128580 0.988200
R14398 n1_M2_127500_128580 n1_M2_128580_128580 0.988200
R14399 n1_M2_128580_128580 n1_M2_129660_128580 0.988200
R14400 n1_M2_60_129660 n1_M2_1140_129660 0.988200
R14401 n1_M2_1140_129660 n1_M2_2220_129660 0.988200
R14402 n1_M2_2220_129660 n1_M2_3300_129660 0.988200
R14403 n1_M2_3300_129660 n1_M2_4380_129660 0.988200
R14404 n1_M2_4380_129660 n1_M2_5460_129660 0.988200
R14405 n1_M2_5460_129660 n1_M2_6540_129660 0.988200
R14406 n1_M2_6540_129660 n1_M2_7620_129660 0.988200
R14407 n1_M2_7620_129660 n1_M2_8700_129660 0.988200
R14408 n1_M2_8700_129660 n1_M2_9780_129660 0.988200
R14409 n1_M2_9780_129660 n1_M2_10860_129660 0.988200
R14410 n1_M2_10860_129660 n1_M2_11940_129660 0.988200
R14411 n1_M2_11940_129660 n1_M2_13020_129660 0.988200
R14412 n1_M2_13020_129660 n1_M2_14100_129660 0.988200
R14413 n1_M2_14100_129660 n1_M2_15180_129660 0.988200
R14414 n1_M2_15180_129660 n1_M2_16260_129660 0.988200
R14415 n1_M2_16260_129660 n1_M2_17340_129660 0.988200
R14416 n1_M2_17340_129660 n1_M2_18420_129660 0.988200
R14417 n1_M2_18420_129660 n1_M2_19500_129660 0.988200
R14418 n1_M2_19500_129660 n1_M2_20580_129660 0.988200
R14419 n1_M2_20580_129660 n1_M2_21660_129660 0.988200
R14420 n1_M2_21660_129660 n1_M2_22740_129660 0.988200
R14421 n1_M2_22740_129660 n1_M2_23820_129660 0.988200
R14422 n1_M2_23820_129660 n1_M2_24900_129660 0.988200
R14423 n1_M2_24900_129660 n1_M2_25980_129660 0.988200
R14424 n1_M2_25980_129660 n1_M2_27060_129660 0.988200
R14425 n1_M2_27060_129660 n1_M2_28140_129660 0.988200
R14426 n1_M2_28140_129660 n1_M2_29220_129660 0.988200
R14427 n1_M2_29220_129660 n1_M2_30300_129660 0.988200
R14428 n1_M2_30300_129660 n1_M2_31380_129660 0.988200
R14429 n1_M2_31380_129660 n1_M2_32460_129660 0.988200
R14430 n1_M2_32460_129660 n1_M2_33540_129660 0.988200
R14431 n1_M2_33540_129660 n1_M2_34620_129660 0.988200
R14432 n1_M2_34620_129660 n1_M2_35700_129660 0.988200
R14433 n1_M2_35700_129660 n1_M2_36780_129660 0.988200
R14434 n1_M2_36780_129660 n1_M2_37860_129660 0.988200
R14435 n1_M2_37860_129660 n1_M2_38940_129660 0.988200
R14436 n1_M2_38940_129660 n1_M2_40020_129660 0.988200
R14437 n1_M2_40020_129660 n1_M2_41100_129660 0.988200
R14438 n1_M2_41100_129660 n1_M2_42180_129660 0.988200
R14439 n1_M2_42180_129660 n1_M2_43260_129660 0.988200
R14440 n1_M2_43260_129660 n1_M2_44340_129660 0.988200
R14441 n1_M2_44340_129660 n1_M2_45420_129660 0.988200
R14442 n1_M2_45420_129660 n1_M2_46500_129660 0.988200
R14443 n1_M2_46500_129660 n1_M2_47580_129660 0.988200
R14444 n1_M2_47580_129660 n1_M2_48660_129660 0.988200
R14445 n1_M2_48660_129660 n1_M2_49740_129660 0.988200
R14446 n1_M2_49740_129660 n1_M2_50820_129660 0.988200
R14447 n1_M2_50820_129660 n1_M2_51900_129660 0.988200
R14448 n1_M2_51900_129660 n1_M2_52980_129660 0.988200
R14449 n1_M2_52980_129660 n1_M2_54060_129660 0.988200
R14450 n1_M2_54060_129660 n1_M2_55140_129660 0.988200
R14451 n1_M2_55140_129660 n1_M2_56220_129660 0.988200
R14452 n1_M2_56220_129660 n1_M2_57300_129660 0.988200
R14453 n1_M2_57300_129660 n1_M2_58380_129660 0.988200
R14454 n1_M2_58380_129660 n1_M2_59460_129660 0.988200
R14455 n1_M2_59460_129660 n1_M2_60540_129660 0.988200
R14456 n1_M2_60540_129660 n1_M2_61620_129660 0.988200
R14457 n1_M2_61620_129660 n1_M2_62700_129660 0.988200
R14458 n1_M2_62700_129660 n1_M2_63780_129660 0.988200
R14459 n1_M2_63780_129660 n1_M2_64860_129660 0.988200
R14460 n1_M2_64860_129660 n1_M2_65940_129660 0.988200
R14461 n1_M2_65940_129660 n1_M2_67020_129660 0.988200
R14462 n1_M2_67020_129660 n1_M2_68100_129660 0.988200
R14463 n1_M2_68100_129660 n1_M2_69180_129660 0.988200
R14464 n1_M2_69180_129660 n1_M2_70260_129660 0.988200
R14465 n1_M2_70260_129660 n1_M2_71340_129660 0.988200
R14466 n1_M2_71340_129660 n1_M2_72420_129660 0.988200
R14467 n1_M2_72420_129660 n1_M2_73500_129660 0.988200
R14468 n1_M2_73500_129660 n1_M2_74580_129660 0.988200
R14469 n1_M2_74580_129660 n1_M2_75660_129660 0.988200
R14470 n1_M2_75660_129660 n1_M2_76740_129660 0.988200
R14471 n1_M2_76740_129660 n1_M2_77820_129660 0.988200
R14472 n1_M2_77820_129660 n1_M2_78900_129660 0.988200
R14473 n1_M2_78900_129660 n1_M2_79980_129660 0.988200
R14474 n1_M2_79980_129660 n1_M2_81060_129660 0.988200
R14475 n1_M2_81060_129660 n1_M2_82140_129660 0.988200
R14476 n1_M2_82140_129660 n1_M2_83220_129660 0.988200
R14477 n1_M2_83220_129660 n1_M2_84300_129660 0.988200
R14478 n1_M2_84300_129660 n1_M2_85380_129660 0.988200
R14479 n1_M2_85380_129660 n1_M2_86460_129660 0.988200
R14480 n1_M2_86460_129660 n1_M2_87540_129660 0.988200
R14481 n1_M2_87540_129660 n1_M2_88620_129660 0.988200
R14482 n1_M2_88620_129660 n1_M2_89700_129660 0.988200
R14483 n1_M2_89700_129660 n1_M2_90780_129660 0.988200
R14484 n1_M2_90780_129660 n1_M2_91860_129660 0.988200
R14485 n1_M2_91860_129660 n1_M2_92940_129660 0.988200
R14486 n1_M2_92940_129660 n1_M2_94020_129660 0.988200
R14487 n1_M2_94020_129660 n1_M2_95100_129660 0.988200
R14488 n1_M2_95100_129660 n1_M2_96180_129660 0.988200
R14489 n1_M2_96180_129660 n1_M2_97260_129660 0.988200
R14490 n1_M2_97260_129660 n1_M2_98340_129660 0.988200
R14491 n1_M2_98340_129660 n1_M2_99420_129660 0.988200
R14492 n1_M2_99420_129660 n1_M2_100500_129660 0.988200
R14493 n1_M2_100500_129660 n1_M2_101580_129660 0.988200
R14494 n1_M2_101580_129660 n1_M2_102660_129660 0.988200
R14495 n1_M2_102660_129660 n1_M2_103740_129660 0.988200
R14496 n1_M2_103740_129660 n1_M2_104820_129660 0.988200
R14497 n1_M2_104820_129660 n1_M2_105900_129660 0.988200
R14498 n1_M2_105900_129660 n1_M2_106980_129660 0.988200
R14499 n1_M2_106980_129660 n1_M2_108060_129660 0.988200
R14500 n1_M2_108060_129660 n1_M2_109140_129660 0.988200
R14501 n1_M2_109140_129660 n1_M2_110220_129660 0.988200
R14502 n1_M2_110220_129660 n1_M2_111300_129660 0.988200
R14503 n1_M2_111300_129660 n1_M2_112380_129660 0.988200
R14504 n1_M2_112380_129660 n1_M2_113460_129660 0.988200
R14505 n1_M2_113460_129660 n1_M2_114540_129660 0.988200
R14506 n1_M2_114540_129660 n1_M2_115620_129660 0.988200
R14507 n1_M2_115620_129660 n1_M2_116700_129660 0.988200
R14508 n1_M2_116700_129660 n1_M2_117780_129660 0.988200
R14509 n1_M2_117780_129660 n1_M2_118860_129660 0.988200
R14510 n1_M2_118860_129660 n1_M2_119940_129660 0.988200
R14511 n1_M2_119940_129660 n1_M2_121020_129660 0.988200
R14512 n1_M2_121020_129660 n1_M2_122100_129660 0.988200
R14513 n1_M2_122100_129660 n1_M2_123180_129660 0.988200
R14514 n1_M2_123180_129660 n1_M2_124260_129660 0.988200
R14515 n1_M2_124260_129660 n1_M2_125340_129660 0.988200
R14516 n1_M2_125340_129660 n1_M2_126420_129660 0.988200
R14517 n1_M2_126420_129660 n1_M2_127500_129660 0.988200
R14518 n1_M2_127500_129660 n1_M2_128580_129660 0.988200
R14519 n1_M2_128580_129660 n1_M2_129660_129660 0.988200
R14520 n1_M5_60_60 n1_M5_60_1140 0.197640
R14521 n1_M5_60_1140 n1_M5_60_2220 0.197640
R14522 n1_M5_60_2220 n1_M5_60_3300 0.197640
R14523 n1_M5_60_3300 n1_M5_60_4380 0.197640
R14524 n1_M5_60_4380 n1_M5_60_5460 0.197640
R14525 n1_M5_60_5460 n1_M5_60_6540 0.197640
R14526 n1_M5_60_6540 n1_M5_60_7620 0.197640
R14527 n1_M5_60_7620 n1_M5_60_8700 0.197640
R14528 n1_M5_60_8700 n1_M5_60_9780 0.197640
R14529 n1_M5_60_9780 n1_M5_60_10860 0.197640
R14530 n1_M5_60_10860 n1_M5_60_11940 0.197640
R14531 n1_M5_60_11940 n1_M5_60_12060 0.021960
R14532 n1_M5_60_13020 n1_M5_60_12060 0.175680
R14533 n1_M5_60_13020 n1_M5_60_14100 0.197640
R14534 n1_M5_60_14100 n1_M5_60_15180 0.197640
R14535 n1_M5_60_15180 n1_M5_60_16260 0.197640
R14536 n1_M5_60_16260 n1_M5_60_17340 0.197640
R14537 n1_M5_60_17340 n1_M5_60_18420 0.197640
R14538 n1_M5_60_18420 n1_M5_60_19500 0.197640
R14539 n1_M5_60_19500 n1_M5_60_20580 0.197640
R14540 n1_M5_60_20580 n1_M5_60_21660 0.197640
R14541 n1_M5_60_21660 n1_M5_60_22740 0.197640
R14542 n1_M5_60_22740 n1_M5_60_23820 0.197640
R14543 n1_M5_60_23820 n1_M5_60_24060 0.043920
R14544 n1_M5_60_24900 n1_M5_60_24060 0.153720
R14545 n1_M5_60_24900 n1_M5_60_25980 0.197640
R14546 n1_M5_60_25980 n1_M5_60_27060 0.197640
R14547 n1_M5_60_27060 n1_M5_60_28140 0.197640
R14548 n1_M5_60_28140 n1_M5_60_29220 0.197640
R14549 n1_M5_60_29220 n1_M5_60_30300 0.197640
R14550 n1_M5_60_30300 n1_M5_60_31380 0.197640
R14551 n1_M5_60_31380 n1_M5_60_32460 0.197640
R14552 n1_M5_60_32460 n1_M5_60_33540 0.197640
R14553 n1_M5_60_33540 n1_M5_60_34620 0.197640
R14554 n1_M5_60_34620 n1_M5_60_35700 0.197640
R14555 n1_M5_60_35700 n1_M5_60_36060 0.065880
R14556 n1_M5_60_36780 n1_M5_60_36060 0.131760
R14557 n1_M5_60_36780 n1_M5_60_37860 0.197640
R14558 n1_M5_60_37860 n1_M5_60_38940 0.197640
R14559 n1_M5_60_38940 n1_M5_60_40020 0.197640
R14560 n1_M5_60_40020 n1_M5_60_41100 0.197640
R14561 n1_M5_60_41100 n1_M5_60_42180 0.197640
R14562 n1_M5_60_42180 n1_M5_60_43260 0.197640
R14563 n1_M5_60_43260 n1_M5_60_44340 0.197640
R14564 n1_M5_60_44340 n1_M5_60_45420 0.197640
R14565 n1_M5_60_45420 n1_M5_60_46500 0.197640
R14566 n1_M5_60_46500 n1_M5_60_47580 0.197640
R14567 n1_M5_60_47580 n1_M5_60_48060 0.087840
R14568 n1_M5_60_48660 n1_M5_60_48060 0.109800
R14569 n1_M5_60_48660 n1_M5_60_49740 0.197640
R14570 n1_M5_60_49740 n1_M5_60_50820 0.197640
R14571 n1_M5_60_50820 n1_M5_60_51900 0.197640
R14572 n1_M5_60_51900 n1_M5_60_52980 0.197640
R14573 n1_M5_60_52980 n1_M5_60_54060 0.197640
R14574 n1_M5_60_54060 n1_M5_60_55140 0.197640
R14575 n1_M5_60_55140 n1_M5_60_56220 0.197640
R14576 n1_M5_60_56220 n1_M5_60_57300 0.197640
R14577 n1_M5_60_57300 n1_M5_60_58380 0.197640
R14578 n1_M5_60_58380 n1_M5_60_59460 0.197640
R14579 n1_M5_60_59460 n1_M5_60_60060 0.109800
R14580 n1_M5_60_60540 n1_M5_60_60060 0.087840
R14581 n1_M5_60_60540 n1_M5_60_61620 0.197640
R14582 n1_M5_60_61620 n1_M5_60_62700 0.197640
R14583 n1_M5_60_62700 n1_M5_60_63780 0.197640
R14584 n1_M5_60_63780 n1_M5_60_64860 0.197640
R14585 n1_M5_60_64860 n1_M5_60_65940 0.197640
R14586 n1_M5_60_65940 n1_M5_60_67020 0.197640
R14587 n1_M5_60_67020 n1_M5_60_68100 0.197640
R14588 n1_M5_60_68100 n1_M5_60_69180 0.197640
R14589 n1_M5_60_69180 n1_M5_60_70260 0.197640
R14590 n1_M5_60_70260 n1_M5_60_71340 0.197640
R14591 n1_M5_60_71340 n1_M5_60_72060 0.131760
R14592 n1_M5_60_72420 n1_M5_60_72060 0.065880
R14593 n1_M5_60_72420 n1_M5_60_73500 0.197640
R14594 n1_M5_60_73500 n1_M5_60_74580 0.197640
R14595 n1_M5_60_74580 n1_M5_60_75660 0.197640
R14596 n1_M5_60_75660 n1_M5_60_76740 0.197640
R14597 n1_M5_60_76740 n1_M5_60_77820 0.197640
R14598 n1_M5_60_77820 n1_M5_60_78900 0.197640
R14599 n1_M5_60_78900 n1_M5_60_79980 0.197640
R14600 n1_M5_60_79980 n1_M5_60_81060 0.197640
R14601 n1_M5_60_81060 n1_M5_60_82140 0.197640
R14602 n1_M5_60_82140 n1_M5_60_83220 0.197640
R14603 n1_M5_60_83220 n1_M5_60_84060 0.153720
R14604 n1_M5_60_84300 n1_M5_60_84060 0.043920
R14605 n1_M5_60_84300 n1_M5_60_85380 0.197640
R14606 n1_M5_60_85380 n1_M5_60_86460 0.197640
R14607 n1_M5_60_86460 n1_M5_60_87540 0.197640
R14608 n1_M5_60_87540 n1_M5_60_88620 0.197640
R14609 n1_M5_60_88620 n1_M5_60_89700 0.197640
R14610 n1_M5_60_89700 n1_M5_60_90780 0.197640
R14611 n1_M5_60_90780 n1_M5_60_91860 0.197640
R14612 n1_M5_60_91860 n1_M5_60_92940 0.197640
R14613 n1_M5_60_92940 n1_M5_60_94020 0.197640
R14614 n1_M5_60_94020 n1_M5_60_95100 0.197640
R14615 n1_M5_60_95100 n1_M5_60_96060 0.175680
R14616 n1_M5_60_96180 n1_M5_60_96060 0.021960
R14617 n1_M5_60_96180 n1_M5_60_97260 0.197640
R14618 n1_M5_60_97260 n1_M5_60_98340 0.197640
R14619 n1_M5_60_98340 n1_M5_60_99420 0.197640
R14620 n1_M5_60_99420 n1_M5_60_100500 0.197640
R14621 n1_M5_60_100500 n1_M5_60_101580 0.197640
R14622 n1_M5_60_101580 n1_M5_60_102660 0.197640
R14623 n1_M5_60_102660 n1_M5_60_103740 0.197640
R14624 n1_M5_60_103740 n1_M5_60_104820 0.197640
R14625 n1_M5_60_104820 n1_M5_60_105900 0.197640
R14626 n1_M5_60_105900 n1_M5_60_106980 0.197640
R14627 n1_M5_60_106980 n1_M5_60_108060 0.197640
R14628 n1_M5_60_108060 n1_M5_60_109140 0.197640
R14629 n1_M5_60_109140 n1_M5_60_110220 0.197640
R14630 n1_M5_60_110220 n1_M5_60_111300 0.197640
R14631 n1_M5_60_111300 n1_M5_60_112380 0.197640
R14632 n1_M5_60_112380 n1_M5_60_113460 0.197640
R14633 n1_M5_60_113460 n1_M5_60_114540 0.197640
R14634 n1_M5_60_114540 n1_M5_60_115620 0.197640
R14635 n1_M5_60_115620 n1_M5_60_116700 0.197640
R14636 n1_M5_60_116700 n1_M5_60_117780 0.197640
R14637 n1_M5_60_117780 n1_M5_60_118860 0.197640
R14638 n1_M5_60_118860 n1_M5_60_119940 0.197640
R14639 n1_M5_60_119940 n1_M5_60_120060 0.021960
R14640 n1_M5_60_121020 n1_M5_60_120060 0.175680
R14641 n1_M5_60_121020 n1_M5_60_122100 0.197640
R14642 n1_M5_60_122100 n1_M5_60_123180 0.197640
R14643 n1_M5_60_123180 n1_M5_60_124260 0.197640
R14644 n1_M5_60_124260 n1_M5_60_125340 0.197640
R14645 n1_M5_60_125340 n1_M5_60_126420 0.197640
R14646 n1_M5_60_126420 n1_M5_60_127500 0.197640
R14647 n1_M5_60_127500 n1_M5_60_128580 0.197640
R14648 n1_M5_60_128580 n1_M5_60_129660 0.197640
R14649 n1_M5_24060_60 n1_M5_24060_1140 0.197640
R14650 n1_M5_24060_1140 n1_M5_24060_2220 0.197640
R14651 n1_M5_24060_2220 n1_M5_24060_3300 0.197640
R14652 n1_M5_24060_3300 n1_M5_24060_4380 0.197640
R14653 n1_M5_24060_4380 n1_M5_24060_5460 0.197640
R14654 n1_M5_24060_5460 n1_M5_24060_6540 0.197640
R14655 n1_M5_24060_6540 n1_M5_24060_7620 0.197640
R14656 n1_M5_24060_7620 n1_M5_24060_8700 0.197640
R14657 n1_M5_24060_8700 n1_M5_24060_9780 0.197640
R14658 n1_M5_24060_9780 n1_M5_24060_10860 0.197640
R14659 n1_M5_24060_10860 n1_M5_24060_11940 0.197640
R14660 n1_M5_24060_11940 n1_M5_24060_12060 0.021960
R14661 n1_M5_24060_13020 n1_M5_24060_12060 0.175680
R14662 n1_M5_24060_13020 n1_M5_24060_14100 0.197640
R14663 n1_M5_24060_14100 n1_M5_24060_15180 0.197640
R14664 n1_M5_24060_15180 n1_M5_24060_16260 0.197640
R14665 n1_M5_24060_16260 n1_M5_24060_17340 0.197640
R14666 n1_M5_24060_17340 n1_M5_24060_18420 0.197640
R14667 n1_M5_24060_18420 n1_M5_24060_19500 0.197640
R14668 n1_M5_24060_19500 n1_M5_24060_20580 0.197640
R14669 n1_M5_24060_20580 n1_M5_24060_21660 0.197640
R14670 n1_M5_24060_21660 n1_M5_24060_22740 0.197640
R14671 n1_M5_24060_22740 n1_M5_24060_23820 0.197640
R14672 n1_M5_24060_23820 n1_M5_24060_24060 0.043920
R14673 n1_M5_24060_24900 n1_M5_24060_24060 0.153720
R14674 n1_M5_24060_24900 n1_M5_24060_25980 0.197640
R14675 n1_M5_24060_25980 n1_M5_24060_27060 0.197640
R14676 n1_M5_24060_27060 n1_M5_24060_28140 0.197640
R14677 n1_M5_24060_28140 n1_M5_24060_29220 0.197640
R14678 n1_M5_24060_29220 n1_M5_24060_30300 0.197640
R14679 n1_M5_24060_30300 n1_M5_24060_31380 0.197640
R14680 n1_M5_24060_31380 n1_M5_24060_32460 0.197640
R14681 n1_M5_24060_32460 n1_M5_24060_33540 0.197640
R14682 n1_M5_24060_33540 n1_M5_24060_34620 0.197640
R14683 n1_M5_24060_34620 n1_M5_24060_35700 0.197640
R14684 n1_M5_24060_35700 n1_M5_24060_36060 0.065880
R14685 n1_M5_24060_36780 n1_M5_24060_36060 0.131760
R14686 n1_M5_24060_36780 n1_M5_24060_37860 0.197640
R14687 n1_M5_24060_37860 n1_M5_24060_38940 0.197640
R14688 n1_M5_24060_38940 n1_M5_24060_40020 0.197640
R14689 n1_M5_24060_40020 n1_M5_24060_41100 0.197640
R14690 n1_M5_24060_41100 n1_M5_24060_42180 0.197640
R14691 n1_M5_24060_42180 n1_M5_24060_43260 0.197640
R14692 n1_M5_24060_43260 n1_M5_24060_44340 0.197640
R14693 n1_M5_24060_44340 n1_M5_24060_45420 0.197640
R14694 n1_M5_24060_45420 n1_M5_24060_46500 0.197640
R14695 n1_M5_24060_46500 n1_M5_24060_47580 0.197640
R14696 n1_M5_24060_47580 n1_M5_24060_48060 0.087840
R14697 n1_M5_24060_48660 n1_M5_24060_48060 0.109800
R14698 n1_M5_24060_48660 n1_M5_24060_49740 0.197640
R14699 n1_M5_24060_49740 n1_M5_24060_50820 0.197640
R14700 n1_M5_24060_50820 n1_M5_24060_51900 0.197640
R14701 n1_M5_24060_51900 n1_M5_24060_52980 0.197640
R14702 n1_M5_24060_52980 n1_M5_24060_54060 0.197640
R14703 n1_M5_24060_54060 n1_M5_24060_55140 0.197640
R14704 n1_M5_24060_55140 n1_M5_24060_56220 0.197640
R14705 n1_M5_24060_56220 n1_M5_24060_57300 0.197640
R14706 n1_M5_24060_57300 n1_M5_24060_58380 0.197640
R14707 n1_M5_24060_58380 n1_M5_24060_59460 0.197640
R14708 n1_M5_24060_59460 n1_M5_24060_60060 0.109800
R14709 n1_M5_24060_60540 n1_M5_24060_60060 0.087840
R14710 n1_M5_24060_60540 n1_M5_24060_61620 0.197640
R14711 n1_M5_24060_61620 n1_M5_24060_62700 0.197640
R14712 n1_M5_24060_62700 n1_M5_24060_63780 0.197640
R14713 n1_M5_24060_63780 n1_M5_24060_64860 0.197640
R14714 n1_M5_24060_64860 n1_M5_24060_65940 0.197640
R14715 n1_M5_24060_65940 n1_M5_24060_67020 0.197640
R14716 n1_M5_24060_67020 n1_M5_24060_68100 0.197640
R14717 n1_M5_24060_68100 n1_M5_24060_69180 0.197640
R14718 n1_M5_24060_69180 n1_M5_24060_70260 0.197640
R14719 n1_M5_24060_70260 n1_M5_24060_71340 0.197640
R14720 n1_M5_24060_71340 n1_M5_24060_72060 0.131760
R14721 n1_M5_24060_72420 n1_M5_24060_72060 0.065880
R14722 n1_M5_24060_72420 n1_M5_24060_73500 0.197640
R14723 n1_M5_24060_73500 n1_M5_24060_74580 0.197640
R14724 n1_M5_24060_74580 n1_M5_24060_75660 0.197640
R14725 n1_M5_24060_75660 n1_M5_24060_76740 0.197640
R14726 n1_M5_24060_76740 n1_M5_24060_77820 0.197640
R14727 n1_M5_24060_77820 n1_M5_24060_78900 0.197640
R14728 n1_M5_24060_78900 n1_M5_24060_79980 0.197640
R14729 n1_M5_24060_79980 n1_M5_24060_81060 0.197640
R14730 n1_M5_24060_81060 n1_M5_24060_82140 0.197640
R14731 n1_M5_24060_82140 n1_M5_24060_83220 0.197640
R14732 n1_M5_24060_83220 n1_M5_24060_84060 0.153720
R14733 n1_M5_24060_84300 n1_M5_24060_84060 0.043920
R14734 n1_M5_24060_84300 n1_M5_24060_85380 0.197640
R14735 n1_M5_24060_85380 n1_M5_24060_86460 0.197640
R14736 n1_M5_24060_86460 n1_M5_24060_87540 0.197640
R14737 n1_M5_24060_87540 n1_M5_24060_88620 0.197640
R14738 n1_M5_24060_88620 n1_M5_24060_89700 0.197640
R14739 n1_M5_24060_89700 n1_M5_24060_90780 0.197640
R14740 n1_M5_24060_90780 n1_M5_24060_91860 0.197640
R14741 n1_M5_24060_91860 n1_M5_24060_92940 0.197640
R14742 n1_M5_24060_92940 n1_M5_24060_94020 0.197640
R14743 n1_M5_24060_94020 n1_M5_24060_95100 0.197640
R14744 n1_M5_24060_95100 n1_M5_24060_96060 0.175680
R14745 n1_M5_24060_96180 n1_M5_24060_96060 0.021960
R14746 n1_M5_24060_96180 n1_M5_24060_97260 0.197640
R14747 n1_M5_24060_97260 n1_M5_24060_98340 0.197640
R14748 n1_M5_24060_98340 n1_M5_24060_99420 0.197640
R14749 n1_M5_24060_99420 n1_M5_24060_100500 0.197640
R14750 n1_M5_24060_100500 n1_M5_24060_101580 0.197640
R14751 n1_M5_24060_101580 n1_M5_24060_102660 0.197640
R14752 n1_M5_24060_102660 n1_M5_24060_103740 0.197640
R14753 n1_M5_24060_103740 n1_M5_24060_104820 0.197640
R14754 n1_M5_24060_104820 n1_M5_24060_105900 0.197640
R14755 n1_M5_24060_105900 n1_M5_24060_106980 0.197640
R14756 n1_M5_24060_106980 n1_M5_24060_108060 0.197640
R14757 n1_M5_24060_108060 n1_M5_24060_109140 0.197640
R14758 n1_M5_24060_109140 n1_M5_24060_110220 0.197640
R14759 n1_M5_24060_110220 n1_M5_24060_111300 0.197640
R14760 n1_M5_24060_111300 n1_M5_24060_112380 0.197640
R14761 n1_M5_24060_112380 n1_M5_24060_113460 0.197640
R14762 n1_M5_24060_113460 n1_M5_24060_114540 0.197640
R14763 n1_M5_24060_114540 n1_M5_24060_115620 0.197640
R14764 n1_M5_24060_115620 n1_M5_24060_116700 0.197640
R14765 n1_M5_24060_116700 n1_M5_24060_117780 0.197640
R14766 n1_M5_24060_117780 n1_M5_24060_118860 0.197640
R14767 n1_M5_24060_118860 n1_M5_24060_119940 0.197640
R14768 n1_M5_24060_119940 n1_M5_24060_120060 0.021960
R14769 n1_M5_24060_121020 n1_M5_24060_120060 0.175680
R14770 n1_M5_24060_121020 n1_M5_24060_122100 0.197640
R14771 n1_M5_24060_122100 n1_M5_24060_123180 0.197640
R14772 n1_M5_24060_123180 n1_M5_24060_124260 0.197640
R14773 n1_M5_24060_124260 n1_M5_24060_125340 0.197640
R14774 n1_M5_24060_125340 n1_M5_24060_126420 0.197640
R14775 n1_M5_24060_126420 n1_M5_24060_127500 0.197640
R14776 n1_M5_24060_127500 n1_M5_24060_128580 0.197640
R14777 n1_M5_24060_128580 n1_M5_24060_129660 0.197640
R14778 n1_M5_48060_60 n1_M5_48060_1140 0.197640
R14779 n1_M5_48060_1140 n1_M5_48060_2220 0.197640
R14780 n1_M5_48060_2220 n1_M5_48060_3300 0.197640
R14781 n1_M5_48060_3300 n1_M5_48060_4380 0.197640
R14782 n1_M5_48060_4380 n1_M5_48060_5460 0.197640
R14783 n1_M5_48060_5460 n1_M5_48060_6540 0.197640
R14784 n1_M5_48060_6540 n1_M5_48060_7620 0.197640
R14785 n1_M5_48060_7620 n1_M5_48060_8700 0.197640
R14786 n1_M5_48060_8700 n1_M5_48060_9780 0.197640
R14787 n1_M5_48060_9780 n1_M5_48060_10860 0.197640
R14788 n1_M5_48060_10860 n1_M5_48060_11940 0.197640
R14789 n1_M5_48060_11940 n1_M5_48060_12060 0.021960
R14790 n1_M5_48060_13020 n1_M5_48060_12060 0.175680
R14791 n1_M5_48060_13020 n1_M5_48060_14100 0.197640
R14792 n1_M5_48060_14100 n1_M5_48060_15180 0.197640
R14793 n1_M5_48060_15180 n1_M5_48060_16260 0.197640
R14794 n1_M5_48060_16260 n1_M5_48060_17340 0.197640
R14795 n1_M5_48060_17340 n1_M5_48060_18420 0.197640
R14796 n1_M5_48060_18420 n1_M5_48060_19500 0.197640
R14797 n1_M5_48060_19500 n1_M5_48060_20580 0.197640
R14798 n1_M5_48060_20580 n1_M5_48060_21660 0.197640
R14799 n1_M5_48060_21660 n1_M5_48060_22740 0.197640
R14800 n1_M5_48060_22740 n1_M5_48060_23820 0.197640
R14801 n1_M5_48060_23820 n1_M5_48060_24060 0.043920
R14802 n1_M5_48060_24900 n1_M5_48060_24060 0.153720
R14803 n1_M5_48060_24900 n1_M5_48060_25980 0.197640
R14804 n1_M5_48060_25980 n1_M5_48060_27060 0.197640
R14805 n1_M5_48060_27060 n1_M5_48060_28140 0.197640
R14806 n1_M5_48060_28140 n1_M5_48060_29220 0.197640
R14807 n1_M5_48060_29220 n1_M5_48060_30300 0.197640
R14808 n1_M5_48060_30300 n1_M5_48060_31380 0.197640
R14809 n1_M5_48060_31380 n1_M5_48060_32460 0.197640
R14810 n1_M5_48060_32460 n1_M5_48060_33540 0.197640
R14811 n1_M5_48060_33540 n1_M5_48060_34620 0.197640
R14812 n1_M5_48060_34620 n1_M5_48060_35700 0.197640
R14813 n1_M5_48060_35700 n1_M5_48060_36060 0.065880
R14814 n1_M5_48060_36780 n1_M5_48060_36060 0.131760
R14815 n1_M5_48060_36780 n1_M5_48060_37860 0.197640
R14816 n1_M5_48060_37860 n1_M5_48060_38940 0.197640
R14817 n1_M5_48060_38940 n1_M5_48060_40020 0.197640
R14818 n1_M5_48060_40020 n1_M5_48060_41100 0.197640
R14819 n1_M5_48060_41100 n1_M5_48060_42180 0.197640
R14820 n1_M5_48060_42180 n1_M5_48060_43260 0.197640
R14821 n1_M5_48060_43260 n1_M5_48060_44340 0.197640
R14822 n1_M5_48060_44340 n1_M5_48060_45420 0.197640
R14823 n1_M5_48060_45420 n1_M5_48060_46500 0.197640
R14824 n1_M5_48060_46500 n1_M5_48060_47580 0.197640
R14825 n1_M5_48060_47580 n1_M5_48060_48060 0.087840
R14826 n1_M5_48060_48660 n1_M5_48060_48060 0.109800
R14827 n1_M5_48060_48660 n1_M5_48060_49740 0.197640
R14828 n1_M5_48060_49740 n1_M5_48060_50820 0.197640
R14829 n1_M5_48060_50820 n1_M5_48060_51900 0.197640
R14830 n1_M5_48060_51900 n1_M5_48060_52980 0.197640
R14831 n1_M5_48060_52980 n1_M5_48060_54060 0.197640
R14832 n1_M5_48060_54060 n1_M5_48060_55140 0.197640
R14833 n1_M5_48060_55140 n1_M5_48060_56220 0.197640
R14834 n1_M5_48060_56220 n1_M5_48060_57300 0.197640
R14835 n1_M5_48060_57300 n1_M5_48060_58380 0.197640
R14836 n1_M5_48060_58380 n1_M5_48060_59460 0.197640
R14837 n1_M5_48060_59460 n1_M5_48060_60060 0.109800
R14838 n1_M5_48060_60540 n1_M5_48060_60060 0.087840
R14839 n1_M5_48060_60540 n1_M5_48060_61620 0.197640
R14840 n1_M5_48060_61620 n1_M5_48060_62700 0.197640
R14841 n1_M5_48060_62700 n1_M5_48060_63780 0.197640
R14842 n1_M5_48060_63780 n1_M5_48060_64860 0.197640
R14843 n1_M5_48060_64860 n1_M5_48060_65940 0.197640
R14844 n1_M5_48060_65940 n1_M5_48060_67020 0.197640
R14845 n1_M5_48060_67020 n1_M5_48060_68100 0.197640
R14846 n1_M5_48060_68100 n1_M5_48060_69180 0.197640
R14847 n1_M5_48060_69180 n1_M5_48060_70260 0.197640
R14848 n1_M5_48060_70260 n1_M5_48060_71340 0.197640
R14849 n1_M5_48060_71340 n1_M5_48060_72060 0.131760
R14850 n1_M5_48060_72420 n1_M5_48060_72060 0.065880
R14851 n1_M5_48060_72420 n1_M5_48060_73500 0.197640
R14852 n1_M5_48060_73500 n1_M5_48060_74580 0.197640
R14853 n1_M5_48060_74580 n1_M5_48060_75660 0.197640
R14854 n1_M5_48060_75660 n1_M5_48060_76740 0.197640
R14855 n1_M5_48060_76740 n1_M5_48060_77820 0.197640
R14856 n1_M5_48060_77820 n1_M5_48060_78900 0.197640
R14857 n1_M5_48060_78900 n1_M5_48060_79980 0.197640
R14858 n1_M5_48060_79980 n1_M5_48060_81060 0.197640
R14859 n1_M5_48060_81060 n1_M5_48060_82140 0.197640
R14860 n1_M5_48060_82140 n1_M5_48060_83220 0.197640
R14861 n1_M5_48060_83220 n1_M5_48060_84060 0.153720
R14862 n1_M5_48060_84300 n1_M5_48060_84060 0.043920
R14863 n1_M5_48060_84300 n1_M5_48060_85380 0.197640
R14864 n1_M5_48060_85380 n1_M5_48060_86460 0.197640
R14865 n1_M5_48060_86460 n1_M5_48060_87540 0.197640
R14866 n1_M5_48060_87540 n1_M5_48060_88620 0.197640
R14867 n1_M5_48060_88620 n1_M5_48060_89700 0.197640
R14868 n1_M5_48060_89700 n1_M5_48060_90780 0.197640
R14869 n1_M5_48060_90780 n1_M5_48060_91860 0.197640
R14870 n1_M5_48060_91860 n1_M5_48060_92940 0.197640
R14871 n1_M5_48060_92940 n1_M5_48060_94020 0.197640
R14872 n1_M5_48060_94020 n1_M5_48060_95100 0.197640
R14873 n1_M5_48060_95100 n1_M5_48060_96060 0.175680
R14874 n1_M5_48060_96180 n1_M5_48060_96060 0.021960
R14875 n1_M5_48060_96180 n1_M5_48060_97260 0.197640
R14876 n1_M5_48060_97260 n1_M5_48060_98340 0.197640
R14877 n1_M5_48060_98340 n1_M5_48060_99420 0.197640
R14878 n1_M5_48060_99420 n1_M5_48060_100500 0.197640
R14879 n1_M5_48060_100500 n1_M5_48060_101580 0.197640
R14880 n1_M5_48060_101580 n1_M5_48060_102660 0.197640
R14881 n1_M5_48060_102660 n1_M5_48060_103740 0.197640
R14882 n1_M5_48060_103740 n1_M5_48060_104820 0.197640
R14883 n1_M5_48060_104820 n1_M5_48060_105900 0.197640
R14884 n1_M5_48060_105900 n1_M5_48060_106980 0.197640
R14885 n1_M5_48060_106980 n1_M5_48060_108060 0.197640
R14886 n1_M5_48060_108060 n1_M5_48060_109140 0.197640
R14887 n1_M5_48060_109140 n1_M5_48060_110220 0.197640
R14888 n1_M5_48060_110220 n1_M5_48060_111300 0.197640
R14889 n1_M5_48060_111300 n1_M5_48060_112380 0.197640
R14890 n1_M5_48060_112380 n1_M5_48060_113460 0.197640
R14891 n1_M5_48060_113460 n1_M5_48060_114540 0.197640
R14892 n1_M5_48060_114540 n1_M5_48060_115620 0.197640
R14893 n1_M5_48060_115620 n1_M5_48060_116700 0.197640
R14894 n1_M5_48060_116700 n1_M5_48060_117780 0.197640
R14895 n1_M5_48060_117780 n1_M5_48060_118860 0.197640
R14896 n1_M5_48060_118860 n1_M5_48060_119940 0.197640
R14897 n1_M5_48060_119940 n1_M5_48060_120060 0.021960
R14898 n1_M5_48060_121020 n1_M5_48060_120060 0.175680
R14899 n1_M5_48060_121020 n1_M5_48060_122100 0.197640
R14900 n1_M5_48060_122100 n1_M5_48060_123180 0.197640
R14901 n1_M5_48060_123180 n1_M5_48060_124260 0.197640
R14902 n1_M5_48060_124260 n1_M5_48060_125340 0.197640
R14903 n1_M5_48060_125340 n1_M5_48060_126420 0.197640
R14904 n1_M5_48060_126420 n1_M5_48060_127500 0.197640
R14905 n1_M5_48060_127500 n1_M5_48060_128580 0.197640
R14906 n1_M5_48060_128580 n1_M5_48060_129660 0.197640
R14907 n1_M5_72060_60 n1_M5_72060_1140 0.197640
R14908 n1_M5_72060_1140 n1_M5_72060_2220 0.197640
R14909 n1_M5_72060_2220 n1_M5_72060_3300 0.197640
R14910 n1_M5_72060_3300 n1_M5_72060_4380 0.197640
R14911 n1_M5_72060_4380 n1_M5_72060_5460 0.197640
R14912 n1_M5_72060_5460 n1_M5_72060_6540 0.197640
R14913 n1_M5_72060_6540 n1_M5_72060_7620 0.197640
R14914 n1_M5_72060_7620 n1_M5_72060_8700 0.197640
R14915 n1_M5_72060_8700 n1_M5_72060_9780 0.197640
R14916 n1_M5_72060_9780 n1_M5_72060_10860 0.197640
R14917 n1_M5_72060_10860 n1_M5_72060_11940 0.197640
R14918 n1_M5_72060_11940 n1_M5_72060_12060 0.021960
R14919 n1_M5_72060_13020 n1_M5_72060_12060 0.175680
R14920 n1_M5_72060_13020 n1_M5_72060_14100 0.197640
R14921 n1_M5_72060_14100 n1_M5_72060_15180 0.197640
R14922 n1_M5_72060_15180 n1_M5_72060_16260 0.197640
R14923 n1_M5_72060_16260 n1_M5_72060_17340 0.197640
R14924 n1_M5_72060_17340 n1_M5_72060_18420 0.197640
R14925 n1_M5_72060_18420 n1_M5_72060_19500 0.197640
R14926 n1_M5_72060_19500 n1_M5_72060_20580 0.197640
R14927 n1_M5_72060_20580 n1_M5_72060_21660 0.197640
R14928 n1_M5_72060_21660 n1_M5_72060_22740 0.197640
R14929 n1_M5_72060_22740 n1_M5_72060_23820 0.197640
R14930 n1_M5_72060_23820 n1_M5_72060_24060 0.043920
R14931 n1_M5_72060_24900 n1_M5_72060_24060 0.153720
R14932 n1_M5_72060_24900 n1_M5_72060_25980 0.197640
R14933 n1_M5_72060_25980 n1_M5_72060_27060 0.197640
R14934 n1_M5_72060_27060 n1_M5_72060_28140 0.197640
R14935 n1_M5_72060_28140 n1_M5_72060_29220 0.197640
R14936 n1_M5_72060_29220 n1_M5_72060_30300 0.197640
R14937 n1_M5_72060_30300 n1_M5_72060_31380 0.197640
R14938 n1_M5_72060_31380 n1_M5_72060_32460 0.197640
R14939 n1_M5_72060_32460 n1_M5_72060_33540 0.197640
R14940 n1_M5_72060_33540 n1_M5_72060_34620 0.197640
R14941 n1_M5_72060_34620 n1_M5_72060_35700 0.197640
R14942 n1_M5_72060_35700 n1_M5_72060_36060 0.065880
R14943 n1_M5_72060_36780 n1_M5_72060_36060 0.131760
R14944 n1_M5_72060_36780 n1_M5_72060_37860 0.197640
R14945 n1_M5_72060_37860 n1_M5_72060_38940 0.197640
R14946 n1_M5_72060_38940 n1_M5_72060_40020 0.197640
R14947 n1_M5_72060_40020 n1_M5_72060_41100 0.197640
R14948 n1_M5_72060_41100 n1_M5_72060_42180 0.197640
R14949 n1_M5_72060_42180 n1_M5_72060_43260 0.197640
R14950 n1_M5_72060_43260 n1_M5_72060_44340 0.197640
R14951 n1_M5_72060_44340 n1_M5_72060_45420 0.197640
R14952 n1_M5_72060_45420 n1_M5_72060_46500 0.197640
R14953 n1_M5_72060_46500 n1_M5_72060_47580 0.197640
R14954 n1_M5_72060_47580 n1_M5_72060_48060 0.087840
R14955 n1_M5_72060_48660 n1_M5_72060_48060 0.109800
R14956 n1_M5_72060_48660 n1_M5_72060_49740 0.197640
R14957 n1_M5_72060_49740 n1_M5_72060_50820 0.197640
R14958 n1_M5_72060_50820 n1_M5_72060_51900 0.197640
R14959 n1_M5_72060_51900 n1_M5_72060_52980 0.197640
R14960 n1_M5_72060_52980 n1_M5_72060_54060 0.197640
R14961 n1_M5_72060_54060 n1_M5_72060_55140 0.197640
R14962 n1_M5_72060_55140 n1_M5_72060_56220 0.197640
R14963 n1_M5_72060_56220 n1_M5_72060_57300 0.197640
R14964 n1_M5_72060_57300 n1_M5_72060_58380 0.197640
R14965 n1_M5_72060_58380 n1_M5_72060_59460 0.197640
R14966 n1_M5_72060_59460 n1_M5_72060_60060 0.109800
R14967 n1_M5_72060_60540 n1_M5_72060_60060 0.087840
R14968 n1_M5_72060_60540 n1_M5_72060_61620 0.197640
R14969 n1_M5_72060_61620 n1_M5_72060_62700 0.197640
R14970 n1_M5_72060_62700 n1_M5_72060_63780 0.197640
R14971 n1_M5_72060_63780 n1_M5_72060_64860 0.197640
R14972 n1_M5_72060_64860 n1_M5_72060_65940 0.197640
R14973 n1_M5_72060_65940 n1_M5_72060_67020 0.197640
R14974 n1_M5_72060_67020 n1_M5_72060_68100 0.197640
R14975 n1_M5_72060_68100 n1_M5_72060_69180 0.197640
R14976 n1_M5_72060_69180 n1_M5_72060_70260 0.197640
R14977 n1_M5_72060_70260 n1_M5_72060_71340 0.197640
R14978 n1_M5_72060_71340 n1_M5_72060_72060 0.131760
R14979 n1_M5_72060_72420 n1_M5_72060_72060 0.065880
R14980 n1_M5_72060_72420 n1_M5_72060_73500 0.197640
R14981 n1_M5_72060_73500 n1_M5_72060_74580 0.197640
R14982 n1_M5_72060_74580 n1_M5_72060_75660 0.197640
R14983 n1_M5_72060_75660 n1_M5_72060_76740 0.197640
R14984 n1_M5_72060_76740 n1_M5_72060_77820 0.197640
R14985 n1_M5_72060_77820 n1_M5_72060_78900 0.197640
R14986 n1_M5_72060_78900 n1_M5_72060_79980 0.197640
R14987 n1_M5_72060_79980 n1_M5_72060_81060 0.197640
R14988 n1_M5_72060_81060 n1_M5_72060_82140 0.197640
R14989 n1_M5_72060_82140 n1_M5_72060_83220 0.197640
R14990 n1_M5_72060_83220 n1_M5_72060_84060 0.153720
R14991 n1_M5_72060_84300 n1_M5_72060_84060 0.043920
R14992 n1_M5_72060_84300 n1_M5_72060_85380 0.197640
R14993 n1_M5_72060_85380 n1_M5_72060_86460 0.197640
R14994 n1_M5_72060_86460 n1_M5_72060_87540 0.197640
R14995 n1_M5_72060_87540 n1_M5_72060_88620 0.197640
R14996 n1_M5_72060_88620 n1_M5_72060_89700 0.197640
R14997 n1_M5_72060_89700 n1_M5_72060_90780 0.197640
R14998 n1_M5_72060_90780 n1_M5_72060_91860 0.197640
R14999 n1_M5_72060_91860 n1_M5_72060_92940 0.197640
R15000 n1_M5_72060_92940 n1_M5_72060_94020 0.197640
R15001 n1_M5_72060_94020 n1_M5_72060_95100 0.197640
R15002 n1_M5_72060_95100 n1_M5_72060_96060 0.175680
R15003 n1_M5_72060_96180 n1_M5_72060_96060 0.021960
R15004 n1_M5_72060_96180 n1_M5_72060_97260 0.197640
R15005 n1_M5_72060_97260 n1_M5_72060_98340 0.197640
R15006 n1_M5_72060_98340 n1_M5_72060_99420 0.197640
R15007 n1_M5_72060_99420 n1_M5_72060_100500 0.197640
R15008 n1_M5_72060_100500 n1_M5_72060_101580 0.197640
R15009 n1_M5_72060_101580 n1_M5_72060_102660 0.197640
R15010 n1_M5_72060_102660 n1_M5_72060_103740 0.197640
R15011 n1_M5_72060_103740 n1_M5_72060_104820 0.197640
R15012 n1_M5_72060_104820 n1_M5_72060_105900 0.197640
R15013 n1_M5_72060_105900 n1_M5_72060_106980 0.197640
R15014 n1_M5_72060_106980 n1_M5_72060_108060 0.197640
R15015 n1_M5_72060_108060 n1_M5_72060_109140 0.197640
R15016 n1_M5_72060_109140 n1_M5_72060_110220 0.197640
R15017 n1_M5_72060_110220 n1_M5_72060_111300 0.197640
R15018 n1_M5_72060_111300 n1_M5_72060_112380 0.197640
R15019 n1_M5_72060_112380 n1_M5_72060_113460 0.197640
R15020 n1_M5_72060_113460 n1_M5_72060_114540 0.197640
R15021 n1_M5_72060_114540 n1_M5_72060_115620 0.197640
R15022 n1_M5_72060_115620 n1_M5_72060_116700 0.197640
R15023 n1_M5_72060_116700 n1_M5_72060_117780 0.197640
R15024 n1_M5_72060_117780 n1_M5_72060_118860 0.197640
R15025 n1_M5_72060_118860 n1_M5_72060_119940 0.197640
R15026 n1_M5_72060_119940 n1_M5_72060_120060 0.021960
R15027 n1_M5_72060_121020 n1_M5_72060_120060 0.175680
R15028 n1_M5_72060_121020 n1_M5_72060_122100 0.197640
R15029 n1_M5_72060_122100 n1_M5_72060_123180 0.197640
R15030 n1_M5_72060_123180 n1_M5_72060_124260 0.197640
R15031 n1_M5_72060_124260 n1_M5_72060_125340 0.197640
R15032 n1_M5_72060_125340 n1_M5_72060_126420 0.197640
R15033 n1_M5_72060_126420 n1_M5_72060_127500 0.197640
R15034 n1_M5_72060_127500 n1_M5_72060_128580 0.197640
R15035 n1_M5_72060_128580 n1_M5_72060_129660 0.197640
R15036 n1_M5_96060_60 n1_M5_96060_1140 0.197640
R15037 n1_M5_96060_1140 n1_M5_96060_2220 0.197640
R15038 n1_M5_96060_2220 n1_M5_96060_3300 0.197640
R15039 n1_M5_96060_3300 n1_M5_96060_4380 0.197640
R15040 n1_M5_96060_4380 n1_M5_96060_5460 0.197640
R15041 n1_M5_96060_5460 n1_M5_96060_6540 0.197640
R15042 n1_M5_96060_6540 n1_M5_96060_7620 0.197640
R15043 n1_M5_96060_7620 n1_M5_96060_8700 0.197640
R15044 n1_M5_96060_8700 n1_M5_96060_9780 0.197640
R15045 n1_M5_96060_9780 n1_M5_96060_10860 0.197640
R15046 n1_M5_96060_10860 n1_M5_96060_11940 0.197640
R15047 n1_M5_96060_11940 n1_M5_96060_12060 0.021960
R15048 n1_M5_96060_13020 n1_M5_96060_12060 0.175680
R15049 n1_M5_96060_13020 n1_M5_96060_14100 0.197640
R15050 n1_M5_96060_14100 n1_M5_96060_15180 0.197640
R15051 n1_M5_96060_15180 n1_M5_96060_16260 0.197640
R15052 n1_M5_96060_16260 n1_M5_96060_17340 0.197640
R15053 n1_M5_96060_17340 n1_M5_96060_18420 0.197640
R15054 n1_M5_96060_18420 n1_M5_96060_19500 0.197640
R15055 n1_M5_96060_19500 n1_M5_96060_20580 0.197640
R15056 n1_M5_96060_20580 n1_M5_96060_21660 0.197640
R15057 n1_M5_96060_21660 n1_M5_96060_22740 0.197640
R15058 n1_M5_96060_22740 n1_M5_96060_23820 0.197640
R15059 n1_M5_96060_23820 n1_M5_96060_24060 0.043920
R15060 n1_M5_96060_24900 n1_M5_96060_24060 0.153720
R15061 n1_M5_96060_24900 n1_M5_96060_25980 0.197640
R15062 n1_M5_96060_25980 n1_M5_96060_27060 0.197640
R15063 n1_M5_96060_27060 n1_M5_96060_28140 0.197640
R15064 n1_M5_96060_28140 n1_M5_96060_29220 0.197640
R15065 n1_M5_96060_29220 n1_M5_96060_30300 0.197640
R15066 n1_M5_96060_30300 n1_M5_96060_31380 0.197640
R15067 n1_M5_96060_31380 n1_M5_96060_32460 0.197640
R15068 n1_M5_96060_32460 n1_M5_96060_33540 0.197640
R15069 n1_M5_96060_33540 n1_M5_96060_34620 0.197640
R15070 n1_M5_96060_34620 n1_M5_96060_35700 0.197640
R15071 n1_M5_96060_35700 n1_M5_96060_36060 0.065880
R15072 n1_M5_96060_36780 n1_M5_96060_36060 0.131760
R15073 n1_M5_96060_36780 n1_M5_96060_37860 0.197640
R15074 n1_M5_96060_37860 n1_M5_96060_38940 0.197640
R15075 n1_M5_96060_38940 n1_M5_96060_40020 0.197640
R15076 n1_M5_96060_40020 n1_M5_96060_41100 0.197640
R15077 n1_M5_96060_41100 n1_M5_96060_42180 0.197640
R15078 n1_M5_96060_42180 n1_M5_96060_43260 0.197640
R15079 n1_M5_96060_43260 n1_M5_96060_44340 0.197640
R15080 n1_M5_96060_44340 n1_M5_96060_45420 0.197640
R15081 n1_M5_96060_45420 n1_M5_96060_46500 0.197640
R15082 n1_M5_96060_46500 n1_M5_96060_47580 0.197640
R15083 n1_M5_96060_47580 n1_M5_96060_48060 0.087840
R15084 n1_M5_96060_48660 n1_M5_96060_48060 0.109800
R15085 n1_M5_96060_48660 n1_M5_96060_49740 0.197640
R15086 n1_M5_96060_49740 n1_M5_96060_50820 0.197640
R15087 n1_M5_96060_50820 n1_M5_96060_51900 0.197640
R15088 n1_M5_96060_51900 n1_M5_96060_52980 0.197640
R15089 n1_M5_96060_52980 n1_M5_96060_54060 0.197640
R15090 n1_M5_96060_54060 n1_M5_96060_55140 0.197640
R15091 n1_M5_96060_55140 n1_M5_96060_56220 0.197640
R15092 n1_M5_96060_56220 n1_M5_96060_57300 0.197640
R15093 n1_M5_96060_57300 n1_M5_96060_58380 0.197640
R15094 n1_M5_96060_58380 n1_M5_96060_59460 0.197640
R15095 n1_M5_96060_59460 n1_M5_96060_60060 0.109800
R15096 n1_M5_96060_60540 n1_M5_96060_60060 0.087840
R15097 n1_M5_96060_60540 n1_M5_96060_61620 0.197640
R15098 n1_M5_96060_61620 n1_M5_96060_62700 0.197640
R15099 n1_M5_96060_62700 n1_M5_96060_63780 0.197640
R15100 n1_M5_96060_63780 n1_M5_96060_64860 0.197640
R15101 n1_M5_96060_64860 n1_M5_96060_65940 0.197640
R15102 n1_M5_96060_65940 n1_M5_96060_67020 0.197640
R15103 n1_M5_96060_67020 n1_M5_96060_68100 0.197640
R15104 n1_M5_96060_68100 n1_M5_96060_69180 0.197640
R15105 n1_M5_96060_69180 n1_M5_96060_70260 0.197640
R15106 n1_M5_96060_70260 n1_M5_96060_71340 0.197640
R15107 n1_M5_96060_71340 n1_M5_96060_72060 0.131760
R15108 n1_M5_96060_72420 n1_M5_96060_72060 0.065880
R15109 n1_M5_96060_72420 n1_M5_96060_73500 0.197640
R15110 n1_M5_96060_73500 n1_M5_96060_74580 0.197640
R15111 n1_M5_96060_74580 n1_M5_96060_75660 0.197640
R15112 n1_M5_96060_75660 n1_M5_96060_76740 0.197640
R15113 n1_M5_96060_76740 n1_M5_96060_77820 0.197640
R15114 n1_M5_96060_77820 n1_M5_96060_78900 0.197640
R15115 n1_M5_96060_78900 n1_M5_96060_79980 0.197640
R15116 n1_M5_96060_79980 n1_M5_96060_81060 0.197640
R15117 n1_M5_96060_81060 n1_M5_96060_82140 0.197640
R15118 n1_M5_96060_82140 n1_M5_96060_83220 0.197640
R15119 n1_M5_96060_83220 n1_M5_96060_84060 0.153720
R15120 n1_M5_96060_84300 n1_M5_96060_84060 0.043920
R15121 n1_M5_96060_84300 n1_M5_96060_85380 0.197640
R15122 n1_M5_96060_85380 n1_M5_96060_86460 0.197640
R15123 n1_M5_96060_86460 n1_M5_96060_87540 0.197640
R15124 n1_M5_96060_87540 n1_M5_96060_88620 0.197640
R15125 n1_M5_96060_88620 n1_M5_96060_89700 0.197640
R15126 n1_M5_96060_89700 n1_M5_96060_90780 0.197640
R15127 n1_M5_96060_90780 n1_M5_96060_91860 0.197640
R15128 n1_M5_96060_91860 n1_M5_96060_92940 0.197640
R15129 n1_M5_96060_92940 n1_M5_96060_94020 0.197640
R15130 n1_M5_96060_94020 n1_M5_96060_95100 0.197640
R15131 n1_M5_96060_95100 n1_M5_96060_96060 0.175680
R15132 n1_M5_96060_96180 n1_M5_96060_96060 0.021960
R15133 n1_M5_96060_96180 n1_M5_96060_97260 0.197640
R15134 n1_M5_96060_97260 n1_M5_96060_98340 0.197640
R15135 n1_M5_96060_98340 n1_M5_96060_99420 0.197640
R15136 n1_M5_96060_99420 n1_M5_96060_100500 0.197640
R15137 n1_M5_96060_100500 n1_M5_96060_101580 0.197640
R15138 n1_M5_96060_101580 n1_M5_96060_102660 0.197640
R15139 n1_M5_96060_102660 n1_M5_96060_103740 0.197640
R15140 n1_M5_96060_103740 n1_M5_96060_104820 0.197640
R15141 n1_M5_96060_104820 n1_M5_96060_105900 0.197640
R15142 n1_M5_96060_105900 n1_M5_96060_106980 0.197640
R15143 n1_M5_96060_106980 n1_M5_96060_108060 0.197640
R15144 n1_M5_96060_108060 n1_M5_96060_109140 0.197640
R15145 n1_M5_96060_109140 n1_M5_96060_110220 0.197640
R15146 n1_M5_96060_110220 n1_M5_96060_111300 0.197640
R15147 n1_M5_96060_111300 n1_M5_96060_112380 0.197640
R15148 n1_M5_96060_112380 n1_M5_96060_113460 0.197640
R15149 n1_M5_96060_113460 n1_M5_96060_114540 0.197640
R15150 n1_M5_96060_114540 n1_M5_96060_115620 0.197640
R15151 n1_M5_96060_115620 n1_M5_96060_116700 0.197640
R15152 n1_M5_96060_116700 n1_M5_96060_117780 0.197640
R15153 n1_M5_96060_117780 n1_M5_96060_118860 0.197640
R15154 n1_M5_96060_118860 n1_M5_96060_119940 0.197640
R15155 n1_M5_96060_119940 n1_M5_96060_120060 0.021960
R15156 n1_M5_96060_121020 n1_M5_96060_120060 0.175680
R15157 n1_M5_96060_121020 n1_M5_96060_122100 0.197640
R15158 n1_M5_96060_122100 n1_M5_96060_123180 0.197640
R15159 n1_M5_96060_123180 n1_M5_96060_124260 0.197640
R15160 n1_M5_96060_124260 n1_M5_96060_125340 0.197640
R15161 n1_M5_96060_125340 n1_M5_96060_126420 0.197640
R15162 n1_M5_96060_126420 n1_M5_96060_127500 0.197640
R15163 n1_M5_96060_127500 n1_M5_96060_128580 0.197640
R15164 n1_M5_96060_128580 n1_M5_96060_129660 0.197640
R15165 n1_M5_120060_60 n1_M5_120060_1140 0.197640
R15166 n1_M5_120060_1140 n1_M5_120060_2220 0.197640
R15167 n1_M5_120060_2220 n1_M5_120060_3300 0.197640
R15168 n1_M5_120060_3300 n1_M5_120060_4380 0.197640
R15169 n1_M5_120060_4380 n1_M5_120060_5460 0.197640
R15170 n1_M5_120060_5460 n1_M5_120060_6540 0.197640
R15171 n1_M5_120060_6540 n1_M5_120060_7620 0.197640
R15172 n1_M5_120060_7620 n1_M5_120060_8700 0.197640
R15173 n1_M5_120060_8700 n1_M5_120060_9780 0.197640
R15174 n1_M5_120060_9780 n1_M5_120060_10860 0.197640
R15175 n1_M5_120060_10860 n1_M5_120060_11940 0.197640
R15176 n1_M5_120060_11940 n1_M5_120060_12060 0.021960
R15177 n1_M5_120060_13020 n1_M5_120060_12060 0.175680
R15178 n1_M5_120060_13020 n1_M5_120060_14100 0.197640
R15179 n1_M5_120060_14100 n1_M5_120060_15180 0.197640
R15180 n1_M5_120060_15180 n1_M5_120060_16260 0.197640
R15181 n1_M5_120060_16260 n1_M5_120060_17340 0.197640
R15182 n1_M5_120060_17340 n1_M5_120060_18420 0.197640
R15183 n1_M5_120060_18420 n1_M5_120060_19500 0.197640
R15184 n1_M5_120060_19500 n1_M5_120060_20580 0.197640
R15185 n1_M5_120060_20580 n1_M5_120060_21660 0.197640
R15186 n1_M5_120060_21660 n1_M5_120060_22740 0.197640
R15187 n1_M5_120060_22740 n1_M5_120060_23820 0.197640
R15188 n1_M5_120060_23820 n1_M5_120060_24060 0.043920
R15189 n1_M5_120060_24900 n1_M5_120060_24060 0.153720
R15190 n1_M5_120060_24900 n1_M5_120060_25980 0.197640
R15191 n1_M5_120060_25980 n1_M5_120060_27060 0.197640
R15192 n1_M5_120060_27060 n1_M5_120060_28140 0.197640
R15193 n1_M5_120060_28140 n1_M5_120060_29220 0.197640
R15194 n1_M5_120060_29220 n1_M5_120060_30300 0.197640
R15195 n1_M5_120060_30300 n1_M5_120060_31380 0.197640
R15196 n1_M5_120060_31380 n1_M5_120060_32460 0.197640
R15197 n1_M5_120060_32460 n1_M5_120060_33540 0.197640
R15198 n1_M5_120060_33540 n1_M5_120060_34620 0.197640
R15199 n1_M5_120060_34620 n1_M5_120060_35700 0.197640
R15200 n1_M5_120060_35700 n1_M5_120060_36060 0.065880
R15201 n1_M5_120060_36780 n1_M5_120060_36060 0.131760
R15202 n1_M5_120060_36780 n1_M5_120060_37860 0.197640
R15203 n1_M5_120060_37860 n1_M5_120060_38940 0.197640
R15204 n1_M5_120060_38940 n1_M5_120060_40020 0.197640
R15205 n1_M5_120060_40020 n1_M5_120060_41100 0.197640
R15206 n1_M5_120060_41100 n1_M5_120060_42180 0.197640
R15207 n1_M5_120060_42180 n1_M5_120060_43260 0.197640
R15208 n1_M5_120060_43260 n1_M5_120060_44340 0.197640
R15209 n1_M5_120060_44340 n1_M5_120060_45420 0.197640
R15210 n1_M5_120060_45420 n1_M5_120060_46500 0.197640
R15211 n1_M5_120060_46500 n1_M5_120060_47580 0.197640
R15212 n1_M5_120060_47580 n1_M5_120060_48060 0.087840
R15213 n1_M5_120060_48660 n1_M5_120060_48060 0.109800
R15214 n1_M5_120060_48660 n1_M5_120060_49740 0.197640
R15215 n1_M5_120060_49740 n1_M5_120060_50820 0.197640
R15216 n1_M5_120060_50820 n1_M5_120060_51900 0.197640
R15217 n1_M5_120060_51900 n1_M5_120060_52980 0.197640
R15218 n1_M5_120060_52980 n1_M5_120060_54060 0.197640
R15219 n1_M5_120060_54060 n1_M5_120060_55140 0.197640
R15220 n1_M5_120060_55140 n1_M5_120060_56220 0.197640
R15221 n1_M5_120060_56220 n1_M5_120060_57300 0.197640
R15222 n1_M5_120060_57300 n1_M5_120060_58380 0.197640
R15223 n1_M5_120060_58380 n1_M5_120060_59460 0.197640
R15224 n1_M5_120060_59460 n1_M5_120060_60060 0.109800
R15225 n1_M5_120060_60540 n1_M5_120060_60060 0.087840
R15226 n1_M5_120060_60540 n1_M5_120060_61620 0.197640
R15227 n1_M5_120060_61620 n1_M5_120060_62700 0.197640
R15228 n1_M5_120060_62700 n1_M5_120060_63780 0.197640
R15229 n1_M5_120060_63780 n1_M5_120060_64860 0.197640
R15230 n1_M5_120060_64860 n1_M5_120060_65940 0.197640
R15231 n1_M5_120060_65940 n1_M5_120060_67020 0.197640
R15232 n1_M5_120060_67020 n1_M5_120060_68100 0.197640
R15233 n1_M5_120060_68100 n1_M5_120060_69180 0.197640
R15234 n1_M5_120060_69180 n1_M5_120060_70260 0.197640
R15235 n1_M5_120060_70260 n1_M5_120060_71340 0.197640
R15236 n1_M5_120060_71340 n1_M5_120060_72060 0.131760
R15237 n1_M5_120060_72420 n1_M5_120060_72060 0.065880
R15238 n1_M5_120060_72420 n1_M5_120060_73500 0.197640
R15239 n1_M5_120060_73500 n1_M5_120060_74580 0.197640
R15240 n1_M5_120060_74580 n1_M5_120060_75660 0.197640
R15241 n1_M5_120060_75660 n1_M5_120060_76740 0.197640
R15242 n1_M5_120060_76740 n1_M5_120060_77820 0.197640
R15243 n1_M5_120060_77820 n1_M5_120060_78900 0.197640
R15244 n1_M5_120060_78900 n1_M5_120060_79980 0.197640
R15245 n1_M5_120060_79980 n1_M5_120060_81060 0.197640
R15246 n1_M5_120060_81060 n1_M5_120060_82140 0.197640
R15247 n1_M5_120060_82140 n1_M5_120060_83220 0.197640
R15248 n1_M5_120060_83220 n1_M5_120060_84060 0.153720
R15249 n1_M5_120060_84300 n1_M5_120060_84060 0.043920
R15250 n1_M5_120060_84300 n1_M5_120060_85380 0.197640
R15251 n1_M5_120060_85380 n1_M5_120060_86460 0.197640
R15252 n1_M5_120060_86460 n1_M5_120060_87540 0.197640
R15253 n1_M5_120060_87540 n1_M5_120060_88620 0.197640
R15254 n1_M5_120060_88620 n1_M5_120060_89700 0.197640
R15255 n1_M5_120060_89700 n1_M5_120060_90780 0.197640
R15256 n1_M5_120060_90780 n1_M5_120060_91860 0.197640
R15257 n1_M5_120060_91860 n1_M5_120060_92940 0.197640
R15258 n1_M5_120060_92940 n1_M5_120060_94020 0.197640
R15259 n1_M5_120060_94020 n1_M5_120060_95100 0.197640
R15260 n1_M5_120060_95100 n1_M5_120060_96060 0.175680
R15261 n1_M5_120060_96180 n1_M5_120060_96060 0.021960
R15262 n1_M5_120060_96180 n1_M5_120060_97260 0.197640
R15263 n1_M5_120060_97260 n1_M5_120060_98340 0.197640
R15264 n1_M5_120060_98340 n1_M5_120060_99420 0.197640
R15265 n1_M5_120060_99420 n1_M5_120060_100500 0.197640
R15266 n1_M5_120060_100500 n1_M5_120060_101580 0.197640
R15267 n1_M5_120060_101580 n1_M5_120060_102660 0.197640
R15268 n1_M5_120060_102660 n1_M5_120060_103740 0.197640
R15269 n1_M5_120060_103740 n1_M5_120060_104820 0.197640
R15270 n1_M5_120060_104820 n1_M5_120060_105900 0.197640
R15271 n1_M5_120060_105900 n1_M5_120060_106980 0.197640
R15272 n1_M5_120060_106980 n1_M5_120060_108060 0.197640
R15273 n1_M5_120060_108060 n1_M5_120060_109140 0.197640
R15274 n1_M5_120060_109140 n1_M5_120060_110220 0.197640
R15275 n1_M5_120060_110220 n1_M5_120060_111300 0.197640
R15276 n1_M5_120060_111300 n1_M5_120060_112380 0.197640
R15277 n1_M5_120060_112380 n1_M5_120060_113460 0.197640
R15278 n1_M5_120060_113460 n1_M5_120060_114540 0.197640
R15279 n1_M5_120060_114540 n1_M5_120060_115620 0.197640
R15280 n1_M5_120060_115620 n1_M5_120060_116700 0.197640
R15281 n1_M5_120060_116700 n1_M5_120060_117780 0.197640
R15282 n1_M5_120060_117780 n1_M5_120060_118860 0.197640
R15283 n1_M5_120060_118860 n1_M5_120060_119940 0.197640
R15284 n1_M5_120060_119940 n1_M5_120060_120060 0.021960
R15285 n1_M5_120060_121020 n1_M5_120060_120060 0.175680
R15286 n1_M5_120060_121020 n1_M5_120060_122100 0.197640
R15287 n1_M5_120060_122100 n1_M5_120060_123180 0.197640
R15288 n1_M5_120060_123180 n1_M5_120060_124260 0.197640
R15289 n1_M5_120060_124260 n1_M5_120060_125340 0.197640
R15290 n1_M5_120060_125340 n1_M5_120060_126420 0.197640
R15291 n1_M5_120060_126420 n1_M5_120060_127500 0.197640
R15292 n1_M5_120060_127500 n1_M5_120060_128580 0.197640
R15293 n1_M5_120060_128580 n1_M5_120060_129660 0.197640
R15294 n1_M6_60_60 n1_M6_4156_60 0.416427
R15295 n1_M6_6060_60 n1_M6_4156_60 0.193573
R15296 n1_M6_6060_60 n1_M6_8252_60 0.222853
R15297 n1_M6_12060_60 n1_M6_8252_60 0.387147
R15298 n1_M6_12060_60 n1_M6_12348_60 0.029280
R15299 n1_M6_12348_60 n1_M6_16444_60 0.416427
R15300 n1_M6_18060_60 n1_M6_16444_60 0.164293
R15301 n1_M6_18060_60 n1_M6_20540_60 0.252133
R15302 n1_M6_24060_60 n1_M6_20540_60 0.357867
R15303 n1_M6_24060_60 n1_M6_24636_60 0.058560
R15304 n1_M6_24636_60 n1_M6_28732_60 0.416427
R15305 n1_M6_30060_60 n1_M6_28732_60 0.135013
R15306 n1_M6_30060_60 n1_M6_32828_60 0.281413
R15307 n1_M6_36060_60 n1_M6_32828_60 0.328587
R15308 n1_M6_36060_60 n1_M6_36924_60 0.087840
R15309 n1_M6_36924_60 n1_M6_41020_60 0.416427
R15310 n1_M6_42060_60 n1_M6_41020_60 0.105733
R15311 n1_M6_42060_60 n1_M6_45116_60 0.310693
R15312 n1_M6_48060_60 n1_M6_45116_60 0.299307
R15313 n1_M6_48060_60 n1_M6_49212_60 0.117120
R15314 n1_M6_49212_60 n1_M6_53308_60 0.416427
R15315 n1_M6_54060_60 n1_M6_53308_60 0.076453
R15316 n1_M6_54060_60 n1_M6_57404_60 0.339973
R15317 n1_M6_60060_60 n1_M6_57404_60 0.270027
R15318 n1_M6_60060_60 n1_M6_61500_60 0.146400
R15319 n1_M6_61500_60 n1_M6_65596_60 0.416427
R15320 n1_M6_66060_60 n1_M6_65596_60 0.047173
R15321 n1_M6_66060_60 n1_M6_69692_60 0.369253
R15322 n1_M6_72060_60 n1_M6_69692_60 0.240747
R15323 n1_M6_72060_60 n1_M6_73788_60 0.175680
R15324 n1_M6_73788_60 n1_M6_77884_60 0.416427
R15325 n1_M6_78060_60 n1_M6_77884_60 0.017893
R15326 n1_M6_78060_60 n1_M6_81980_60 0.398533
R15327 n1_M6_84060_60 n1_M6_81980_60 0.211467
R15328 n1_M6_84060_60 n1_M6_86076_60 0.204960
R15329 n1_M6_90060_60 n1_M6_86076_60 0.405040
R15330 n1_M6_90060_60 n1_M6_90172_60 0.011387
R15331 n1_M6_90172_60 n1_M6_94268_60 0.416427
R15332 n1_M6_96060_60 n1_M6_94268_60 0.182187
R15333 n1_M6_96060_60 n1_M6_98364_60 0.234240
R15334 n1_M6_102060_60 n1_M6_98364_60 0.375760
R15335 n1_M6_102060_60 n1_M6_102460_60 0.040667
R15336 n1_M6_102460_60 n1_M6_106556_60 0.416427
R15337 n1_M6_108060_60 n1_M6_106556_60 0.152907
R15338 n1_M6_108060_60 n1_M6_110652_60 0.263520
R15339 n1_M6_114060_60 n1_M6_110652_60 0.346480
R15340 n1_M6_114060_60 n1_M6_114748_60 0.069947
R15341 n1_M6_114748_60 n1_M6_118844_60 0.416427
R15342 n1_M6_120060_60 n1_M6_118844_60 0.123627
R15343 n1_M6_120060_60 n1_M6_122940_60 0.292800
R15344 n1_M6_126060_60 n1_M6_122940_60 0.317200
R15345 n1_M6_126060_60 n1_M6_127036_60 0.099227
R15346 n1_M6_60_12060 n1_M6_4156_12060 0.416427
R15347 n1_M6_6060_12060 n1_M6_4156_12060 0.193573
R15348 n1_M6_6060_12060 n1_M6_8252_12060 0.222853
R15349 n1_M6_12060_12060 n1_M6_8252_12060 0.387147
R15350 n1_M6_12060_12060 n1_M6_12348_12060 0.029280
R15351 n1_M6_12348_12060 n1_M6_16444_12060 0.416427
R15352 n1_M6_18060_12060 n1_M6_16444_12060 0.164293
R15353 n1_M6_18060_12060 n1_M6_20540_12060 0.252133
R15354 n1_M6_24060_12060 n1_M6_20540_12060 0.357867
R15355 n1_M6_24060_12060 n1_M6_24636_12060 0.058560
R15356 n1_M6_24636_12060 n1_M6_28732_12060 0.416427
R15357 n1_M6_30060_12060 n1_M6_28732_12060 0.135013
R15358 n1_M6_30060_12060 n1_M6_32828_12060 0.281413
R15359 n1_M6_36060_12060 n1_M6_32828_12060 0.328587
R15360 n1_M6_36060_12060 n1_M6_36924_12060 0.087840
R15361 n1_M6_36924_12060 n1_M6_41020_12060 0.416427
R15362 n1_M6_42060_12060 n1_M6_41020_12060 0.105733
R15363 n1_M6_42060_12060 n1_M6_45116_12060 0.310693
R15364 n1_M6_48060_12060 n1_M6_45116_12060 0.299307
R15365 n1_M6_48060_12060 n1_M6_49212_12060 0.117120
R15366 n1_M6_49212_12060 n1_M6_53308_12060 0.416427
R15367 n1_M6_54060_12060 n1_M6_53308_12060 0.076453
R15368 n1_M6_54060_12060 n1_M6_57404_12060 0.339973
R15369 n1_M6_60060_12060 n1_M6_57404_12060 0.270027
R15370 n1_M6_60060_12060 n1_M6_61500_12060 0.146400
R15371 n1_M6_61500_12060 n1_M6_65596_12060 0.416427
R15372 n1_M6_66060_12060 n1_M6_65596_12060 0.047173
R15373 n1_M6_66060_12060 n1_M6_69692_12060 0.369253
R15374 n1_M6_72060_12060 n1_M6_69692_12060 0.240747
R15375 n1_M6_72060_12060 n1_M6_73788_12060 0.175680
R15376 n1_M6_73788_12060 n1_M6_77884_12060 0.416427
R15377 n1_M6_78060_12060 n1_M6_77884_12060 0.017893
R15378 n1_M6_78060_12060 n1_M6_81980_12060 0.398533
R15379 n1_M6_84060_12060 n1_M6_81980_12060 0.211467
R15380 n1_M6_84060_12060 n1_M6_86076_12060 0.204960
R15381 n1_M6_90060_12060 n1_M6_86076_12060 0.405040
R15382 n1_M6_90060_12060 n1_M6_90172_12060 0.011387
R15383 n1_M6_90172_12060 n1_M6_94268_12060 0.416427
R15384 n1_M6_96060_12060 n1_M6_94268_12060 0.182187
R15385 n1_M6_96060_12060 n1_M6_98364_12060 0.234240
R15386 n1_M6_102060_12060 n1_M6_98364_12060 0.375760
R15387 n1_M6_102060_12060 n1_M6_102460_12060 0.040667
R15388 n1_M6_102460_12060 n1_M6_106556_12060 0.416427
R15389 n1_M6_108060_12060 n1_M6_106556_12060 0.152907
R15390 n1_M6_108060_12060 n1_M6_110652_12060 0.263520
R15391 n1_M6_114060_12060 n1_M6_110652_12060 0.346480
R15392 n1_M6_114060_12060 n1_M6_114748_12060 0.069947
R15393 n1_M6_114748_12060 n1_M6_118844_12060 0.416427
R15394 n1_M6_120060_12060 n1_M6_118844_12060 0.123627
R15395 n1_M6_120060_12060 n1_M6_122940_12060 0.292800
R15396 n1_M6_126060_12060 n1_M6_122940_12060 0.317200
R15397 n1_M6_126060_12060 n1_M6_127036_12060 0.099227
R15398 n1_M6_60_24060 n1_M6_4156_24060 0.416427
R15399 n1_M6_6060_24060 n1_M6_4156_24060 0.193573
R15400 n1_M6_6060_24060 n1_M6_8252_24060 0.222853
R15401 n1_M6_12060_24060 n1_M6_8252_24060 0.387147
R15402 n1_M6_12060_24060 n1_M6_12348_24060 0.029280
R15403 n1_M6_12348_24060 n1_M6_16444_24060 0.416427
R15404 n1_M6_18060_24060 n1_M6_16444_24060 0.164293
R15405 n1_M6_18060_24060 n1_M6_20540_24060 0.252133
R15406 n1_M6_24060_24060 n1_M6_20540_24060 0.357867
R15407 n1_M6_24060_24060 n1_M6_24636_24060 0.058560
R15408 n1_M6_24636_24060 n1_M6_28732_24060 0.416427
R15409 n1_M6_30060_24060 n1_M6_28732_24060 0.135013
R15410 n1_M6_30060_24060 n1_M6_32828_24060 0.281413
R15411 n1_M6_36060_24060 n1_M6_32828_24060 0.328587
R15412 n1_M6_36060_24060 n1_M6_36924_24060 0.087840
R15413 n1_M6_36924_24060 n1_M6_41020_24060 0.416427
R15414 n1_M6_42060_24060 n1_M6_41020_24060 0.105733
R15415 n1_M6_42060_24060 n1_M6_45116_24060 0.310693
R15416 n1_M6_48060_24060 n1_M6_45116_24060 0.299307
R15417 n1_M6_48060_24060 n1_M6_49212_24060 0.117120
R15418 n1_M6_49212_24060 n1_M6_53308_24060 0.416427
R15419 n1_M6_54060_24060 n1_M6_53308_24060 0.076453
R15420 n1_M6_54060_24060 n1_M6_57404_24060 0.339973
R15421 n1_M6_60060_24060 n1_M6_57404_24060 0.270027
R15422 n1_M6_60060_24060 n1_M6_61500_24060 0.146400
R15423 n1_M6_61500_24060 n1_M6_65596_24060 0.416427
R15424 n1_M6_66060_24060 n1_M6_65596_24060 0.047173
R15425 n1_M6_66060_24060 n1_M6_69692_24060 0.369253
R15426 n1_M6_72060_24060 n1_M6_69692_24060 0.240747
R15427 n1_M6_72060_24060 n1_M6_73788_24060 0.175680
R15428 n1_M6_73788_24060 n1_M6_77884_24060 0.416427
R15429 n1_M6_78060_24060 n1_M6_77884_24060 0.017893
R15430 n1_M6_78060_24060 n1_M6_81980_24060 0.398533
R15431 n1_M6_84060_24060 n1_M6_81980_24060 0.211467
R15432 n1_M6_84060_24060 n1_M6_86076_24060 0.204960
R15433 n1_M6_90060_24060 n1_M6_86076_24060 0.405040
R15434 n1_M6_90060_24060 n1_M6_90172_24060 0.011387
R15435 n1_M6_90172_24060 n1_M6_94268_24060 0.416427
R15436 n1_M6_96060_24060 n1_M6_94268_24060 0.182187
R15437 n1_M6_96060_24060 n1_M6_98364_24060 0.234240
R15438 n1_M6_102060_24060 n1_M6_98364_24060 0.375760
R15439 n1_M6_102060_24060 n1_M6_102460_24060 0.040667
R15440 n1_M6_102460_24060 n1_M6_106556_24060 0.416427
R15441 n1_M6_108060_24060 n1_M6_106556_24060 0.152907
R15442 n1_M6_108060_24060 n1_M6_110652_24060 0.263520
R15443 n1_M6_114060_24060 n1_M6_110652_24060 0.346480
R15444 n1_M6_114060_24060 n1_M6_114748_24060 0.069947
R15445 n1_M6_114748_24060 n1_M6_118844_24060 0.416427
R15446 n1_M6_120060_24060 n1_M6_118844_24060 0.123627
R15447 n1_M6_120060_24060 n1_M6_122940_24060 0.292800
R15448 n1_M6_126060_24060 n1_M6_122940_24060 0.317200
R15449 n1_M6_126060_24060 n1_M6_127036_24060 0.099227
R15450 n1_M6_60_36060 n1_M6_4156_36060 0.416427
R15451 n1_M6_6060_36060 n1_M6_4156_36060 0.193573
R15452 n1_M6_6060_36060 n1_M6_8252_36060 0.222853
R15453 n1_M6_12060_36060 n1_M6_8252_36060 0.387147
R15454 n1_M6_12060_36060 n1_M6_12348_36060 0.029280
R15455 n1_M6_12348_36060 n1_M6_16444_36060 0.416427
R15456 n1_M6_18060_36060 n1_M6_16444_36060 0.164293
R15457 n1_M6_18060_36060 n1_M6_20540_36060 0.252133
R15458 n1_M6_24060_36060 n1_M6_20540_36060 0.357867
R15459 n1_M6_24060_36060 n1_M6_24636_36060 0.058560
R15460 n1_M6_24636_36060 n1_M6_28732_36060 0.416427
R15461 n1_M6_30060_36060 n1_M6_28732_36060 0.135013
R15462 n1_M6_30060_36060 n1_M6_32828_36060 0.281413
R15463 n1_M6_36060_36060 n1_M6_32828_36060 0.328587
R15464 n1_M6_36060_36060 n1_M6_36924_36060 0.087840
R15465 n1_M6_36924_36060 n1_M6_41020_36060 0.416427
R15466 n1_M6_42060_36060 n1_M6_41020_36060 0.105733
R15467 n1_M6_42060_36060 n1_M6_45116_36060 0.310693
R15468 n1_M6_48060_36060 n1_M6_45116_36060 0.299307
R15469 n1_M6_48060_36060 n1_M6_49212_36060 0.117120
R15470 n1_M6_49212_36060 n1_M6_53308_36060 0.416427
R15471 n1_M6_54060_36060 n1_M6_53308_36060 0.076453
R15472 n1_M6_54060_36060 n1_M6_57404_36060 0.339973
R15473 n1_M6_60060_36060 n1_M6_57404_36060 0.270027
R15474 n1_M6_60060_36060 n1_M6_61500_36060 0.146400
R15475 n1_M6_61500_36060 n1_M6_65596_36060 0.416427
R15476 n1_M6_66060_36060 n1_M6_65596_36060 0.047173
R15477 n1_M6_66060_36060 n1_M6_69692_36060 0.369253
R15478 n1_M6_72060_36060 n1_M6_69692_36060 0.240747
R15479 n1_M6_72060_36060 n1_M6_73788_36060 0.175680
R15480 n1_M6_73788_36060 n1_M6_77884_36060 0.416427
R15481 n1_M6_78060_36060 n1_M6_77884_36060 0.017893
R15482 n1_M6_78060_36060 n1_M6_81980_36060 0.398533
R15483 n1_M6_84060_36060 n1_M6_81980_36060 0.211467
R15484 n1_M6_84060_36060 n1_M6_86076_36060 0.204960
R15485 n1_M6_90060_36060 n1_M6_86076_36060 0.405040
R15486 n1_M6_90060_36060 n1_M6_90172_36060 0.011387
R15487 n1_M6_90172_36060 n1_M6_94268_36060 0.416427
R15488 n1_M6_96060_36060 n1_M6_94268_36060 0.182187
R15489 n1_M6_96060_36060 n1_M6_98364_36060 0.234240
R15490 n1_M6_102060_36060 n1_M6_98364_36060 0.375760
R15491 n1_M6_102060_36060 n1_M6_102460_36060 0.040667
R15492 n1_M6_102460_36060 n1_M6_106556_36060 0.416427
R15493 n1_M6_108060_36060 n1_M6_106556_36060 0.152907
R15494 n1_M6_108060_36060 n1_M6_110652_36060 0.263520
R15495 n1_M6_114060_36060 n1_M6_110652_36060 0.346480
R15496 n1_M6_114060_36060 n1_M6_114748_36060 0.069947
R15497 n1_M6_114748_36060 n1_M6_118844_36060 0.416427
R15498 n1_M6_120060_36060 n1_M6_118844_36060 0.123627
R15499 n1_M6_120060_36060 n1_M6_122940_36060 0.292800
R15500 n1_M6_126060_36060 n1_M6_122940_36060 0.317200
R15501 n1_M6_126060_36060 n1_M6_127036_36060 0.099227
R15502 n1_M6_60_48060 n1_M6_4156_48060 0.416427
R15503 n1_M6_6060_48060 n1_M6_4156_48060 0.193573
R15504 n1_M6_6060_48060 n1_M6_8252_48060 0.222853
R15505 n1_M6_12060_48060 n1_M6_8252_48060 0.387147
R15506 n1_M6_12060_48060 n1_M6_12348_48060 0.029280
R15507 n1_M6_12348_48060 n1_M6_16444_48060 0.416427
R15508 n1_M6_18060_48060 n1_M6_16444_48060 0.164293
R15509 n1_M6_18060_48060 n1_M6_20540_48060 0.252133
R15510 n1_M6_24060_48060 n1_M6_20540_48060 0.357867
R15511 n1_M6_24060_48060 n1_M6_24636_48060 0.058560
R15512 n1_M6_24636_48060 n1_M6_28732_48060 0.416427
R15513 n1_M6_30060_48060 n1_M6_28732_48060 0.135013
R15514 n1_M6_30060_48060 n1_M6_32828_48060 0.281413
R15515 n1_M6_36060_48060 n1_M6_32828_48060 0.328587
R15516 n1_M6_36060_48060 n1_M6_36924_48060 0.087840
R15517 n1_M6_36924_48060 n1_M6_41020_48060 0.416427
R15518 n1_M6_42060_48060 n1_M6_41020_48060 0.105733
R15519 n1_M6_42060_48060 n1_M6_45116_48060 0.310693
R15520 n1_M6_48060_48060 n1_M6_45116_48060 0.299307
R15521 n1_M6_48060_48060 n1_M6_49212_48060 0.117120
R15522 n1_M6_49212_48060 n1_M6_53308_48060 0.416427
R15523 n1_M6_54060_48060 n1_M6_53308_48060 0.076453
R15524 n1_M6_54060_48060 n1_M6_57404_48060 0.339973
R15525 n1_M6_60060_48060 n1_M6_57404_48060 0.270027
R15526 n1_M6_60060_48060 n1_M6_61500_48060 0.146400
R15527 n1_M6_61500_48060 n1_M6_65596_48060 0.416427
R15528 n1_M6_66060_48060 n1_M6_65596_48060 0.047173
R15529 n1_M6_66060_48060 n1_M6_69692_48060 0.369253
R15530 n1_M6_72060_48060 n1_M6_69692_48060 0.240747
R15531 n1_M6_72060_48060 n1_M6_73788_48060 0.175680
R15532 n1_M6_73788_48060 n1_M6_77884_48060 0.416427
R15533 n1_M6_78060_48060 n1_M6_77884_48060 0.017893
R15534 n1_M6_78060_48060 n1_M6_81980_48060 0.398533
R15535 n1_M6_84060_48060 n1_M6_81980_48060 0.211467
R15536 n1_M6_84060_48060 n1_M6_86076_48060 0.204960
R15537 n1_M6_90060_48060 n1_M6_86076_48060 0.405040
R15538 n1_M6_90060_48060 n1_M6_90172_48060 0.011387
R15539 n1_M6_90172_48060 n1_M6_94268_48060 0.416427
R15540 n1_M6_96060_48060 n1_M6_94268_48060 0.182187
R15541 n1_M6_96060_48060 n1_M6_98364_48060 0.234240
R15542 n1_M6_102060_48060 n1_M6_98364_48060 0.375760
R15543 n1_M6_102060_48060 n1_M6_102460_48060 0.040667
R15544 n1_M6_102460_48060 n1_M6_106556_48060 0.416427
R15545 n1_M6_108060_48060 n1_M6_106556_48060 0.152907
R15546 n1_M6_108060_48060 n1_M6_110652_48060 0.263520
R15547 n1_M6_114060_48060 n1_M6_110652_48060 0.346480
R15548 n1_M6_114060_48060 n1_M6_114748_48060 0.069947
R15549 n1_M6_114748_48060 n1_M6_118844_48060 0.416427
R15550 n1_M6_120060_48060 n1_M6_118844_48060 0.123627
R15551 n1_M6_120060_48060 n1_M6_122940_48060 0.292800
R15552 n1_M6_126060_48060 n1_M6_122940_48060 0.317200
R15553 n1_M6_126060_48060 n1_M6_127036_48060 0.099227
R15554 n1_M6_60_60060 n1_M6_4156_60060 0.416427
R15555 n1_M6_6060_60060 n1_M6_4156_60060 0.193573
R15556 n1_M6_6060_60060 n1_M6_8252_60060 0.222853
R15557 n1_M6_12060_60060 n1_M6_8252_60060 0.387147
R15558 n1_M6_12060_60060 n1_M6_12348_60060 0.029280
R15559 n1_M6_12348_60060 n1_M6_16444_60060 0.416427
R15560 n1_M6_18060_60060 n1_M6_16444_60060 0.164293
R15561 n1_M6_18060_60060 n1_M6_20540_60060 0.252133
R15562 n1_M6_24060_60060 n1_M6_20540_60060 0.357867
R15563 n1_M6_24060_60060 n1_M6_24636_60060 0.058560
R15564 n1_M6_24636_60060 n1_M6_28732_60060 0.416427
R15565 n1_M6_30060_60060 n1_M6_28732_60060 0.135013
R15566 n1_M6_30060_60060 n1_M6_32828_60060 0.281413
R15567 n1_M6_36060_60060 n1_M6_32828_60060 0.328587
R15568 n1_M6_36060_60060 n1_M6_36924_60060 0.087840
R15569 n1_M6_36924_60060 n1_M6_41020_60060 0.416427
R15570 n1_M6_42060_60060 n1_M6_41020_60060 0.105733
R15571 n1_M6_42060_60060 n1_M6_45116_60060 0.310693
R15572 n1_M6_48060_60060 n1_M6_45116_60060 0.299307
R15573 n1_M6_48060_60060 n1_M6_49212_60060 0.117120
R15574 n1_M6_49212_60060 n1_M6_53308_60060 0.416427
R15575 n1_M6_54060_60060 n1_M6_53308_60060 0.076453
R15576 n1_M6_54060_60060 n1_M6_57404_60060 0.339973
R15577 n1_M6_60060_60060 n1_M6_57404_60060 0.270027
R15578 n1_M6_60060_60060 n1_M6_61500_60060 0.146400
R15579 n1_M6_61500_60060 n1_M6_65596_60060 0.416427
R15580 n1_M6_66060_60060 n1_M6_65596_60060 0.047173
R15581 n1_M6_66060_60060 n1_M6_69692_60060 0.369253
R15582 n1_M6_72060_60060 n1_M6_69692_60060 0.240747
R15583 n1_M6_72060_60060 n1_M6_73788_60060 0.175680
R15584 n1_M6_73788_60060 n1_M6_77884_60060 0.416427
R15585 n1_M6_78060_60060 n1_M6_77884_60060 0.017893
R15586 n1_M6_78060_60060 n1_M6_81980_60060 0.398533
R15587 n1_M6_84060_60060 n1_M6_81980_60060 0.211467
R15588 n1_M6_84060_60060 n1_M6_86076_60060 0.204960
R15589 n1_M6_90060_60060 n1_M6_86076_60060 0.405040
R15590 n1_M6_90060_60060 n1_M6_90172_60060 0.011387
R15591 n1_M6_90172_60060 n1_M6_94268_60060 0.416427
R15592 n1_M6_96060_60060 n1_M6_94268_60060 0.182187
R15593 n1_M6_96060_60060 n1_M6_98364_60060 0.234240
R15594 n1_M6_102060_60060 n1_M6_98364_60060 0.375760
R15595 n1_M6_102060_60060 n1_M6_102460_60060 0.040667
R15596 n1_M6_102460_60060 n1_M6_106556_60060 0.416427
R15597 n1_M6_108060_60060 n1_M6_106556_60060 0.152907
R15598 n1_M6_108060_60060 n1_M6_110652_60060 0.263520
R15599 n1_M6_114060_60060 n1_M6_110652_60060 0.346480
R15600 n1_M6_114060_60060 n1_M6_114748_60060 0.069947
R15601 n1_M6_114748_60060 n1_M6_118844_60060 0.416427
R15602 n1_M6_120060_60060 n1_M6_118844_60060 0.123627
R15603 n1_M6_120060_60060 n1_M6_122940_60060 0.292800
R15604 n1_M6_126060_60060 n1_M6_122940_60060 0.317200
R15605 n1_M6_126060_60060 n1_M6_127036_60060 0.099227
R15606 n1_M6_60_72060 n1_M6_4156_72060 0.416427
R15607 n1_M6_6060_72060 n1_M6_4156_72060 0.193573
R15608 n1_M6_6060_72060 n1_M6_8252_72060 0.222853
R15609 n1_M6_12060_72060 n1_M6_8252_72060 0.387147
R15610 n1_M6_12060_72060 n1_M6_12348_72060 0.029280
R15611 n1_M6_12348_72060 n1_M6_16444_72060 0.416427
R15612 n1_M6_18060_72060 n1_M6_16444_72060 0.164293
R15613 n1_M6_18060_72060 n1_M6_20540_72060 0.252133
R15614 n1_M6_24060_72060 n1_M6_20540_72060 0.357867
R15615 n1_M6_24060_72060 n1_M6_24636_72060 0.058560
R15616 n1_M6_24636_72060 n1_M6_28732_72060 0.416427
R15617 n1_M6_30060_72060 n1_M6_28732_72060 0.135013
R15618 n1_M6_30060_72060 n1_M6_32828_72060 0.281413
R15619 n1_M6_36060_72060 n1_M6_32828_72060 0.328587
R15620 n1_M6_36060_72060 n1_M6_36924_72060 0.087840
R15621 n1_M6_36924_72060 n1_M6_41020_72060 0.416427
R15622 n1_M6_42060_72060 n1_M6_41020_72060 0.105733
R15623 n1_M6_42060_72060 n1_M6_45116_72060 0.310693
R15624 n1_M6_48060_72060 n1_M6_45116_72060 0.299307
R15625 n1_M6_48060_72060 n1_M6_49212_72060 0.117120
R15626 n1_M6_49212_72060 n1_M6_53308_72060 0.416427
R15627 n1_M6_54060_72060 n1_M6_53308_72060 0.076453
R15628 n1_M6_54060_72060 n1_M6_57404_72060 0.339973
R15629 n1_M6_60060_72060 n1_M6_57404_72060 0.270027
R15630 n1_M6_60060_72060 n1_M6_61500_72060 0.146400
R15631 n1_M6_61500_72060 n1_M6_65596_72060 0.416427
R15632 n1_M6_66060_72060 n1_M6_65596_72060 0.047173
R15633 n1_M6_66060_72060 n1_M6_69692_72060 0.369253
R15634 n1_M6_72060_72060 n1_M6_69692_72060 0.240747
R15635 n1_M6_72060_72060 n1_M6_73788_72060 0.175680
R15636 n1_M6_73788_72060 n1_M6_77884_72060 0.416427
R15637 n1_M6_78060_72060 n1_M6_77884_72060 0.017893
R15638 n1_M6_78060_72060 n1_M6_81980_72060 0.398533
R15639 n1_M6_84060_72060 n1_M6_81980_72060 0.211467
R15640 n1_M6_84060_72060 n1_M6_86076_72060 0.204960
R15641 n1_M6_90060_72060 n1_M6_86076_72060 0.405040
R15642 n1_M6_90060_72060 n1_M6_90172_72060 0.011387
R15643 n1_M6_90172_72060 n1_M6_94268_72060 0.416427
R15644 n1_M6_96060_72060 n1_M6_94268_72060 0.182187
R15645 n1_M6_96060_72060 n1_M6_98364_72060 0.234240
R15646 n1_M6_102060_72060 n1_M6_98364_72060 0.375760
R15647 n1_M6_102060_72060 n1_M6_102460_72060 0.040667
R15648 n1_M6_102460_72060 n1_M6_106556_72060 0.416427
R15649 n1_M6_108060_72060 n1_M6_106556_72060 0.152907
R15650 n1_M6_108060_72060 n1_M6_110652_72060 0.263520
R15651 n1_M6_114060_72060 n1_M6_110652_72060 0.346480
R15652 n1_M6_114060_72060 n1_M6_114748_72060 0.069947
R15653 n1_M6_114748_72060 n1_M6_118844_72060 0.416427
R15654 n1_M6_120060_72060 n1_M6_118844_72060 0.123627
R15655 n1_M6_120060_72060 n1_M6_122940_72060 0.292800
R15656 n1_M6_126060_72060 n1_M6_122940_72060 0.317200
R15657 n1_M6_126060_72060 n1_M6_127036_72060 0.099227
R15658 n1_M6_60_84060 n1_M6_4156_84060 0.416427
R15659 n1_M6_6060_84060 n1_M6_4156_84060 0.193573
R15660 n1_M6_6060_84060 n1_M6_8252_84060 0.222853
R15661 n1_M6_12060_84060 n1_M6_8252_84060 0.387147
R15662 n1_M6_12060_84060 n1_M6_12348_84060 0.029280
R15663 n1_M6_12348_84060 n1_M6_16444_84060 0.416427
R15664 n1_M6_18060_84060 n1_M6_16444_84060 0.164293
R15665 n1_M6_18060_84060 n1_M6_20540_84060 0.252133
R15666 n1_M6_24060_84060 n1_M6_20540_84060 0.357867
R15667 n1_M6_24060_84060 n1_M6_24636_84060 0.058560
R15668 n1_M6_24636_84060 n1_M6_28732_84060 0.416427
R15669 n1_M6_30060_84060 n1_M6_28732_84060 0.135013
R15670 n1_M6_30060_84060 n1_M6_32828_84060 0.281413
R15671 n1_M6_36060_84060 n1_M6_32828_84060 0.328587
R15672 n1_M6_36060_84060 n1_M6_36924_84060 0.087840
R15673 n1_M6_36924_84060 n1_M6_41020_84060 0.416427
R15674 n1_M6_42060_84060 n1_M6_41020_84060 0.105733
R15675 n1_M6_42060_84060 n1_M6_45116_84060 0.310693
R15676 n1_M6_48060_84060 n1_M6_45116_84060 0.299307
R15677 n1_M6_48060_84060 n1_M6_49212_84060 0.117120
R15678 n1_M6_49212_84060 n1_M6_53308_84060 0.416427
R15679 n1_M6_54060_84060 n1_M6_53308_84060 0.076453
R15680 n1_M6_54060_84060 n1_M6_57404_84060 0.339973
R15681 n1_M6_60060_84060 n1_M6_57404_84060 0.270027
R15682 n1_M6_60060_84060 n1_M6_61500_84060 0.146400
R15683 n1_M6_61500_84060 n1_M6_65596_84060 0.416427
R15684 n1_M6_66060_84060 n1_M6_65596_84060 0.047173
R15685 n1_M6_66060_84060 n1_M6_69692_84060 0.369253
R15686 n1_M6_72060_84060 n1_M6_69692_84060 0.240747
R15687 n1_M6_72060_84060 n1_M6_73788_84060 0.175680
R15688 n1_M6_73788_84060 n1_M6_77884_84060 0.416427
R15689 n1_M6_78060_84060 n1_M6_77884_84060 0.017893
R15690 n1_M6_78060_84060 n1_M6_81980_84060 0.398533
R15691 n1_M6_84060_84060 n1_M6_81980_84060 0.211467
R15692 n1_M6_84060_84060 n1_M6_86076_84060 0.204960
R15693 n1_M6_90060_84060 n1_M6_86076_84060 0.405040
R15694 n1_M6_90060_84060 n1_M6_90172_84060 0.011387
R15695 n1_M6_90172_84060 n1_M6_94268_84060 0.416427
R15696 n1_M6_96060_84060 n1_M6_94268_84060 0.182187
R15697 n1_M6_96060_84060 n1_M6_98364_84060 0.234240
R15698 n1_M6_102060_84060 n1_M6_98364_84060 0.375760
R15699 n1_M6_102060_84060 n1_M6_102460_84060 0.040667
R15700 n1_M6_102460_84060 n1_M6_106556_84060 0.416427
R15701 n1_M6_108060_84060 n1_M6_106556_84060 0.152907
R15702 n1_M6_108060_84060 n1_M6_110652_84060 0.263520
R15703 n1_M6_114060_84060 n1_M6_110652_84060 0.346480
R15704 n1_M6_114060_84060 n1_M6_114748_84060 0.069947
R15705 n1_M6_114748_84060 n1_M6_118844_84060 0.416427
R15706 n1_M6_120060_84060 n1_M6_118844_84060 0.123627
R15707 n1_M6_120060_84060 n1_M6_122940_84060 0.292800
R15708 n1_M6_126060_84060 n1_M6_122940_84060 0.317200
R15709 n1_M6_126060_84060 n1_M6_127036_84060 0.099227
R15710 n1_M6_60_96060 n1_M6_4156_96060 0.416427
R15711 n1_M6_6060_96060 n1_M6_4156_96060 0.193573
R15712 n1_M6_6060_96060 n1_M6_8252_96060 0.222853
R15713 n1_M6_12060_96060 n1_M6_8252_96060 0.387147
R15714 n1_M6_12060_96060 n1_M6_12348_96060 0.029280
R15715 n1_M6_12348_96060 n1_M6_16444_96060 0.416427
R15716 n1_M6_18060_96060 n1_M6_16444_96060 0.164293
R15717 n1_M6_18060_96060 n1_M6_20540_96060 0.252133
R15718 n1_M6_24060_96060 n1_M6_20540_96060 0.357867
R15719 n1_M6_24060_96060 n1_M6_24636_96060 0.058560
R15720 n1_M6_24636_96060 n1_M6_28732_96060 0.416427
R15721 n1_M6_30060_96060 n1_M6_28732_96060 0.135013
R15722 n1_M6_30060_96060 n1_M6_32828_96060 0.281413
R15723 n1_M6_36060_96060 n1_M6_32828_96060 0.328587
R15724 n1_M6_36060_96060 n1_M6_36924_96060 0.087840
R15725 n1_M6_36924_96060 n1_M6_41020_96060 0.416427
R15726 n1_M6_42060_96060 n1_M6_41020_96060 0.105733
R15727 n1_M6_42060_96060 n1_M6_45116_96060 0.310693
R15728 n1_M6_48060_96060 n1_M6_45116_96060 0.299307
R15729 n1_M6_48060_96060 n1_M6_49212_96060 0.117120
R15730 n1_M6_49212_96060 n1_M6_53308_96060 0.416427
R15731 n1_M6_54060_96060 n1_M6_53308_96060 0.076453
R15732 n1_M6_54060_96060 n1_M6_57404_96060 0.339973
R15733 n1_M6_60060_96060 n1_M6_57404_96060 0.270027
R15734 n1_M6_60060_96060 n1_M6_61500_96060 0.146400
R15735 n1_M6_61500_96060 n1_M6_65596_96060 0.416427
R15736 n1_M6_66060_96060 n1_M6_65596_96060 0.047173
R15737 n1_M6_66060_96060 n1_M6_69692_96060 0.369253
R15738 n1_M6_72060_96060 n1_M6_69692_96060 0.240747
R15739 n1_M6_72060_96060 n1_M6_73788_96060 0.175680
R15740 n1_M6_73788_96060 n1_M6_77884_96060 0.416427
R15741 n1_M6_78060_96060 n1_M6_77884_96060 0.017893
R15742 n1_M6_78060_96060 n1_M6_81980_96060 0.398533
R15743 n1_M6_84060_96060 n1_M6_81980_96060 0.211467
R15744 n1_M6_84060_96060 n1_M6_86076_96060 0.204960
R15745 n1_M6_90060_96060 n1_M6_86076_96060 0.405040
R15746 n1_M6_90060_96060 n1_M6_90172_96060 0.011387
R15747 n1_M6_90172_96060 n1_M6_94268_96060 0.416427
R15748 n1_M6_96060_96060 n1_M6_94268_96060 0.182187
R15749 n1_M6_96060_96060 n1_M6_98364_96060 0.234240
R15750 n1_M6_102060_96060 n1_M6_98364_96060 0.375760
R15751 n1_M6_102060_96060 n1_M6_102460_96060 0.040667
R15752 n1_M6_102460_96060 n1_M6_106556_96060 0.416427
R15753 n1_M6_108060_96060 n1_M6_106556_96060 0.152907
R15754 n1_M6_108060_96060 n1_M6_110652_96060 0.263520
R15755 n1_M6_114060_96060 n1_M6_110652_96060 0.346480
R15756 n1_M6_114060_96060 n1_M6_114748_96060 0.069947
R15757 n1_M6_114748_96060 n1_M6_118844_96060 0.416427
R15758 n1_M6_120060_96060 n1_M6_118844_96060 0.123627
R15759 n1_M6_120060_96060 n1_M6_122940_96060 0.292800
R15760 n1_M6_126060_96060 n1_M6_122940_96060 0.317200
R15761 n1_M6_126060_96060 n1_M6_127036_96060 0.099227
R15762 n1_M6_60_108060 n1_M6_4156_108060 0.416427
R15763 n1_M6_6060_108060 n1_M6_4156_108060 0.193573
R15764 n1_M6_6060_108060 n1_M6_8252_108060 0.222853
R15765 n1_M6_12060_108060 n1_M6_8252_108060 0.387147
R15766 n1_M6_12060_108060 n1_M6_12348_108060 0.029280
R15767 n1_M6_12348_108060 n1_M6_16444_108060 0.416427
R15768 n1_M6_18060_108060 n1_M6_16444_108060 0.164293
R15769 n1_M6_18060_108060 n1_M6_20540_108060 0.252133
R15770 n1_M6_24060_108060 n1_M6_20540_108060 0.357867
R15771 n1_M6_24060_108060 n1_M6_24636_108060 0.058560
R15772 n1_M6_24636_108060 n1_M6_28732_108060 0.416427
R15773 n1_M6_30060_108060 n1_M6_28732_108060 0.135013
R15774 n1_M6_30060_108060 n1_M6_32828_108060 0.281413
R15775 n1_M6_36060_108060 n1_M6_32828_108060 0.328587
R15776 n1_M6_36060_108060 n1_M6_36924_108060 0.087840
R15777 n1_M6_36924_108060 n1_M6_41020_108060 0.416427
R15778 n1_M6_42060_108060 n1_M6_41020_108060 0.105733
R15779 n1_M6_42060_108060 n1_M6_45116_108060 0.310693
R15780 n1_M6_48060_108060 n1_M6_45116_108060 0.299307
R15781 n1_M6_48060_108060 n1_M6_49212_108060 0.117120
R15782 n1_M6_49212_108060 n1_M6_53308_108060 0.416427
R15783 n1_M6_54060_108060 n1_M6_53308_108060 0.076453
R15784 n1_M6_54060_108060 n1_M6_57404_108060 0.339973
R15785 n1_M6_60060_108060 n1_M6_57404_108060 0.270027
R15786 n1_M6_60060_108060 n1_M6_61500_108060 0.146400
R15787 n1_M6_61500_108060 n1_M6_65596_108060 0.416427
R15788 n1_M6_66060_108060 n1_M6_65596_108060 0.047173
R15789 n1_M6_66060_108060 n1_M6_69692_108060 0.369253
R15790 n1_M6_72060_108060 n1_M6_69692_108060 0.240747
R15791 n1_M6_72060_108060 n1_M6_73788_108060 0.175680
R15792 n1_M6_73788_108060 n1_M6_77884_108060 0.416427
R15793 n1_M6_78060_108060 n1_M6_77884_108060 0.017893
R15794 n1_M6_78060_108060 n1_M6_81980_108060 0.398533
R15795 n1_M6_84060_108060 n1_M6_81980_108060 0.211467
R15796 n1_M6_84060_108060 n1_M6_86076_108060 0.204960
R15797 n1_M6_90060_108060 n1_M6_86076_108060 0.405040
R15798 n1_M6_90060_108060 n1_M6_90172_108060 0.011387
R15799 n1_M6_90172_108060 n1_M6_94268_108060 0.416427
R15800 n1_M6_96060_108060 n1_M6_94268_108060 0.182187
R15801 n1_M6_96060_108060 n1_M6_98364_108060 0.234240
R15802 n1_M6_102060_108060 n1_M6_98364_108060 0.375760
R15803 n1_M6_102060_108060 n1_M6_102460_108060 0.040667
R15804 n1_M6_102460_108060 n1_M6_106556_108060 0.416427
R15805 n1_M6_108060_108060 n1_M6_106556_108060 0.152907
R15806 n1_M6_108060_108060 n1_M6_110652_108060 0.263520
R15807 n1_M6_114060_108060 n1_M6_110652_108060 0.346480
R15808 n1_M6_114060_108060 n1_M6_114748_108060 0.069947
R15809 n1_M6_114748_108060 n1_M6_118844_108060 0.416427
R15810 n1_M6_120060_108060 n1_M6_118844_108060 0.123627
R15811 n1_M6_120060_108060 n1_M6_122940_108060 0.292800
R15812 n1_M6_126060_108060 n1_M6_122940_108060 0.317200
R15813 n1_M6_126060_108060 n1_M6_127036_108060 0.099227
R15814 n1_M6_60_120060 n1_M6_4156_120060 0.416427
R15815 n1_M6_6060_120060 n1_M6_4156_120060 0.193573
R15816 n1_M6_6060_120060 n1_M6_8252_120060 0.222853
R15817 n1_M6_12060_120060 n1_M6_8252_120060 0.387147
R15818 n1_M6_12060_120060 n1_M6_12348_120060 0.029280
R15819 n1_M6_12348_120060 n1_M6_16444_120060 0.416427
R15820 n1_M6_18060_120060 n1_M6_16444_120060 0.164293
R15821 n1_M6_18060_120060 n1_M6_20540_120060 0.252133
R15822 n1_M6_24060_120060 n1_M6_20540_120060 0.357867
R15823 n1_M6_24060_120060 n1_M6_24636_120060 0.058560
R15824 n1_M6_24636_120060 n1_M6_28732_120060 0.416427
R15825 n1_M6_30060_120060 n1_M6_28732_120060 0.135013
R15826 n1_M6_30060_120060 n1_M6_32828_120060 0.281413
R15827 n1_M6_36060_120060 n1_M6_32828_120060 0.328587
R15828 n1_M6_36060_120060 n1_M6_36924_120060 0.087840
R15829 n1_M6_36924_120060 n1_M6_41020_120060 0.416427
R15830 n1_M6_42060_120060 n1_M6_41020_120060 0.105733
R15831 n1_M6_42060_120060 n1_M6_45116_120060 0.310693
R15832 n1_M6_48060_120060 n1_M6_45116_120060 0.299307
R15833 n1_M6_48060_120060 n1_M6_49212_120060 0.117120
R15834 n1_M6_49212_120060 n1_M6_53308_120060 0.416427
R15835 n1_M6_54060_120060 n1_M6_53308_120060 0.076453
R15836 n1_M6_54060_120060 n1_M6_57404_120060 0.339973
R15837 n1_M6_60060_120060 n1_M6_57404_120060 0.270027
R15838 n1_M6_60060_120060 n1_M6_61500_120060 0.146400
R15839 n1_M6_61500_120060 n1_M6_65596_120060 0.416427
R15840 n1_M6_66060_120060 n1_M6_65596_120060 0.047173
R15841 n1_M6_66060_120060 n1_M6_69692_120060 0.369253
R15842 n1_M6_72060_120060 n1_M6_69692_120060 0.240747
R15843 n1_M6_72060_120060 n1_M6_73788_120060 0.175680
R15844 n1_M6_73788_120060 n1_M6_77884_120060 0.416427
R15845 n1_M6_78060_120060 n1_M6_77884_120060 0.017893
R15846 n1_M6_78060_120060 n1_M6_81980_120060 0.398533
R15847 n1_M6_84060_120060 n1_M6_81980_120060 0.211467
R15848 n1_M6_84060_120060 n1_M6_86076_120060 0.204960
R15849 n1_M6_90060_120060 n1_M6_86076_120060 0.405040
R15850 n1_M6_90060_120060 n1_M6_90172_120060 0.011387
R15851 n1_M6_90172_120060 n1_M6_94268_120060 0.416427
R15852 n1_M6_96060_120060 n1_M6_94268_120060 0.182187
R15853 n1_M6_96060_120060 n1_M6_98364_120060 0.234240
R15854 n1_M6_102060_120060 n1_M6_98364_120060 0.375760
R15855 n1_M6_102060_120060 n1_M6_102460_120060 0.040667
R15856 n1_M6_102460_120060 n1_M6_106556_120060 0.416427
R15857 n1_M6_108060_120060 n1_M6_106556_120060 0.152907
R15858 n1_M6_108060_120060 n1_M6_110652_120060 0.263520
R15859 n1_M6_114060_120060 n1_M6_110652_120060 0.346480
R15860 n1_M6_114060_120060 n1_M6_114748_120060 0.069947
R15861 n1_M6_114748_120060 n1_M6_118844_120060 0.416427
R15862 n1_M6_120060_120060 n1_M6_118844_120060 0.123627
R15863 n1_M6_120060_120060 n1_M6_122940_120060 0.292800
R15864 n1_M6_126060_120060 n1_M6_122940_120060 0.317200
R15865 n1_M6_126060_120060 n1_M6_127036_120060 0.099227
R15866 n1_M7_60_60 n1_M7_60_6460 0.366000
R15867 n1_M7_60_12060 n1_M7_60_6460 0.320250
R15868 n1_M7_60_12060 n1_M7_60_12860 0.045750
R15869 n1_M7_60_12860 n1_M7_60_19260 0.366000
R15870 n1_M7_60_24060 n1_M7_60_19260 0.274500
R15871 n1_M7_60_24060 n1_M7_60_25660 0.091500
R15872 n1_M7_60_25660 n1_M7_60_32060 0.366000
R15873 n1_M7_60_36060 n1_M7_60_32060 0.228750
R15874 n1_M7_60_36060 n1_M7_60_38460 0.137250
R15875 n1_M7_60_38460 n1_M7_60_44860 0.366000
R15876 n1_M7_60_48060 n1_M7_60_44860 0.183000
R15877 n1_M7_60_48060 n1_M7_60_51260 0.183000
R15878 n1_M7_60_51260 n1_M7_60_57660 0.366000
R15879 n1_M7_60_60060 n1_M7_60_57660 0.137250
R15880 n1_M7_60_60060 n1_M7_60_64060 0.228750
R15881 n1_M7_60_64060 n1_M7_60_70460 0.366000
R15882 n1_M7_60_72060 n1_M7_60_70460 0.091500
R15883 n1_M7_60_72060 n1_M7_60_76860 0.274500
R15884 n1_M7_60_76860 n1_M7_60_83260 0.366000
R15885 n1_M7_60_84060 n1_M7_60_83260 0.045750
R15886 n1_M7_60_84060 n1_M7_60_89660 0.320250
R15887 n1_M7_60_96060 n1_M7_60_89660 0.366000
R15888 n1_M7_60_96060 n1_M7_60_102460 0.366000
R15889 n1_M7_60_108060 n1_M7_60_102460 0.320250
R15890 n1_M7_60_108060 n1_M7_60_108860 0.045750
R15891 n1_M7_60_108860 n1_M7_60_115260 0.366000
R15892 n1_M7_60_120060 n1_M7_60_115260 0.274500
R15893 n1_M7_60_120060 n1_M7_60_121660 0.091500
R15894 n1_M7_60_121660 n1_M7_60_128060 0.366000
R15895 n1_M7_4156_60 n1_M7_4156_6460 0.366000
R15896 n1_M7_4156_12060 n1_M7_4156_6460 0.320250
R15897 n1_M7_4156_12060 n1_M7_4156_12860 0.045750
R15898 n1_M7_4156_12860 n1_M7_4156_19260 0.366000
R15899 n1_M7_4156_24060 n1_M7_4156_19260 0.274500
R15900 n1_M7_4156_24060 n1_M7_4156_25660 0.091500
R15901 n1_M7_4156_25660 n1_M7_4156_32060 0.366000
R15902 n1_M7_4156_36060 n1_M7_4156_32060 0.228750
R15903 n1_M7_4156_36060 n1_M7_4156_38460 0.137250
R15904 n1_M7_4156_38460 n1_M7_4156_44860 0.366000
R15905 n1_M7_4156_48060 n1_M7_4156_44860 0.183000
R15906 n1_M7_4156_48060 n1_M7_4156_51260 0.183000
R15907 n1_M7_4156_51260 n1_M7_4156_57660 0.366000
R15908 n1_M7_4156_60060 n1_M7_4156_57660 0.137250
R15909 n1_M7_4156_60060 n1_M7_4156_64060 0.228750
R15910 n1_M7_4156_64060 n1_M7_4156_70460 0.366000
R15911 n1_M7_4156_72060 n1_M7_4156_70460 0.091500
R15912 n1_M7_4156_72060 n1_M7_4156_76860 0.274500
R15913 n1_M7_4156_76860 n1_M7_4156_83260 0.366000
R15914 n1_M7_4156_84060 n1_M7_4156_83260 0.045750
R15915 n1_M7_4156_84060 n1_M7_4156_89660 0.320250
R15916 n1_M7_4156_96060 n1_M7_4156_89660 0.366000
R15917 n1_M7_4156_96060 n1_M7_4156_102460 0.366000
R15918 n1_M7_4156_108060 n1_M7_4156_102460 0.320250
R15919 n1_M7_4156_108060 n1_M7_4156_108860 0.045750
R15920 n1_M7_4156_108860 n1_M7_4156_115260 0.366000
R15921 n1_M7_4156_120060 n1_M7_4156_115260 0.274500
R15922 n1_M7_4156_120060 n1_M7_4156_121660 0.091500
R15923 n1_M7_4156_121660 n1_M7_4156_128060 0.366000
R15924 n1_M7_8252_60 n1_M7_8252_6460 0.366000
R15925 n1_M7_8252_12060 n1_M7_8252_6460 0.320250
R15926 n1_M7_8252_12060 n1_M7_8252_12860 0.045750
R15927 n1_M7_8252_12860 n1_M7_8252_19260 0.366000
R15928 n1_M7_8252_24060 n1_M7_8252_19260 0.274500
R15929 n1_M7_8252_24060 n1_M7_8252_25660 0.091500
R15930 n1_M7_8252_25660 n1_M7_8252_32060 0.366000
R15931 n1_M7_8252_36060 n1_M7_8252_32060 0.228750
R15932 n1_M7_8252_36060 n1_M7_8252_38460 0.137250
R15933 n1_M7_8252_38460 n1_M7_8252_44860 0.366000
R15934 n1_M7_8252_48060 n1_M7_8252_44860 0.183000
R15935 n1_M7_8252_48060 n1_M7_8252_51260 0.183000
R15936 n1_M7_8252_51260 n1_M7_8252_57660 0.366000
R15937 n1_M7_8252_60060 n1_M7_8252_57660 0.137250
R15938 n1_M7_8252_60060 n1_M7_8252_64060 0.228750
R15939 n1_M7_8252_64060 n1_M7_8252_70460 0.366000
R15940 n1_M7_8252_72060 n1_M7_8252_70460 0.091500
R15941 n1_M7_8252_72060 n1_M7_8252_76860 0.274500
R15942 n1_M7_8252_76860 n1_M7_8252_83260 0.366000
R15943 n1_M7_8252_84060 n1_M7_8252_83260 0.045750
R15944 n1_M7_8252_84060 n1_M7_8252_89660 0.320250
R15945 n1_M7_8252_96060 n1_M7_8252_89660 0.366000
R15946 n1_M7_8252_96060 n1_M7_8252_102460 0.366000
R15947 n1_M7_8252_108060 n1_M7_8252_102460 0.320250
R15948 n1_M7_8252_108060 n1_M7_8252_108860 0.045750
R15949 n1_M7_8252_108860 n1_M7_8252_115260 0.366000
R15950 n1_M7_8252_120060 n1_M7_8252_115260 0.274500
R15951 n1_M7_8252_120060 n1_M7_8252_121660 0.091500
R15952 n1_M7_8252_121660 n1_M7_8252_128060 0.366000
R15953 n1_M7_12348_60 n1_M7_12348_6460 0.366000
R15954 n1_M7_12348_12060 n1_M7_12348_6460 0.320250
R15955 n1_M7_12348_12060 n1_M7_12348_12860 0.045750
R15956 n1_M7_12348_12860 n1_M7_12348_19260 0.366000
R15957 n1_M7_12348_24060 n1_M7_12348_19260 0.274500
R15958 n1_M7_12348_24060 n1_M7_12348_25660 0.091500
R15959 n1_M7_12348_25660 n1_M7_12348_32060 0.366000
R15960 n1_M7_12348_36060 n1_M7_12348_32060 0.228750
R15961 n1_M7_12348_36060 n1_M7_12348_38460 0.137250
R15962 n1_M7_12348_38460 n1_M7_12348_44860 0.366000
R15963 n1_M7_12348_48060 n1_M7_12348_44860 0.183000
R15964 n1_M7_12348_48060 n1_M7_12348_51260 0.183000
R15965 n1_M7_12348_51260 n1_M7_12348_57660 0.366000
R15966 n1_M7_12348_60060 n1_M7_12348_57660 0.137250
R15967 n1_M7_12348_60060 n1_M7_12348_64060 0.228750
R15968 n1_M7_12348_64060 n1_M7_12348_70460 0.366000
R15969 n1_M7_12348_72060 n1_M7_12348_70460 0.091500
R15970 n1_M7_12348_72060 n1_M7_12348_76860 0.274500
R15971 n1_M7_12348_76860 n1_M7_12348_83260 0.366000
R15972 n1_M7_12348_84060 n1_M7_12348_83260 0.045750
R15973 n1_M7_12348_84060 n1_M7_12348_89660 0.320250
R15974 n1_M7_12348_96060 n1_M7_12348_89660 0.366000
R15975 n1_M7_12348_96060 n1_M7_12348_102460 0.366000
R15976 n1_M7_12348_108060 n1_M7_12348_102460 0.320250
R15977 n1_M7_12348_108060 n1_M7_12348_108860 0.045750
R15978 n1_M7_12348_108860 n1_M7_12348_115260 0.366000
R15979 n1_M7_12348_120060 n1_M7_12348_115260 0.274500
R15980 n1_M7_12348_120060 n1_M7_12348_121660 0.091500
R15981 n1_M7_12348_121660 n1_M7_12348_128060 0.366000
R15982 n1_M7_16444_60 n1_M7_16444_6460 0.366000
R15983 n1_M7_16444_12060 n1_M7_16444_6460 0.320250
R15984 n1_M7_16444_12060 n1_M7_16444_12860 0.045750
R15985 n1_M7_16444_12860 n1_M7_16444_19260 0.366000
R15986 n1_M7_16444_24060 n1_M7_16444_19260 0.274500
R15987 n1_M7_16444_24060 n1_M7_16444_25660 0.091500
R15988 n1_M7_16444_25660 n1_M7_16444_32060 0.366000
R15989 n1_M7_16444_36060 n1_M7_16444_32060 0.228750
R15990 n1_M7_16444_36060 n1_M7_16444_38460 0.137250
R15991 n1_M7_16444_38460 n1_M7_16444_44860 0.366000
R15992 n1_M7_16444_48060 n1_M7_16444_44860 0.183000
R15993 n1_M7_16444_48060 n1_M7_16444_51260 0.183000
R15994 n1_M7_16444_51260 n1_M7_16444_57660 0.366000
R15995 n1_M7_16444_60060 n1_M7_16444_57660 0.137250
R15996 n1_M7_16444_60060 n1_M7_16444_64060 0.228750
R15997 n1_M7_16444_64060 n1_M7_16444_70460 0.366000
R15998 n1_M7_16444_72060 n1_M7_16444_70460 0.091500
R15999 n1_M7_16444_72060 n1_M7_16444_76860 0.274500
R16000 n1_M7_16444_76860 n1_M7_16444_83260 0.366000
R16001 n1_M7_16444_84060 n1_M7_16444_83260 0.045750
R16002 n1_M7_16444_84060 n1_M7_16444_89660 0.320250
R16003 n1_M7_16444_96060 n1_M7_16444_89660 0.366000
R16004 n1_M7_16444_96060 n1_M7_16444_102460 0.366000
R16005 n1_M7_16444_108060 n1_M7_16444_102460 0.320250
R16006 n1_M7_16444_108060 n1_M7_16444_108860 0.045750
R16007 n1_M7_16444_108860 n1_M7_16444_115260 0.366000
R16008 n1_M7_16444_120060 n1_M7_16444_115260 0.274500
R16009 n1_M7_16444_120060 n1_M7_16444_121660 0.091500
R16010 n1_M7_16444_121660 n1_M7_16444_128060 0.366000
R16011 n1_M7_20540_60 n1_M7_20540_6460 0.366000
R16012 n1_M7_20540_12060 n1_M7_20540_6460 0.320250
R16013 n1_M7_20540_12060 n1_M7_20540_12860 0.045750
R16014 n1_M7_20540_12860 n1_M7_20540_19260 0.366000
R16015 n1_M7_20540_24060 n1_M7_20540_19260 0.274500
R16016 n1_M7_20540_24060 n1_M7_20540_25660 0.091500
R16017 n1_M7_20540_25660 n1_M7_20540_32060 0.366000
R16018 n1_M7_20540_36060 n1_M7_20540_32060 0.228750
R16019 n1_M7_20540_36060 n1_M7_20540_38460 0.137250
R16020 n1_M7_20540_38460 n1_M7_20540_44860 0.366000
R16021 n1_M7_20540_48060 n1_M7_20540_44860 0.183000
R16022 n1_M7_20540_48060 n1_M7_20540_51260 0.183000
R16023 n1_M7_20540_51260 n1_M7_20540_57660 0.366000
R16024 n1_M7_20540_60060 n1_M7_20540_57660 0.137250
R16025 n1_M7_20540_60060 n1_M7_20540_64060 0.228750
R16026 n1_M7_20540_64060 n1_M7_20540_70460 0.366000
R16027 n1_M7_20540_72060 n1_M7_20540_70460 0.091500
R16028 n1_M7_20540_72060 n1_M7_20540_76860 0.274500
R16029 n1_M7_20540_76860 n1_M7_20540_83260 0.366000
R16030 n1_M7_20540_84060 n1_M7_20540_83260 0.045750
R16031 n1_M7_20540_84060 n1_M7_20540_89660 0.320250
R16032 n1_M7_20540_96060 n1_M7_20540_89660 0.366000
R16033 n1_M7_20540_96060 n1_M7_20540_102460 0.366000
R16034 n1_M7_20540_108060 n1_M7_20540_102460 0.320250
R16035 n1_M7_20540_108060 n1_M7_20540_108860 0.045750
R16036 n1_M7_20540_108860 n1_M7_20540_115260 0.366000
R16037 n1_M7_20540_120060 n1_M7_20540_115260 0.274500
R16038 n1_M7_20540_120060 n1_M7_20540_121660 0.091500
R16039 n1_M7_20540_121660 n1_M7_20540_128060 0.366000
R16040 n1_M7_24636_60 n1_M7_24636_6460 0.366000
R16041 n1_M7_24636_12060 n1_M7_24636_6460 0.320250
R16042 n1_M7_24636_12060 n1_M7_24636_12860 0.045750
R16043 n1_M7_24636_12860 n1_M7_24636_19260 0.366000
R16044 n1_M7_24636_24060 n1_M7_24636_19260 0.274500
R16045 n1_M7_24636_24060 n1_M7_24636_25660 0.091500
R16046 n1_M7_24636_25660 n1_M7_24636_32060 0.366000
R16047 n1_M7_24636_36060 n1_M7_24636_32060 0.228750
R16048 n1_M7_24636_36060 n1_M7_24636_38460 0.137250
R16049 n1_M7_24636_38460 n1_M7_24636_44860 0.366000
R16050 n1_M7_24636_48060 n1_M7_24636_44860 0.183000
R16051 n1_M7_24636_48060 n1_M7_24636_51260 0.183000
R16052 n1_M7_24636_51260 n1_M7_24636_57660 0.366000
R16053 n1_M7_24636_60060 n1_M7_24636_57660 0.137250
R16054 n1_M7_24636_60060 n1_M7_24636_64060 0.228750
R16055 n1_M7_24636_64060 n1_M7_24636_70460 0.366000
R16056 n1_M7_24636_72060 n1_M7_24636_70460 0.091500
R16057 n1_M7_24636_72060 n1_M7_24636_76860 0.274500
R16058 n1_M7_24636_76860 n1_M7_24636_83260 0.366000
R16059 n1_M7_24636_84060 n1_M7_24636_83260 0.045750
R16060 n1_M7_24636_84060 n1_M7_24636_89660 0.320250
R16061 n1_M7_24636_96060 n1_M7_24636_89660 0.366000
R16062 n1_M7_24636_96060 n1_M7_24636_102460 0.366000
R16063 n1_M7_24636_108060 n1_M7_24636_102460 0.320250
R16064 n1_M7_24636_108060 n1_M7_24636_108860 0.045750
R16065 n1_M7_24636_108860 n1_M7_24636_115260 0.366000
R16066 n1_M7_24636_120060 n1_M7_24636_115260 0.274500
R16067 n1_M7_24636_120060 n1_M7_24636_121660 0.091500
R16068 n1_M7_24636_121660 n1_M7_24636_128060 0.366000
R16069 n1_M7_28732_60 n1_M7_28732_6460 0.366000
R16070 n1_M7_28732_12060 n1_M7_28732_6460 0.320250
R16071 n1_M7_28732_12060 n1_M7_28732_12860 0.045750
R16072 n1_M7_28732_12860 n1_M7_28732_19260 0.366000
R16073 n1_M7_28732_24060 n1_M7_28732_19260 0.274500
R16074 n1_M7_28732_24060 n1_M7_28732_25660 0.091500
R16075 n1_M7_28732_25660 n1_M7_28732_32060 0.366000
R16076 n1_M7_28732_36060 n1_M7_28732_32060 0.228750
R16077 n1_M7_28732_36060 n1_M7_28732_38460 0.137250
R16078 n1_M7_28732_38460 n1_M7_28732_44860 0.366000
R16079 n1_M7_28732_48060 n1_M7_28732_44860 0.183000
R16080 n1_M7_28732_48060 n1_M7_28732_51260 0.183000
R16081 n1_M7_28732_51260 n1_M7_28732_57660 0.366000
R16082 n1_M7_28732_60060 n1_M7_28732_57660 0.137250
R16083 n1_M7_28732_60060 n1_M7_28732_64060 0.228750
R16084 n1_M7_28732_64060 n1_M7_28732_70460 0.366000
R16085 n1_M7_28732_72060 n1_M7_28732_70460 0.091500
R16086 n1_M7_28732_72060 n1_M7_28732_76860 0.274500
R16087 n1_M7_28732_76860 n1_M7_28732_83260 0.366000
R16088 n1_M7_28732_84060 n1_M7_28732_83260 0.045750
R16089 n1_M7_28732_84060 n1_M7_28732_89660 0.320250
R16090 n1_M7_28732_96060 n1_M7_28732_89660 0.366000
R16091 n1_M7_28732_96060 n1_M7_28732_102460 0.366000
R16092 n1_M7_28732_108060 n1_M7_28732_102460 0.320250
R16093 n1_M7_28732_108060 n1_M7_28732_108860 0.045750
R16094 n1_M7_28732_108860 n1_M7_28732_115260 0.366000
R16095 n1_M7_28732_120060 n1_M7_28732_115260 0.274500
R16096 n1_M7_28732_120060 n1_M7_28732_121660 0.091500
R16097 n1_M7_28732_121660 n1_M7_28732_128060 0.366000
R16098 n1_M7_32828_60 n1_M7_32828_6460 0.366000
R16099 n1_M7_32828_12060 n1_M7_32828_6460 0.320250
R16100 n1_M7_32828_12060 n1_M7_32828_12860 0.045750
R16101 n1_M7_32828_12860 n1_M7_32828_19260 0.366000
R16102 n1_M7_32828_24060 n1_M7_32828_19260 0.274500
R16103 n1_M7_32828_24060 n1_M7_32828_25660 0.091500
R16104 n1_M7_32828_25660 n1_M7_32828_32060 0.366000
R16105 n1_M7_32828_36060 n1_M7_32828_32060 0.228750
R16106 n1_M7_32828_36060 n1_M7_32828_38460 0.137250
R16107 n1_M7_32828_38460 n1_M7_32828_44860 0.366000
R16108 n1_M7_32828_48060 n1_M7_32828_44860 0.183000
R16109 n1_M7_32828_48060 n1_M7_32828_51260 0.183000
R16110 n1_M7_32828_51260 n1_M7_32828_57660 0.366000
R16111 n1_M7_32828_60060 n1_M7_32828_57660 0.137250
R16112 n1_M7_32828_60060 n1_M7_32828_64060 0.228750
R16113 n1_M7_32828_64060 n1_M7_32828_70460 0.366000
R16114 n1_M7_32828_72060 n1_M7_32828_70460 0.091500
R16115 n1_M7_32828_72060 n1_M7_32828_76860 0.274500
R16116 n1_M7_32828_76860 n1_M7_32828_83260 0.366000
R16117 n1_M7_32828_84060 n1_M7_32828_83260 0.045750
R16118 n1_M7_32828_84060 n1_M7_32828_89660 0.320250
R16119 n1_M7_32828_96060 n1_M7_32828_89660 0.366000
R16120 n1_M7_32828_96060 n1_M7_32828_102460 0.366000
R16121 n1_M7_32828_108060 n1_M7_32828_102460 0.320250
R16122 n1_M7_32828_108060 n1_M7_32828_108860 0.045750
R16123 n1_M7_32828_108860 n1_M7_32828_115260 0.366000
R16124 n1_M7_32828_120060 n1_M7_32828_115260 0.274500
R16125 n1_M7_32828_120060 n1_M7_32828_121660 0.091500
R16126 n1_M7_32828_121660 n1_M7_32828_128060 0.366000
R16127 n1_M7_36924_60 n1_M7_36924_6460 0.366000
R16128 n1_M7_36924_12060 n1_M7_36924_6460 0.320250
R16129 n1_M7_36924_12060 n1_M7_36924_12860 0.045750
R16130 n1_M7_36924_12860 n1_M7_36924_19260 0.366000
R16131 n1_M7_36924_24060 n1_M7_36924_19260 0.274500
R16132 n1_M7_36924_24060 n1_M7_36924_25660 0.091500
R16133 n1_M7_36924_25660 n1_M7_36924_32060 0.366000
R16134 n1_M7_36924_36060 n1_M7_36924_32060 0.228750
R16135 n1_M7_36924_36060 n1_M7_36924_38460 0.137250
R16136 n1_M7_36924_38460 n1_M7_36924_44860 0.366000
R16137 n1_M7_36924_48060 n1_M7_36924_44860 0.183000
R16138 n1_M7_36924_48060 n1_M7_36924_51260 0.183000
R16139 n1_M7_36924_51260 n1_M7_36924_57660 0.366000
R16140 n1_M7_36924_60060 n1_M7_36924_57660 0.137250
R16141 n1_M7_36924_60060 n1_M7_36924_64060 0.228750
R16142 n1_M7_36924_64060 n1_M7_36924_70460 0.366000
R16143 n1_M7_36924_72060 n1_M7_36924_70460 0.091500
R16144 n1_M7_36924_72060 n1_M7_36924_76860 0.274500
R16145 n1_M7_36924_76860 n1_M7_36924_83260 0.366000
R16146 n1_M7_36924_84060 n1_M7_36924_83260 0.045750
R16147 n1_M7_36924_84060 n1_M7_36924_89660 0.320250
R16148 n1_M7_36924_96060 n1_M7_36924_89660 0.366000
R16149 n1_M7_36924_96060 n1_M7_36924_102460 0.366000
R16150 n1_M7_36924_108060 n1_M7_36924_102460 0.320250
R16151 n1_M7_36924_108060 n1_M7_36924_108860 0.045750
R16152 n1_M7_36924_108860 n1_M7_36924_115260 0.366000
R16153 n1_M7_36924_120060 n1_M7_36924_115260 0.274500
R16154 n1_M7_36924_120060 n1_M7_36924_121660 0.091500
R16155 n1_M7_36924_121660 n1_M7_36924_128060 0.366000
R16156 n1_M7_41020_60 n1_M7_41020_6460 0.366000
R16157 n1_M7_41020_12060 n1_M7_41020_6460 0.320250
R16158 n1_M7_41020_12060 n1_M7_41020_12860 0.045750
R16159 n1_M7_41020_12860 n1_M7_41020_19260 0.366000
R16160 n1_M7_41020_24060 n1_M7_41020_19260 0.274500
R16161 n1_M7_41020_24060 n1_M7_41020_25660 0.091500
R16162 n1_M7_41020_25660 n1_M7_41020_32060 0.366000
R16163 n1_M7_41020_36060 n1_M7_41020_32060 0.228750
R16164 n1_M7_41020_36060 n1_M7_41020_38460 0.137250
R16165 n1_M7_41020_38460 n1_M7_41020_44860 0.366000
R16166 n1_M7_41020_48060 n1_M7_41020_44860 0.183000
R16167 n1_M7_41020_48060 n1_M7_41020_51260 0.183000
R16168 n1_M7_41020_51260 n1_M7_41020_57660 0.366000
R16169 n1_M7_41020_60060 n1_M7_41020_57660 0.137250
R16170 n1_M7_41020_60060 n1_M7_41020_64060 0.228750
R16171 n1_M7_41020_64060 n1_M7_41020_70460 0.366000
R16172 n1_M7_41020_72060 n1_M7_41020_70460 0.091500
R16173 n1_M7_41020_72060 n1_M7_41020_76860 0.274500
R16174 n1_M7_41020_76860 n1_M7_41020_83260 0.366000
R16175 n1_M7_41020_84060 n1_M7_41020_83260 0.045750
R16176 n1_M7_41020_84060 n1_M7_41020_89660 0.320250
R16177 n1_M7_41020_96060 n1_M7_41020_89660 0.366000
R16178 n1_M7_41020_96060 n1_M7_41020_102460 0.366000
R16179 n1_M7_41020_108060 n1_M7_41020_102460 0.320250
R16180 n1_M7_41020_108060 n1_M7_41020_108860 0.045750
R16181 n1_M7_41020_108860 n1_M7_41020_115260 0.366000
R16182 n1_M7_41020_120060 n1_M7_41020_115260 0.274500
R16183 n1_M7_41020_120060 n1_M7_41020_121660 0.091500
R16184 n1_M7_41020_121660 n1_M7_41020_128060 0.366000
R16185 n1_M7_45116_60 n1_M7_45116_6460 0.366000
R16186 n1_M7_45116_12060 n1_M7_45116_6460 0.320250
R16187 n1_M7_45116_12060 n1_M7_45116_12860 0.045750
R16188 n1_M7_45116_12860 n1_M7_45116_19260 0.366000
R16189 n1_M7_45116_24060 n1_M7_45116_19260 0.274500
R16190 n1_M7_45116_24060 n1_M7_45116_25660 0.091500
R16191 n1_M7_45116_25660 n1_M7_45116_32060 0.366000
R16192 n1_M7_45116_36060 n1_M7_45116_32060 0.228750
R16193 n1_M7_45116_36060 n1_M7_45116_38460 0.137250
R16194 n1_M7_45116_38460 n1_M7_45116_44860 0.366000
R16195 n1_M7_45116_48060 n1_M7_45116_44860 0.183000
R16196 n1_M7_45116_48060 n1_M7_45116_51260 0.183000
R16197 n1_M7_45116_51260 n1_M7_45116_57660 0.366000
R16198 n1_M7_45116_60060 n1_M7_45116_57660 0.137250
R16199 n1_M7_45116_60060 n1_M7_45116_64060 0.228750
R16200 n1_M7_45116_64060 n1_M7_45116_70460 0.366000
R16201 n1_M7_45116_72060 n1_M7_45116_70460 0.091500
R16202 n1_M7_45116_72060 n1_M7_45116_76860 0.274500
R16203 n1_M7_45116_76860 n1_M7_45116_83260 0.366000
R16204 n1_M7_45116_84060 n1_M7_45116_83260 0.045750
R16205 n1_M7_45116_84060 n1_M7_45116_89660 0.320250
R16206 n1_M7_45116_96060 n1_M7_45116_89660 0.366000
R16207 n1_M7_45116_96060 n1_M7_45116_102460 0.366000
R16208 n1_M7_45116_108060 n1_M7_45116_102460 0.320250
R16209 n1_M7_45116_108060 n1_M7_45116_108860 0.045750
R16210 n1_M7_45116_108860 n1_M7_45116_115260 0.366000
R16211 n1_M7_45116_120060 n1_M7_45116_115260 0.274500
R16212 n1_M7_45116_120060 n1_M7_45116_121660 0.091500
R16213 n1_M7_45116_121660 n1_M7_45116_128060 0.366000
R16214 n1_M7_49212_60 n1_M7_49212_6460 0.366000
R16215 n1_M7_49212_12060 n1_M7_49212_6460 0.320250
R16216 n1_M7_49212_12060 n1_M7_49212_12860 0.045750
R16217 n1_M7_49212_12860 n1_M7_49212_19260 0.366000
R16218 n1_M7_49212_24060 n1_M7_49212_19260 0.274500
R16219 n1_M7_49212_24060 n1_M7_49212_25660 0.091500
R16220 n1_M7_49212_25660 n1_M7_49212_32060 0.366000
R16221 n1_M7_49212_36060 n1_M7_49212_32060 0.228750
R16222 n1_M7_49212_36060 n1_M7_49212_38460 0.137250
R16223 n1_M7_49212_38460 n1_M7_49212_44860 0.366000
R16224 n1_M7_49212_48060 n1_M7_49212_44860 0.183000
R16225 n1_M7_49212_48060 n1_M7_49212_51260 0.183000
R16226 n1_M7_49212_51260 n1_M7_49212_57660 0.366000
R16227 n1_M7_49212_60060 n1_M7_49212_57660 0.137250
R16228 n1_M7_49212_60060 n1_M7_49212_64060 0.228750
R16229 n1_M7_49212_64060 n1_M7_49212_70460 0.366000
R16230 n1_M7_49212_72060 n1_M7_49212_70460 0.091500
R16231 n1_M7_49212_72060 n1_M7_49212_76860 0.274500
R16232 n1_M7_49212_76860 n1_M7_49212_83260 0.366000
R16233 n1_M7_49212_84060 n1_M7_49212_83260 0.045750
R16234 n1_M7_49212_84060 n1_M7_49212_89660 0.320250
R16235 n1_M7_49212_96060 n1_M7_49212_89660 0.366000
R16236 n1_M7_49212_96060 n1_M7_49212_102460 0.366000
R16237 n1_M7_49212_108060 n1_M7_49212_102460 0.320250
R16238 n1_M7_49212_108060 n1_M7_49212_108860 0.045750
R16239 n1_M7_49212_108860 n1_M7_49212_115260 0.366000
R16240 n1_M7_49212_120060 n1_M7_49212_115260 0.274500
R16241 n1_M7_49212_120060 n1_M7_49212_121660 0.091500
R16242 n1_M7_49212_121660 n1_M7_49212_128060 0.366000
R16243 n1_M7_53308_60 n1_M7_53308_6460 0.366000
R16244 n1_M7_53308_12060 n1_M7_53308_6460 0.320250
R16245 n1_M7_53308_12060 n1_M7_53308_12860 0.045750
R16246 n1_M7_53308_12860 n1_M7_53308_19260 0.366000
R16247 n1_M7_53308_24060 n1_M7_53308_19260 0.274500
R16248 n1_M7_53308_24060 n1_M7_53308_25660 0.091500
R16249 n1_M7_53308_25660 n1_M7_53308_32060 0.366000
R16250 n1_M7_53308_36060 n1_M7_53308_32060 0.228750
R16251 n1_M7_53308_36060 n1_M7_53308_38460 0.137250
R16252 n1_M7_53308_38460 n1_M7_53308_44860 0.366000
R16253 n1_M7_53308_48060 n1_M7_53308_44860 0.183000
R16254 n1_M7_53308_48060 n1_M7_53308_51260 0.183000
R16255 n1_M7_53308_51260 n1_M7_53308_57660 0.366000
R16256 n1_M7_53308_60060 n1_M7_53308_57660 0.137250
R16257 n1_M7_53308_60060 n1_M7_53308_64060 0.228750
R16258 n1_M7_53308_64060 n1_M7_53308_70460 0.366000
R16259 n1_M7_53308_72060 n1_M7_53308_70460 0.091500
R16260 n1_M7_53308_72060 n1_M7_53308_76860 0.274500
R16261 n1_M7_53308_76860 n1_M7_53308_83260 0.366000
R16262 n1_M7_53308_84060 n1_M7_53308_83260 0.045750
R16263 n1_M7_53308_84060 n1_M7_53308_89660 0.320250
R16264 n1_M7_53308_96060 n1_M7_53308_89660 0.366000
R16265 n1_M7_53308_96060 n1_M7_53308_102460 0.366000
R16266 n1_M7_53308_108060 n1_M7_53308_102460 0.320250
R16267 n1_M7_53308_108060 n1_M7_53308_108860 0.045750
R16268 n1_M7_53308_108860 n1_M7_53308_115260 0.366000
R16269 n1_M7_53308_120060 n1_M7_53308_115260 0.274500
R16270 n1_M7_53308_120060 n1_M7_53308_121660 0.091500
R16271 n1_M7_53308_121660 n1_M7_53308_128060 0.366000
R16272 n1_M7_57404_60 n1_M7_57404_6460 0.366000
R16273 n1_M7_57404_12060 n1_M7_57404_6460 0.320250
R16274 n1_M7_57404_12060 n1_M7_57404_12860 0.045750
R16275 n1_M7_57404_12860 n1_M7_57404_19260 0.366000
R16276 n1_M7_57404_24060 n1_M7_57404_19260 0.274500
R16277 n1_M7_57404_24060 n1_M7_57404_25660 0.091500
R16278 n1_M7_57404_25660 n1_M7_57404_32060 0.366000
R16279 n1_M7_57404_36060 n1_M7_57404_32060 0.228750
R16280 n1_M7_57404_36060 n1_M7_57404_38460 0.137250
R16281 n1_M7_57404_38460 n1_M7_57404_44860 0.366000
R16282 n1_M7_57404_48060 n1_M7_57404_44860 0.183000
R16283 n1_M7_57404_48060 n1_M7_57404_51260 0.183000
R16284 n1_M7_57404_51260 n1_M7_57404_57660 0.366000
R16285 n1_M7_57404_60060 n1_M7_57404_57660 0.137250
R16286 n1_M7_57404_60060 n1_M7_57404_64060 0.228750
R16287 n1_M7_57404_64060 n1_M7_57404_70460 0.366000
R16288 n1_M7_57404_72060 n1_M7_57404_70460 0.091500
R16289 n1_M7_57404_72060 n1_M7_57404_76860 0.274500
R16290 n1_M7_57404_76860 n1_M7_57404_83260 0.366000
R16291 n1_M7_57404_84060 n1_M7_57404_83260 0.045750
R16292 n1_M7_57404_84060 n1_M7_57404_89660 0.320250
R16293 n1_M7_57404_96060 n1_M7_57404_89660 0.366000
R16294 n1_M7_57404_96060 n1_M7_57404_102460 0.366000
R16295 n1_M7_57404_108060 n1_M7_57404_102460 0.320250
R16296 n1_M7_57404_108060 n1_M7_57404_108860 0.045750
R16297 n1_M7_57404_108860 n1_M7_57404_115260 0.366000
R16298 n1_M7_57404_120060 n1_M7_57404_115260 0.274500
R16299 n1_M7_57404_120060 n1_M7_57404_121660 0.091500
R16300 n1_M7_57404_121660 n1_M7_57404_128060 0.366000
R16301 n1_M7_61500_60 n1_M7_61500_6460 0.366000
R16302 n1_M7_61500_12060 n1_M7_61500_6460 0.320250
R16303 n1_M7_61500_12060 n1_M7_61500_12860 0.045750
R16304 n1_M7_61500_12860 n1_M7_61500_19260 0.366000
R16305 n1_M7_61500_24060 n1_M7_61500_19260 0.274500
R16306 n1_M7_61500_24060 n1_M7_61500_25660 0.091500
R16307 n1_M7_61500_25660 n1_M7_61500_32060 0.366000
R16308 n1_M7_61500_36060 n1_M7_61500_32060 0.228750
R16309 n1_M7_61500_36060 n1_M7_61500_38460 0.137250
R16310 n1_M7_61500_38460 n1_M7_61500_44860 0.366000
R16311 n1_M7_61500_48060 n1_M7_61500_44860 0.183000
R16312 n1_M7_61500_48060 n1_M7_61500_51260 0.183000
R16313 n1_M7_61500_51260 n1_M7_61500_57660 0.366000
R16314 n1_M7_61500_60060 n1_M7_61500_57660 0.137250
R16315 n1_M7_61500_60060 n1_M7_61500_64060 0.228750
R16316 n1_M7_61500_64060 n1_M7_61500_70460 0.366000
R16317 n1_M7_61500_72060 n1_M7_61500_70460 0.091500
R16318 n1_M7_61500_72060 n1_M7_61500_76860 0.274500
R16319 n1_M7_61500_76860 n1_M7_61500_83260 0.366000
R16320 n1_M7_61500_84060 n1_M7_61500_83260 0.045750
R16321 n1_M7_61500_84060 n1_M7_61500_89660 0.320250
R16322 n1_M7_61500_96060 n1_M7_61500_89660 0.366000
R16323 n1_M7_61500_96060 n1_M7_61500_102460 0.366000
R16324 n1_M7_61500_108060 n1_M7_61500_102460 0.320250
R16325 n1_M7_61500_108060 n1_M7_61500_108860 0.045750
R16326 n1_M7_61500_108860 n1_M7_61500_115260 0.366000
R16327 n1_M7_61500_120060 n1_M7_61500_115260 0.274500
R16328 n1_M7_61500_120060 n1_M7_61500_121660 0.091500
R16329 n1_M7_61500_121660 n1_M7_61500_128060 0.366000
R16330 n1_M7_65596_60 n1_M7_65596_6460 0.366000
R16331 n1_M7_65596_12060 n1_M7_65596_6460 0.320250
R16332 n1_M7_65596_12060 n1_M7_65596_12860 0.045750
R16333 n1_M7_65596_12860 n1_M7_65596_19260 0.366000
R16334 n1_M7_65596_24060 n1_M7_65596_19260 0.274500
R16335 n1_M7_65596_24060 n1_M7_65596_25660 0.091500
R16336 n1_M7_65596_25660 n1_M7_65596_32060 0.366000
R16337 n1_M7_65596_36060 n1_M7_65596_32060 0.228750
R16338 n1_M7_65596_36060 n1_M7_65596_38460 0.137250
R16339 n1_M7_65596_38460 n1_M7_65596_44860 0.366000
R16340 n1_M7_65596_48060 n1_M7_65596_44860 0.183000
R16341 n1_M7_65596_48060 n1_M7_65596_51260 0.183000
R16342 n1_M7_65596_51260 n1_M7_65596_57660 0.366000
R16343 n1_M7_65596_60060 n1_M7_65596_57660 0.137250
R16344 n1_M7_65596_60060 n1_M7_65596_64060 0.228750
R16345 n1_M7_65596_64060 n1_M7_65596_70460 0.366000
R16346 n1_M7_65596_72060 n1_M7_65596_70460 0.091500
R16347 n1_M7_65596_72060 n1_M7_65596_76860 0.274500
R16348 n1_M7_65596_76860 n1_M7_65596_83260 0.366000
R16349 n1_M7_65596_84060 n1_M7_65596_83260 0.045750
R16350 n1_M7_65596_84060 n1_M7_65596_89660 0.320250
R16351 n1_M7_65596_96060 n1_M7_65596_89660 0.366000
R16352 n1_M7_65596_96060 n1_M7_65596_102460 0.366000
R16353 n1_M7_65596_108060 n1_M7_65596_102460 0.320250
R16354 n1_M7_65596_108060 n1_M7_65596_108860 0.045750
R16355 n1_M7_65596_108860 n1_M7_65596_115260 0.366000
R16356 n1_M7_65596_120060 n1_M7_65596_115260 0.274500
R16357 n1_M7_65596_120060 n1_M7_65596_121660 0.091500
R16358 n1_M7_65596_121660 n1_M7_65596_128060 0.366000
R16359 n1_M7_69692_60 n1_M7_69692_6460 0.366000
R16360 n1_M7_69692_12060 n1_M7_69692_6460 0.320250
R16361 n1_M7_69692_12060 n1_M7_69692_12860 0.045750
R16362 n1_M7_69692_12860 n1_M7_69692_19260 0.366000
R16363 n1_M7_69692_24060 n1_M7_69692_19260 0.274500
R16364 n1_M7_69692_24060 n1_M7_69692_25660 0.091500
R16365 n1_M7_69692_25660 n1_M7_69692_32060 0.366000
R16366 n1_M7_69692_36060 n1_M7_69692_32060 0.228750
R16367 n1_M7_69692_36060 n1_M7_69692_38460 0.137250
R16368 n1_M7_69692_38460 n1_M7_69692_44860 0.366000
R16369 n1_M7_69692_48060 n1_M7_69692_44860 0.183000
R16370 n1_M7_69692_48060 n1_M7_69692_51260 0.183000
R16371 n1_M7_69692_51260 n1_M7_69692_57660 0.366000
R16372 n1_M7_69692_60060 n1_M7_69692_57660 0.137250
R16373 n1_M7_69692_60060 n1_M7_69692_64060 0.228750
R16374 n1_M7_69692_64060 n1_M7_69692_70460 0.366000
R16375 n1_M7_69692_72060 n1_M7_69692_70460 0.091500
R16376 n1_M7_69692_72060 n1_M7_69692_76860 0.274500
R16377 n1_M7_69692_76860 n1_M7_69692_83260 0.366000
R16378 n1_M7_69692_84060 n1_M7_69692_83260 0.045750
R16379 n1_M7_69692_84060 n1_M7_69692_89660 0.320250
R16380 n1_M7_69692_96060 n1_M7_69692_89660 0.366000
R16381 n1_M7_69692_96060 n1_M7_69692_102460 0.366000
R16382 n1_M7_69692_108060 n1_M7_69692_102460 0.320250
R16383 n1_M7_69692_108060 n1_M7_69692_108860 0.045750
R16384 n1_M7_69692_108860 n1_M7_69692_115260 0.366000
R16385 n1_M7_69692_120060 n1_M7_69692_115260 0.274500
R16386 n1_M7_69692_120060 n1_M7_69692_121660 0.091500
R16387 n1_M7_69692_121660 n1_M7_69692_128060 0.366000
R16388 n1_M7_73788_60 n1_M7_73788_6460 0.366000
R16389 n1_M7_73788_12060 n1_M7_73788_6460 0.320250
R16390 n1_M7_73788_12060 n1_M7_73788_12860 0.045750
R16391 n1_M7_73788_12860 n1_M7_73788_19260 0.366000
R16392 n1_M7_73788_24060 n1_M7_73788_19260 0.274500
R16393 n1_M7_73788_24060 n1_M7_73788_25660 0.091500
R16394 n1_M7_73788_25660 n1_M7_73788_32060 0.366000
R16395 n1_M7_73788_36060 n1_M7_73788_32060 0.228750
R16396 n1_M7_73788_36060 n1_M7_73788_38460 0.137250
R16397 n1_M7_73788_38460 n1_M7_73788_44860 0.366000
R16398 n1_M7_73788_48060 n1_M7_73788_44860 0.183000
R16399 n1_M7_73788_48060 n1_M7_73788_51260 0.183000
R16400 n1_M7_73788_51260 n1_M7_73788_57660 0.366000
R16401 n1_M7_73788_60060 n1_M7_73788_57660 0.137250
R16402 n1_M7_73788_60060 n1_M7_73788_64060 0.228750
R16403 n1_M7_73788_64060 n1_M7_73788_70460 0.366000
R16404 n1_M7_73788_72060 n1_M7_73788_70460 0.091500
R16405 n1_M7_73788_72060 n1_M7_73788_76860 0.274500
R16406 n1_M7_73788_76860 n1_M7_73788_83260 0.366000
R16407 n1_M7_73788_84060 n1_M7_73788_83260 0.045750
R16408 n1_M7_73788_84060 n1_M7_73788_89660 0.320250
R16409 n1_M7_73788_96060 n1_M7_73788_89660 0.366000
R16410 n1_M7_73788_96060 n1_M7_73788_102460 0.366000
R16411 n1_M7_73788_108060 n1_M7_73788_102460 0.320250
R16412 n1_M7_73788_108060 n1_M7_73788_108860 0.045750
R16413 n1_M7_73788_108860 n1_M7_73788_115260 0.366000
R16414 n1_M7_73788_120060 n1_M7_73788_115260 0.274500
R16415 n1_M7_73788_120060 n1_M7_73788_121660 0.091500
R16416 n1_M7_73788_121660 n1_M7_73788_128060 0.366000
R16417 n1_M7_77884_60 n1_M7_77884_6460 0.366000
R16418 n1_M7_77884_12060 n1_M7_77884_6460 0.320250
R16419 n1_M7_77884_12060 n1_M7_77884_12860 0.045750
R16420 n1_M7_77884_12860 n1_M7_77884_19260 0.366000
R16421 n1_M7_77884_24060 n1_M7_77884_19260 0.274500
R16422 n1_M7_77884_24060 n1_M7_77884_25660 0.091500
R16423 n1_M7_77884_25660 n1_M7_77884_32060 0.366000
R16424 n1_M7_77884_36060 n1_M7_77884_32060 0.228750
R16425 n1_M7_77884_36060 n1_M7_77884_38460 0.137250
R16426 n1_M7_77884_38460 n1_M7_77884_44860 0.366000
R16427 n1_M7_77884_48060 n1_M7_77884_44860 0.183000
R16428 n1_M7_77884_48060 n1_M7_77884_51260 0.183000
R16429 n1_M7_77884_51260 n1_M7_77884_57660 0.366000
R16430 n1_M7_77884_60060 n1_M7_77884_57660 0.137250
R16431 n1_M7_77884_60060 n1_M7_77884_64060 0.228750
R16432 n1_M7_77884_64060 n1_M7_77884_70460 0.366000
R16433 n1_M7_77884_72060 n1_M7_77884_70460 0.091500
R16434 n1_M7_77884_72060 n1_M7_77884_76860 0.274500
R16435 n1_M7_77884_76860 n1_M7_77884_83260 0.366000
R16436 n1_M7_77884_84060 n1_M7_77884_83260 0.045750
R16437 n1_M7_77884_84060 n1_M7_77884_89660 0.320250
R16438 n1_M7_77884_96060 n1_M7_77884_89660 0.366000
R16439 n1_M7_77884_96060 n1_M7_77884_102460 0.366000
R16440 n1_M7_77884_108060 n1_M7_77884_102460 0.320250
R16441 n1_M7_77884_108060 n1_M7_77884_108860 0.045750
R16442 n1_M7_77884_108860 n1_M7_77884_115260 0.366000
R16443 n1_M7_77884_120060 n1_M7_77884_115260 0.274500
R16444 n1_M7_77884_120060 n1_M7_77884_121660 0.091500
R16445 n1_M7_77884_121660 n1_M7_77884_128060 0.366000
R16446 n1_M7_81980_60 n1_M7_81980_6460 0.366000
R16447 n1_M7_81980_12060 n1_M7_81980_6460 0.320250
R16448 n1_M7_81980_12060 n1_M7_81980_12860 0.045750
R16449 n1_M7_81980_12860 n1_M7_81980_19260 0.366000
R16450 n1_M7_81980_24060 n1_M7_81980_19260 0.274500
R16451 n1_M7_81980_24060 n1_M7_81980_25660 0.091500
R16452 n1_M7_81980_25660 n1_M7_81980_32060 0.366000
R16453 n1_M7_81980_36060 n1_M7_81980_32060 0.228750
R16454 n1_M7_81980_36060 n1_M7_81980_38460 0.137250
R16455 n1_M7_81980_38460 n1_M7_81980_44860 0.366000
R16456 n1_M7_81980_48060 n1_M7_81980_44860 0.183000
R16457 n1_M7_81980_48060 n1_M7_81980_51260 0.183000
R16458 n1_M7_81980_51260 n1_M7_81980_57660 0.366000
R16459 n1_M7_81980_60060 n1_M7_81980_57660 0.137250
R16460 n1_M7_81980_60060 n1_M7_81980_64060 0.228750
R16461 n1_M7_81980_64060 n1_M7_81980_70460 0.366000
R16462 n1_M7_81980_72060 n1_M7_81980_70460 0.091500
R16463 n1_M7_81980_72060 n1_M7_81980_76860 0.274500
R16464 n1_M7_81980_76860 n1_M7_81980_83260 0.366000
R16465 n1_M7_81980_84060 n1_M7_81980_83260 0.045750
R16466 n1_M7_81980_84060 n1_M7_81980_89660 0.320250
R16467 n1_M7_81980_96060 n1_M7_81980_89660 0.366000
R16468 n1_M7_81980_96060 n1_M7_81980_102460 0.366000
R16469 n1_M7_81980_108060 n1_M7_81980_102460 0.320250
R16470 n1_M7_81980_108060 n1_M7_81980_108860 0.045750
R16471 n1_M7_81980_108860 n1_M7_81980_115260 0.366000
R16472 n1_M7_81980_120060 n1_M7_81980_115260 0.274500
R16473 n1_M7_81980_120060 n1_M7_81980_121660 0.091500
R16474 n1_M7_81980_121660 n1_M7_81980_128060 0.366000
R16475 n1_M7_86076_60 n1_M7_86076_6460 0.366000
R16476 n1_M7_86076_12060 n1_M7_86076_6460 0.320250
R16477 n1_M7_86076_12060 n1_M7_86076_12860 0.045750
R16478 n1_M7_86076_12860 n1_M7_86076_19260 0.366000
R16479 n1_M7_86076_24060 n1_M7_86076_19260 0.274500
R16480 n1_M7_86076_24060 n1_M7_86076_25660 0.091500
R16481 n1_M7_86076_25660 n1_M7_86076_32060 0.366000
R16482 n1_M7_86076_36060 n1_M7_86076_32060 0.228750
R16483 n1_M7_86076_36060 n1_M7_86076_38460 0.137250
R16484 n1_M7_86076_38460 n1_M7_86076_44860 0.366000
R16485 n1_M7_86076_48060 n1_M7_86076_44860 0.183000
R16486 n1_M7_86076_48060 n1_M7_86076_51260 0.183000
R16487 n1_M7_86076_51260 n1_M7_86076_57660 0.366000
R16488 n1_M7_86076_60060 n1_M7_86076_57660 0.137250
R16489 n1_M7_86076_60060 n1_M7_86076_64060 0.228750
R16490 n1_M7_86076_64060 n1_M7_86076_70460 0.366000
R16491 n1_M7_86076_72060 n1_M7_86076_70460 0.091500
R16492 n1_M7_86076_72060 n1_M7_86076_76860 0.274500
R16493 n1_M7_86076_76860 n1_M7_86076_83260 0.366000
R16494 n1_M7_86076_84060 n1_M7_86076_83260 0.045750
R16495 n1_M7_86076_84060 n1_M7_86076_89660 0.320250
R16496 n1_M7_86076_96060 n1_M7_86076_89660 0.366000
R16497 n1_M7_86076_96060 n1_M7_86076_102460 0.366000
R16498 n1_M7_86076_108060 n1_M7_86076_102460 0.320250
R16499 n1_M7_86076_108060 n1_M7_86076_108860 0.045750
R16500 n1_M7_86076_108860 n1_M7_86076_115260 0.366000
R16501 n1_M7_86076_120060 n1_M7_86076_115260 0.274500
R16502 n1_M7_86076_120060 n1_M7_86076_121660 0.091500
R16503 n1_M7_86076_121660 n1_M7_86076_128060 0.366000
R16504 n1_M7_90172_60 n1_M7_90172_6460 0.366000
R16505 n1_M7_90172_12060 n1_M7_90172_6460 0.320250
R16506 n1_M7_90172_12060 n1_M7_90172_12860 0.045750
R16507 n1_M7_90172_12860 n1_M7_90172_19260 0.366000
R16508 n1_M7_90172_24060 n1_M7_90172_19260 0.274500
R16509 n1_M7_90172_24060 n1_M7_90172_25660 0.091500
R16510 n1_M7_90172_25660 n1_M7_90172_32060 0.366000
R16511 n1_M7_90172_36060 n1_M7_90172_32060 0.228750
R16512 n1_M7_90172_36060 n1_M7_90172_38460 0.137250
R16513 n1_M7_90172_38460 n1_M7_90172_44860 0.366000
R16514 n1_M7_90172_48060 n1_M7_90172_44860 0.183000
R16515 n1_M7_90172_48060 n1_M7_90172_51260 0.183000
R16516 n1_M7_90172_51260 n1_M7_90172_57660 0.366000
R16517 n1_M7_90172_60060 n1_M7_90172_57660 0.137250
R16518 n1_M7_90172_60060 n1_M7_90172_64060 0.228750
R16519 n1_M7_90172_64060 n1_M7_90172_70460 0.366000
R16520 n1_M7_90172_72060 n1_M7_90172_70460 0.091500
R16521 n1_M7_90172_72060 n1_M7_90172_76860 0.274500
R16522 n1_M7_90172_76860 n1_M7_90172_83260 0.366000
R16523 n1_M7_90172_84060 n1_M7_90172_83260 0.045750
R16524 n1_M7_90172_84060 n1_M7_90172_89660 0.320250
R16525 n1_M7_90172_96060 n1_M7_90172_89660 0.366000
R16526 n1_M7_90172_96060 n1_M7_90172_102460 0.366000
R16527 n1_M7_90172_108060 n1_M7_90172_102460 0.320250
R16528 n1_M7_90172_108060 n1_M7_90172_108860 0.045750
R16529 n1_M7_90172_108860 n1_M7_90172_115260 0.366000
R16530 n1_M7_90172_120060 n1_M7_90172_115260 0.274500
R16531 n1_M7_90172_120060 n1_M7_90172_121660 0.091500
R16532 n1_M7_90172_121660 n1_M7_90172_128060 0.366000
R16533 n1_M7_94268_60 n1_M7_94268_6460 0.366000
R16534 n1_M7_94268_12060 n1_M7_94268_6460 0.320250
R16535 n1_M7_94268_12060 n1_M7_94268_12860 0.045750
R16536 n1_M7_94268_12860 n1_M7_94268_19260 0.366000
R16537 n1_M7_94268_24060 n1_M7_94268_19260 0.274500
R16538 n1_M7_94268_24060 n1_M7_94268_25660 0.091500
R16539 n1_M7_94268_25660 n1_M7_94268_32060 0.366000
R16540 n1_M7_94268_36060 n1_M7_94268_32060 0.228750
R16541 n1_M7_94268_36060 n1_M7_94268_38460 0.137250
R16542 n1_M7_94268_38460 n1_M7_94268_44860 0.366000
R16543 n1_M7_94268_48060 n1_M7_94268_44860 0.183000
R16544 n1_M7_94268_48060 n1_M7_94268_51260 0.183000
R16545 n1_M7_94268_51260 n1_M7_94268_57660 0.366000
R16546 n1_M7_94268_60060 n1_M7_94268_57660 0.137250
R16547 n1_M7_94268_60060 n1_M7_94268_64060 0.228750
R16548 n1_M7_94268_64060 n1_M7_94268_70460 0.366000
R16549 n1_M7_94268_72060 n1_M7_94268_70460 0.091500
R16550 n1_M7_94268_72060 n1_M7_94268_76860 0.274500
R16551 n1_M7_94268_76860 n1_M7_94268_83260 0.366000
R16552 n1_M7_94268_84060 n1_M7_94268_83260 0.045750
R16553 n1_M7_94268_84060 n1_M7_94268_89660 0.320250
R16554 n1_M7_94268_96060 n1_M7_94268_89660 0.366000
R16555 n1_M7_94268_96060 n1_M7_94268_102460 0.366000
R16556 n1_M7_94268_108060 n1_M7_94268_102460 0.320250
R16557 n1_M7_94268_108060 n1_M7_94268_108860 0.045750
R16558 n1_M7_94268_108860 n1_M7_94268_115260 0.366000
R16559 n1_M7_94268_120060 n1_M7_94268_115260 0.274500
R16560 n1_M7_94268_120060 n1_M7_94268_121660 0.091500
R16561 n1_M7_94268_121660 n1_M7_94268_128060 0.366000
R16562 n1_M7_98364_60 n1_M7_98364_6460 0.366000
R16563 n1_M7_98364_12060 n1_M7_98364_6460 0.320250
R16564 n1_M7_98364_12060 n1_M7_98364_12860 0.045750
R16565 n1_M7_98364_12860 n1_M7_98364_19260 0.366000
R16566 n1_M7_98364_24060 n1_M7_98364_19260 0.274500
R16567 n1_M7_98364_24060 n1_M7_98364_25660 0.091500
R16568 n1_M7_98364_25660 n1_M7_98364_32060 0.366000
R16569 n1_M7_98364_36060 n1_M7_98364_32060 0.228750
R16570 n1_M7_98364_36060 n1_M7_98364_38460 0.137250
R16571 n1_M7_98364_38460 n1_M7_98364_44860 0.366000
R16572 n1_M7_98364_48060 n1_M7_98364_44860 0.183000
R16573 n1_M7_98364_48060 n1_M7_98364_51260 0.183000
R16574 n1_M7_98364_51260 n1_M7_98364_57660 0.366000
R16575 n1_M7_98364_60060 n1_M7_98364_57660 0.137250
R16576 n1_M7_98364_60060 n1_M7_98364_64060 0.228750
R16577 n1_M7_98364_64060 n1_M7_98364_70460 0.366000
R16578 n1_M7_98364_72060 n1_M7_98364_70460 0.091500
R16579 n1_M7_98364_72060 n1_M7_98364_76860 0.274500
R16580 n1_M7_98364_76860 n1_M7_98364_83260 0.366000
R16581 n1_M7_98364_84060 n1_M7_98364_83260 0.045750
R16582 n1_M7_98364_84060 n1_M7_98364_89660 0.320250
R16583 n1_M7_98364_96060 n1_M7_98364_89660 0.366000
R16584 n1_M7_98364_96060 n1_M7_98364_102460 0.366000
R16585 n1_M7_98364_108060 n1_M7_98364_102460 0.320250
R16586 n1_M7_98364_108060 n1_M7_98364_108860 0.045750
R16587 n1_M7_98364_108860 n1_M7_98364_115260 0.366000
R16588 n1_M7_98364_120060 n1_M7_98364_115260 0.274500
R16589 n1_M7_98364_120060 n1_M7_98364_121660 0.091500
R16590 n1_M7_98364_121660 n1_M7_98364_128060 0.366000
R16591 n1_M7_102460_60 n1_M7_102460_6460 0.366000
R16592 n1_M7_102460_12060 n1_M7_102460_6460 0.320250
R16593 n1_M7_102460_12060 n1_M7_102460_12860 0.045750
R16594 n1_M7_102460_12860 n1_M7_102460_19260 0.366000
R16595 n1_M7_102460_24060 n1_M7_102460_19260 0.274500
R16596 n1_M7_102460_24060 n1_M7_102460_25660 0.091500
R16597 n1_M7_102460_25660 n1_M7_102460_32060 0.366000
R16598 n1_M7_102460_36060 n1_M7_102460_32060 0.228750
R16599 n1_M7_102460_36060 n1_M7_102460_38460 0.137250
R16600 n1_M7_102460_38460 n1_M7_102460_44860 0.366000
R16601 n1_M7_102460_48060 n1_M7_102460_44860 0.183000
R16602 n1_M7_102460_48060 n1_M7_102460_51260 0.183000
R16603 n1_M7_102460_51260 n1_M7_102460_57660 0.366000
R16604 n1_M7_102460_60060 n1_M7_102460_57660 0.137250
R16605 n1_M7_102460_60060 n1_M7_102460_64060 0.228750
R16606 n1_M7_102460_64060 n1_M7_102460_70460 0.366000
R16607 n1_M7_102460_72060 n1_M7_102460_70460 0.091500
R16608 n1_M7_102460_72060 n1_M7_102460_76860 0.274500
R16609 n1_M7_102460_76860 n1_M7_102460_83260 0.366000
R16610 n1_M7_102460_84060 n1_M7_102460_83260 0.045750
R16611 n1_M7_102460_84060 n1_M7_102460_89660 0.320250
R16612 n1_M7_102460_96060 n1_M7_102460_89660 0.366000
R16613 n1_M7_102460_96060 n1_M7_102460_102460 0.366000
R16614 n1_M7_102460_108060 n1_M7_102460_102460 0.320250
R16615 n1_M7_102460_108060 n1_M7_102460_108860 0.045750
R16616 n1_M7_102460_108860 n1_M7_102460_115260 0.366000
R16617 n1_M7_102460_120060 n1_M7_102460_115260 0.274500
R16618 n1_M7_102460_120060 n1_M7_102460_121660 0.091500
R16619 n1_M7_102460_121660 n1_M7_102460_128060 0.366000
R16620 n1_M7_106556_60 n1_M7_106556_6460 0.366000
R16621 n1_M7_106556_12060 n1_M7_106556_6460 0.320250
R16622 n1_M7_106556_12060 n1_M7_106556_12860 0.045750
R16623 n1_M7_106556_12860 n1_M7_106556_19260 0.366000
R16624 n1_M7_106556_24060 n1_M7_106556_19260 0.274500
R16625 n1_M7_106556_24060 n1_M7_106556_25660 0.091500
R16626 n1_M7_106556_25660 n1_M7_106556_32060 0.366000
R16627 n1_M7_106556_36060 n1_M7_106556_32060 0.228750
R16628 n1_M7_106556_36060 n1_M7_106556_38460 0.137250
R16629 n1_M7_106556_38460 n1_M7_106556_44860 0.366000
R16630 n1_M7_106556_48060 n1_M7_106556_44860 0.183000
R16631 n1_M7_106556_48060 n1_M7_106556_51260 0.183000
R16632 n1_M7_106556_51260 n1_M7_106556_57660 0.366000
R16633 n1_M7_106556_60060 n1_M7_106556_57660 0.137250
R16634 n1_M7_106556_60060 n1_M7_106556_64060 0.228750
R16635 n1_M7_106556_64060 n1_M7_106556_70460 0.366000
R16636 n1_M7_106556_72060 n1_M7_106556_70460 0.091500
R16637 n1_M7_106556_72060 n1_M7_106556_76860 0.274500
R16638 n1_M7_106556_76860 n1_M7_106556_83260 0.366000
R16639 n1_M7_106556_84060 n1_M7_106556_83260 0.045750
R16640 n1_M7_106556_84060 n1_M7_106556_89660 0.320250
R16641 n1_M7_106556_96060 n1_M7_106556_89660 0.366000
R16642 n1_M7_106556_96060 n1_M7_106556_102460 0.366000
R16643 n1_M7_106556_108060 n1_M7_106556_102460 0.320250
R16644 n1_M7_106556_108060 n1_M7_106556_108860 0.045750
R16645 n1_M7_106556_108860 n1_M7_106556_115260 0.366000
R16646 n1_M7_106556_120060 n1_M7_106556_115260 0.274500
R16647 n1_M7_106556_120060 n1_M7_106556_121660 0.091500
R16648 n1_M7_106556_121660 n1_M7_106556_128060 0.366000
R16649 n1_M7_110652_60 n1_M7_110652_6460 0.366000
R16650 n1_M7_110652_12060 n1_M7_110652_6460 0.320250
R16651 n1_M7_110652_12060 n1_M7_110652_12860 0.045750
R16652 n1_M7_110652_12860 n1_M7_110652_19260 0.366000
R16653 n1_M7_110652_24060 n1_M7_110652_19260 0.274500
R16654 n1_M7_110652_24060 n1_M7_110652_25660 0.091500
R16655 n1_M7_110652_25660 n1_M7_110652_32060 0.366000
R16656 n1_M7_110652_36060 n1_M7_110652_32060 0.228750
R16657 n1_M7_110652_36060 n1_M7_110652_38460 0.137250
R16658 n1_M7_110652_38460 n1_M7_110652_44860 0.366000
R16659 n1_M7_110652_48060 n1_M7_110652_44860 0.183000
R16660 n1_M7_110652_48060 n1_M7_110652_51260 0.183000
R16661 n1_M7_110652_51260 n1_M7_110652_57660 0.366000
R16662 n1_M7_110652_60060 n1_M7_110652_57660 0.137250
R16663 n1_M7_110652_60060 n1_M7_110652_64060 0.228750
R16664 n1_M7_110652_64060 n1_M7_110652_70460 0.366000
R16665 n1_M7_110652_72060 n1_M7_110652_70460 0.091500
R16666 n1_M7_110652_72060 n1_M7_110652_76860 0.274500
R16667 n1_M7_110652_76860 n1_M7_110652_83260 0.366000
R16668 n1_M7_110652_84060 n1_M7_110652_83260 0.045750
R16669 n1_M7_110652_84060 n1_M7_110652_89660 0.320250
R16670 n1_M7_110652_96060 n1_M7_110652_89660 0.366000
R16671 n1_M7_110652_96060 n1_M7_110652_102460 0.366000
R16672 n1_M7_110652_108060 n1_M7_110652_102460 0.320250
R16673 n1_M7_110652_108060 n1_M7_110652_108860 0.045750
R16674 n1_M7_110652_108860 n1_M7_110652_115260 0.366000
R16675 n1_M7_110652_120060 n1_M7_110652_115260 0.274500
R16676 n1_M7_110652_120060 n1_M7_110652_121660 0.091500
R16677 n1_M7_110652_121660 n1_M7_110652_128060 0.366000
R16678 n1_M7_114748_60 n1_M7_114748_6460 0.366000
R16679 n1_M7_114748_12060 n1_M7_114748_6460 0.320250
R16680 n1_M7_114748_12060 n1_M7_114748_12860 0.045750
R16681 n1_M7_114748_12860 n1_M7_114748_19260 0.366000
R16682 n1_M7_114748_24060 n1_M7_114748_19260 0.274500
R16683 n1_M7_114748_24060 n1_M7_114748_25660 0.091500
R16684 n1_M7_114748_25660 n1_M7_114748_32060 0.366000
R16685 n1_M7_114748_36060 n1_M7_114748_32060 0.228750
R16686 n1_M7_114748_36060 n1_M7_114748_38460 0.137250
R16687 n1_M7_114748_38460 n1_M7_114748_44860 0.366000
R16688 n1_M7_114748_48060 n1_M7_114748_44860 0.183000
R16689 n1_M7_114748_48060 n1_M7_114748_51260 0.183000
R16690 n1_M7_114748_51260 n1_M7_114748_57660 0.366000
R16691 n1_M7_114748_60060 n1_M7_114748_57660 0.137250
R16692 n1_M7_114748_60060 n1_M7_114748_64060 0.228750
R16693 n1_M7_114748_64060 n1_M7_114748_70460 0.366000
R16694 n1_M7_114748_72060 n1_M7_114748_70460 0.091500
R16695 n1_M7_114748_72060 n1_M7_114748_76860 0.274500
R16696 n1_M7_114748_76860 n1_M7_114748_83260 0.366000
R16697 n1_M7_114748_84060 n1_M7_114748_83260 0.045750
R16698 n1_M7_114748_84060 n1_M7_114748_89660 0.320250
R16699 n1_M7_114748_96060 n1_M7_114748_89660 0.366000
R16700 n1_M7_114748_96060 n1_M7_114748_102460 0.366000
R16701 n1_M7_114748_108060 n1_M7_114748_102460 0.320250
R16702 n1_M7_114748_108060 n1_M7_114748_108860 0.045750
R16703 n1_M7_114748_108860 n1_M7_114748_115260 0.366000
R16704 n1_M7_114748_120060 n1_M7_114748_115260 0.274500
R16705 n1_M7_114748_120060 n1_M7_114748_121660 0.091500
R16706 n1_M7_114748_121660 n1_M7_114748_128060 0.366000
R16707 n1_M7_118844_60 n1_M7_118844_6460 0.366000
R16708 n1_M7_118844_12060 n1_M7_118844_6460 0.320250
R16709 n1_M7_118844_12060 n1_M7_118844_12860 0.045750
R16710 n1_M7_118844_12860 n1_M7_118844_19260 0.366000
R16711 n1_M7_118844_24060 n1_M7_118844_19260 0.274500
R16712 n1_M7_118844_24060 n1_M7_118844_25660 0.091500
R16713 n1_M7_118844_25660 n1_M7_118844_32060 0.366000
R16714 n1_M7_118844_36060 n1_M7_118844_32060 0.228750
R16715 n1_M7_118844_36060 n1_M7_118844_38460 0.137250
R16716 n1_M7_118844_38460 n1_M7_118844_44860 0.366000
R16717 n1_M7_118844_48060 n1_M7_118844_44860 0.183000
R16718 n1_M7_118844_48060 n1_M7_118844_51260 0.183000
R16719 n1_M7_118844_51260 n1_M7_118844_57660 0.366000
R16720 n1_M7_118844_60060 n1_M7_118844_57660 0.137250
R16721 n1_M7_118844_60060 n1_M7_118844_64060 0.228750
R16722 n1_M7_118844_64060 n1_M7_118844_70460 0.366000
R16723 n1_M7_118844_72060 n1_M7_118844_70460 0.091500
R16724 n1_M7_118844_72060 n1_M7_118844_76860 0.274500
R16725 n1_M7_118844_76860 n1_M7_118844_83260 0.366000
R16726 n1_M7_118844_84060 n1_M7_118844_83260 0.045750
R16727 n1_M7_118844_84060 n1_M7_118844_89660 0.320250
R16728 n1_M7_118844_96060 n1_M7_118844_89660 0.366000
R16729 n1_M7_118844_96060 n1_M7_118844_102460 0.366000
R16730 n1_M7_118844_108060 n1_M7_118844_102460 0.320250
R16731 n1_M7_118844_108060 n1_M7_118844_108860 0.045750
R16732 n1_M7_118844_108860 n1_M7_118844_115260 0.366000
R16733 n1_M7_118844_120060 n1_M7_118844_115260 0.274500
R16734 n1_M7_118844_120060 n1_M7_118844_121660 0.091500
R16735 n1_M7_118844_121660 n1_M7_118844_128060 0.366000
R16736 n1_M7_122940_60 n1_M7_122940_6460 0.366000
R16737 n1_M7_122940_12060 n1_M7_122940_6460 0.320250
R16738 n1_M7_122940_12060 n1_M7_122940_12860 0.045750
R16739 n1_M7_122940_12860 n1_M7_122940_19260 0.366000
R16740 n1_M7_122940_24060 n1_M7_122940_19260 0.274500
R16741 n1_M7_122940_24060 n1_M7_122940_25660 0.091500
R16742 n1_M7_122940_25660 n1_M7_122940_32060 0.366000
R16743 n1_M7_122940_36060 n1_M7_122940_32060 0.228750
R16744 n1_M7_122940_36060 n1_M7_122940_38460 0.137250
R16745 n1_M7_122940_38460 n1_M7_122940_44860 0.366000
R16746 n1_M7_122940_48060 n1_M7_122940_44860 0.183000
R16747 n1_M7_122940_48060 n1_M7_122940_51260 0.183000
R16748 n1_M7_122940_51260 n1_M7_122940_57660 0.366000
R16749 n1_M7_122940_60060 n1_M7_122940_57660 0.137250
R16750 n1_M7_122940_60060 n1_M7_122940_64060 0.228750
R16751 n1_M7_122940_64060 n1_M7_122940_70460 0.366000
R16752 n1_M7_122940_72060 n1_M7_122940_70460 0.091500
R16753 n1_M7_122940_72060 n1_M7_122940_76860 0.274500
R16754 n1_M7_122940_76860 n1_M7_122940_83260 0.366000
R16755 n1_M7_122940_84060 n1_M7_122940_83260 0.045750
R16756 n1_M7_122940_84060 n1_M7_122940_89660 0.320250
R16757 n1_M7_122940_96060 n1_M7_122940_89660 0.366000
R16758 n1_M7_122940_96060 n1_M7_122940_102460 0.366000
R16759 n1_M7_122940_108060 n1_M7_122940_102460 0.320250
R16760 n1_M7_122940_108060 n1_M7_122940_108860 0.045750
R16761 n1_M7_122940_108860 n1_M7_122940_115260 0.366000
R16762 n1_M7_122940_120060 n1_M7_122940_115260 0.274500
R16763 n1_M7_122940_120060 n1_M7_122940_121660 0.091500
R16764 n1_M7_122940_121660 n1_M7_122940_128060 0.366000
R16765 n1_M7_127036_60 n1_M7_127036_6460 0.366000
R16766 n1_M7_127036_12060 n1_M7_127036_6460 0.320250
R16767 n1_M7_127036_12060 n1_M7_127036_12860 0.045750
R16768 n1_M7_127036_12860 n1_M7_127036_19260 0.366000
R16769 n1_M7_127036_24060 n1_M7_127036_19260 0.274500
R16770 n1_M7_127036_24060 n1_M7_127036_25660 0.091500
R16771 n1_M7_127036_25660 n1_M7_127036_32060 0.366000
R16772 n1_M7_127036_36060 n1_M7_127036_32060 0.228750
R16773 n1_M7_127036_36060 n1_M7_127036_38460 0.137250
R16774 n1_M7_127036_38460 n1_M7_127036_44860 0.366000
R16775 n1_M7_127036_48060 n1_M7_127036_44860 0.183000
R16776 n1_M7_127036_48060 n1_M7_127036_51260 0.183000
R16777 n1_M7_127036_51260 n1_M7_127036_57660 0.366000
R16778 n1_M7_127036_60060 n1_M7_127036_57660 0.137250
R16779 n1_M7_127036_60060 n1_M7_127036_64060 0.228750
R16780 n1_M7_127036_64060 n1_M7_127036_70460 0.366000
R16781 n1_M7_127036_72060 n1_M7_127036_70460 0.091500
R16782 n1_M7_127036_72060 n1_M7_127036_76860 0.274500
R16783 n1_M7_127036_76860 n1_M7_127036_83260 0.366000
R16784 n1_M7_127036_84060 n1_M7_127036_83260 0.045750
R16785 n1_M7_127036_84060 n1_M7_127036_89660 0.320250
R16786 n1_M7_127036_96060 n1_M7_127036_89660 0.366000
R16787 n1_M7_127036_96060 n1_M7_127036_102460 0.366000
R16788 n1_M7_127036_108060 n1_M7_127036_102460 0.320250
R16789 n1_M7_127036_108060 n1_M7_127036_108860 0.045750
R16790 n1_M7_127036_108860 n1_M7_127036_115260 0.366000
R16791 n1_M7_127036_120060 n1_M7_127036_115260 0.274500
R16792 n1_M7_127036_120060 n1_M7_127036_121660 0.091500
R16793 n1_M7_127036_121660 n1_M7_127036_128060 0.366000
R16794 n1_M8_60_60 n1_M8_1140_60 0.001755
R16795 n1_M8_1140_60 n1_M8_2220_60 0.001755
R16796 n1_M8_2220_60 n1_M8_3300_60 0.001755
R16797 n1_M8_3300_60 n1_M8_4380_60 0.001755
R16798 n1_M8_4380_60 n1_M8_5460_60 0.001755
R16799 n1_M8_5460_60 n1_M8_6540_60 0.001755
R16800 n1_M8_6540_60 n1_M8_7620_60 0.001755
R16801 n1_M8_7620_60 n1_M8_8700_60 0.001755
R16802 n1_M8_8700_60 n1_M8_9780_60 0.001755
R16803 n1_M8_9780_60 n1_M8_10860_60 0.001755
R16804 n1_M8_10860_60 n1_M8_11940_60 0.001755
R16805 n1_M8_11940_60 n1_M8_13020_60 0.001755
R16806 n1_M8_13020_60 n1_M8_14100_60 0.001755
R16807 n1_M8_14100_60 n1_M8_15180_60 0.001755
R16808 n1_M8_15180_60 n1_M8_16260_60 0.001755
R16809 n1_M8_16260_60 n1_M8_17340_60 0.001755
R16810 n1_M8_17340_60 n1_M8_18420_60 0.001755
R16811 n1_M8_18420_60 n1_M8_19500_60 0.001755
R16812 n1_M8_19500_60 n1_M8_20580_60 0.001755
R16813 n1_M8_20580_60 n1_M8_21660_60 0.001755
R16814 n1_M8_21660_60 n1_M8_22740_60 0.001755
R16815 n1_M8_22740_60 n1_M8_23820_60 0.001755
R16816 n1_M8_23820_60 n1_M8_24900_60 0.001755
R16817 n1_M8_24900_60 n1_M8_25980_60 0.001755
R16818 n1_M8_25980_60 n1_M8_27060_60 0.001755
R16819 n1_M8_27060_60 n1_M8_28140_60 0.001755
R16820 n1_M8_28140_60 n1_M8_29220_60 0.001755
R16821 n1_M8_29220_60 n1_M8_30300_60 0.001755
R16822 n1_M8_30300_60 n1_M8_31380_60 0.001755
R16823 n1_M8_31380_60 n1_M8_32460_60 0.001755
R16824 n1_M8_32460_60 n1_M8_33540_60 0.001755
R16825 n1_M8_33540_60 n1_M8_34620_60 0.001755
R16826 n1_M8_34620_60 n1_M8_35700_60 0.001755
R16827 n1_M8_35700_60 n1_M8_36780_60 0.001755
R16828 n1_M8_36780_60 n1_M8_37860_60 0.001755
R16829 n1_M8_37860_60 n1_M8_38940_60 0.001755
R16830 n1_M8_38940_60 n1_M8_40020_60 0.001755
R16831 n1_M8_40020_60 n1_M8_41100_60 0.001755
R16832 n1_M8_41100_60 n1_M8_42180_60 0.001755
R16833 n1_M8_42180_60 n1_M8_43260_60 0.001755
R16834 n1_M8_43260_60 n1_M8_44340_60 0.001755
R16835 n1_M8_44340_60 n1_M8_45420_60 0.001755
R16836 n1_M8_45420_60 n1_M8_46500_60 0.001755
R16837 n1_M8_46500_60 n1_M8_47580_60 0.001755
R16838 n1_M8_47580_60 n1_M8_48660_60 0.001755
R16839 n1_M8_48660_60 n1_M8_49740_60 0.001755
R16840 n1_M8_49740_60 n1_M8_50820_60 0.001755
R16841 n1_M8_50820_60 n1_M8_51900_60 0.001755
R16842 n1_M8_51900_60 n1_M8_52980_60 0.001755
R16843 n1_M8_52980_60 n1_M8_54060_60 0.001755
R16844 n1_M8_54060_60 n1_M8_55140_60 0.001755
R16845 n1_M8_55140_60 n1_M8_56220_60 0.001755
R16846 n1_M8_56220_60 n1_M8_57300_60 0.001755
R16847 n1_M8_57300_60 n1_M8_58380_60 0.001755
R16848 n1_M8_58380_60 n1_M8_59460_60 0.001755
R16849 n1_M8_59460_60 n1_M8_60540_60 0.001755
R16850 n1_M8_60540_60 n1_M8_61620_60 0.001755
R16851 n1_M8_61620_60 n1_M8_62700_60 0.001755
R16852 n1_M8_62700_60 n1_M8_63780_60 0.001755
R16853 n1_M8_63780_60 n1_M8_64860_60 0.001755
R16854 n1_M8_64860_60 n1_M8_65940_60 0.001755
R16855 n1_M8_65940_60 n1_M8_67020_60 0.001755
R16856 n1_M8_67020_60 n1_M8_68100_60 0.001755
R16857 n1_M8_68100_60 n1_M8_69180_60 0.001755
R16858 n1_M8_69180_60 n1_M8_70260_60 0.001755
R16859 n1_M8_70260_60 n1_M8_71340_60 0.001755
R16860 n1_M8_71340_60 n1_M8_72420_60 0.001755
R16861 n1_M8_72420_60 n1_M8_73500_60 0.001755
R16862 n1_M8_73500_60 n1_M8_74580_60 0.001755
R16863 n1_M8_74580_60 n1_M8_75660_60 0.001755
R16864 n1_M8_75660_60 n1_M8_76740_60 0.001755
R16865 n1_M8_76740_60 n1_M8_77820_60 0.001755
R16866 n1_M8_77820_60 n1_M8_78900_60 0.001755
R16867 n1_M8_78900_60 n1_M8_79980_60 0.001755
R16868 n1_M8_79980_60 n1_M8_81060_60 0.001755
R16869 n1_M8_81060_60 n1_M8_82140_60 0.001755
R16870 n1_M8_82140_60 n1_M8_83220_60 0.001755
R16871 n1_M8_83220_60 n1_M8_84300_60 0.001755
R16872 n1_M8_84300_60 n1_M8_85380_60 0.001755
R16873 n1_M8_85380_60 n1_M8_86460_60 0.001755
R16874 n1_M8_86460_60 n1_M8_87540_60 0.001755
R16875 n1_M8_87540_60 n1_M8_88620_60 0.001755
R16876 n1_M8_88620_60 n1_M8_89700_60 0.001755
R16877 n1_M8_89700_60 n1_M8_90780_60 0.001755
R16878 n1_M8_90780_60 n1_M8_91860_60 0.001755
R16879 n1_M8_91860_60 n1_M8_92940_60 0.001755
R16880 n1_M8_92940_60 n1_M8_94020_60 0.001755
R16881 n1_M8_94020_60 n1_M8_95100_60 0.001755
R16882 n1_M8_95100_60 n1_M8_96180_60 0.001755
R16883 n1_M8_96180_60 n1_M8_97260_60 0.001755
R16884 n1_M8_97260_60 n1_M8_98340_60 0.001755
R16885 n1_M8_98340_60 n1_M8_99420_60 0.001755
R16886 n1_M8_99420_60 n1_M8_100500_60 0.001755
R16887 n1_M8_100500_60 n1_M8_101580_60 0.001755
R16888 n1_M8_101580_60 n1_M8_102660_60 0.001755
R16889 n1_M8_102660_60 n1_M8_103740_60 0.001755
R16890 n1_M8_103740_60 n1_M8_104820_60 0.001755
R16891 n1_M8_104820_60 n1_M8_105900_60 0.001755
R16892 n1_M8_105900_60 n1_M8_106980_60 0.001755
R16893 n1_M8_106980_60 n1_M8_108060_60 0.001755
R16894 n1_M8_108060_60 n1_M8_109140_60 0.001755
R16895 n1_M8_109140_60 n1_M8_110220_60 0.001755
R16896 n1_M8_110220_60 n1_M8_111300_60 0.001755
R16897 n1_M8_111300_60 n1_M8_112380_60 0.001755
R16898 n1_M8_112380_60 n1_M8_113460_60 0.001755
R16899 n1_M8_113460_60 n1_M8_114540_60 0.001755
R16900 n1_M8_114540_60 n1_M8_115620_60 0.001755
R16901 n1_M8_115620_60 n1_M8_116700_60 0.001755
R16902 n1_M8_116700_60 n1_M8_117780_60 0.001755
R16903 n1_M8_117780_60 n1_M8_118860_60 0.001755
R16904 n1_M8_118860_60 n1_M8_119940_60 0.001755
R16905 n1_M8_119940_60 n1_M8_121020_60 0.001755
R16906 n1_M8_121020_60 n1_M8_122100_60 0.001755
R16907 n1_M8_122100_60 n1_M8_123180_60 0.001755
R16908 n1_M8_123180_60 n1_M8_124260_60 0.001755
R16909 n1_M8_124260_60 n1_M8_125340_60 0.001755
R16910 n1_M8_125340_60 n1_M8_126420_60 0.001755
R16911 n1_M8_126420_60 n1_M8_127500_60 0.001755
R16912 n1_M8_127500_60 n1_M8_128580_60 0.001755
R16913 n1_M8_128580_60 n1_M8_129660_60 0.001755
R16914 n1_M8_60_6460 n1_M8_1140_6460 0.001755
R16915 n1_M8_1140_6460 n1_M8_2220_6460 0.001755
R16916 n1_M8_2220_6460 n1_M8_3300_6460 0.001755
R16917 n1_M8_3300_6460 n1_M8_4380_6460 0.001755
R16918 n1_M8_4380_6460 n1_M8_5460_6460 0.001755
R16919 n1_M8_5460_6460 n1_M8_6540_6460 0.001755
R16920 n1_M8_6540_6460 n1_M8_7620_6460 0.001755
R16921 n1_M8_7620_6460 n1_M8_8700_6460 0.001755
R16922 n1_M8_8700_6460 n1_M8_9780_6460 0.001755
R16923 n1_M8_9780_6460 n1_M8_10860_6460 0.001755
R16924 n1_M8_10860_6460 n1_M8_11940_6460 0.001755
R16925 n1_M8_11940_6460 n1_M8_13020_6460 0.001755
R16926 n1_M8_13020_6460 n1_M8_14100_6460 0.001755
R16927 n1_M8_14100_6460 n1_M8_15180_6460 0.001755
R16928 n1_M8_15180_6460 n1_M8_16260_6460 0.001755
R16929 n1_M8_16260_6460 n1_M8_17340_6460 0.001755
R16930 n1_M8_17340_6460 n1_M8_18420_6460 0.001755
R16931 n1_M8_18420_6460 n1_M8_19500_6460 0.001755
R16932 n1_M8_19500_6460 n1_M8_20580_6460 0.001755
R16933 n1_M8_20580_6460 n1_M8_21660_6460 0.001755
R16934 n1_M8_21660_6460 n1_M8_22740_6460 0.001755
R16935 n1_M8_22740_6460 n1_M8_23820_6460 0.001755
R16936 n1_M8_23820_6460 n1_M8_24900_6460 0.001755
R16937 n1_M8_24900_6460 n1_M8_25980_6460 0.001755
R16938 n1_M8_25980_6460 n1_M8_27060_6460 0.001755
R16939 n1_M8_27060_6460 n1_M8_28140_6460 0.001755
R16940 n1_M8_28140_6460 n1_M8_29220_6460 0.001755
R16941 n1_M8_29220_6460 n1_M8_30300_6460 0.001755
R16942 n1_M8_30300_6460 n1_M8_31380_6460 0.001755
R16943 n1_M8_31380_6460 n1_M8_32460_6460 0.001755
R16944 n1_M8_32460_6460 n1_M8_33540_6460 0.001755
R16945 n1_M8_33540_6460 n1_M8_34620_6460 0.001755
R16946 n1_M8_34620_6460 n1_M8_35700_6460 0.001755
R16947 n1_M8_35700_6460 n1_M8_36780_6460 0.001755
R16948 n1_M8_36780_6460 n1_M8_37860_6460 0.001755
R16949 n1_M8_37860_6460 n1_M8_38940_6460 0.001755
R16950 n1_M8_38940_6460 n1_M8_40020_6460 0.001755
R16951 n1_M8_40020_6460 n1_M8_41100_6460 0.001755
R16952 n1_M8_41100_6460 n1_M8_42180_6460 0.001755
R16953 n1_M8_42180_6460 n1_M8_43260_6460 0.001755
R16954 n1_M8_43260_6460 n1_M8_44340_6460 0.001755
R16955 n1_M8_44340_6460 n1_M8_45420_6460 0.001755
R16956 n1_M8_45420_6460 n1_M8_46500_6460 0.001755
R16957 n1_M8_46500_6460 n1_M8_47580_6460 0.001755
R16958 n1_M8_47580_6460 n1_M8_48660_6460 0.001755
R16959 n1_M8_48660_6460 n1_M8_49740_6460 0.001755
R16960 n1_M8_49740_6460 n1_M8_50820_6460 0.001755
R16961 n1_M8_50820_6460 n1_M8_51900_6460 0.001755
R16962 n1_M8_51900_6460 n1_M8_52980_6460 0.001755
R16963 n1_M8_52980_6460 n1_M8_54060_6460 0.001755
R16964 n1_M8_54060_6460 n1_M8_55140_6460 0.001755
R16965 n1_M8_55140_6460 n1_M8_56220_6460 0.001755
R16966 n1_M8_56220_6460 n1_M8_57300_6460 0.001755
R16967 n1_M8_57300_6460 n1_M8_58380_6460 0.001755
R16968 n1_M8_58380_6460 n1_M8_59460_6460 0.001755
R16969 n1_M8_59460_6460 n1_M8_60540_6460 0.001755
R16970 n1_M8_60540_6460 n1_M8_61620_6460 0.001755
R16971 n1_M8_61620_6460 n1_M8_62700_6460 0.001755
R16972 n1_M8_62700_6460 n1_M8_63780_6460 0.001755
R16973 n1_M8_63780_6460 n1_M8_64860_6460 0.001755
R16974 n1_M8_64860_6460 n1_M8_65940_6460 0.001755
R16975 n1_M8_65940_6460 n1_M8_67020_6460 0.001755
R16976 n1_M8_67020_6460 n1_M8_68100_6460 0.001755
R16977 n1_M8_68100_6460 n1_M8_69180_6460 0.001755
R16978 n1_M8_69180_6460 n1_M8_70260_6460 0.001755
R16979 n1_M8_70260_6460 n1_M8_71340_6460 0.001755
R16980 n1_M8_71340_6460 n1_M8_72420_6460 0.001755
R16981 n1_M8_72420_6460 n1_M8_73500_6460 0.001755
R16982 n1_M8_73500_6460 n1_M8_74580_6460 0.001755
R16983 n1_M8_74580_6460 n1_M8_75660_6460 0.001755
R16984 n1_M8_75660_6460 n1_M8_76740_6460 0.001755
R16985 n1_M8_76740_6460 n1_M8_77820_6460 0.001755
R16986 n1_M8_77820_6460 n1_M8_78900_6460 0.001755
R16987 n1_M8_78900_6460 n1_M8_79980_6460 0.001755
R16988 n1_M8_79980_6460 n1_M8_81060_6460 0.001755
R16989 n1_M8_81060_6460 n1_M8_82140_6460 0.001755
R16990 n1_M8_82140_6460 n1_M8_83220_6460 0.001755
R16991 n1_M8_83220_6460 n1_M8_84300_6460 0.001755
R16992 n1_M8_84300_6460 n1_M8_85380_6460 0.001755
R16993 n1_M8_85380_6460 n1_M8_86460_6460 0.001755
R16994 n1_M8_86460_6460 n1_M8_87540_6460 0.001755
R16995 n1_M8_87540_6460 n1_M8_88620_6460 0.001755
R16996 n1_M8_88620_6460 n1_M8_89700_6460 0.001755
R16997 n1_M8_89700_6460 n1_M8_90780_6460 0.001755
R16998 n1_M8_90780_6460 n1_M8_91860_6460 0.001755
R16999 n1_M8_91860_6460 n1_M8_92940_6460 0.001755
R17000 n1_M8_92940_6460 n1_M8_94020_6460 0.001755
R17001 n1_M8_94020_6460 n1_M8_95100_6460 0.001755
R17002 n1_M8_95100_6460 n1_M8_96180_6460 0.001755
R17003 n1_M8_96180_6460 n1_M8_97260_6460 0.001755
R17004 n1_M8_97260_6460 n1_M8_98340_6460 0.001755
R17005 n1_M8_98340_6460 n1_M8_99420_6460 0.001755
R17006 n1_M8_99420_6460 n1_M8_100500_6460 0.001755
R17007 n1_M8_100500_6460 n1_M8_101580_6460 0.001755
R17008 n1_M8_101580_6460 n1_M8_102660_6460 0.001755
R17009 n1_M8_102660_6460 n1_M8_103740_6460 0.001755
R17010 n1_M8_103740_6460 n1_M8_104820_6460 0.001755
R17011 n1_M8_104820_6460 n1_M8_105900_6460 0.001755
R17012 n1_M8_105900_6460 n1_M8_106980_6460 0.001755
R17013 n1_M8_106980_6460 n1_M8_108060_6460 0.001755
R17014 n1_M8_108060_6460 n1_M8_109140_6460 0.001755
R17015 n1_M8_109140_6460 n1_M8_110220_6460 0.001755
R17016 n1_M8_110220_6460 n1_M8_111300_6460 0.001755
R17017 n1_M8_111300_6460 n1_M8_112380_6460 0.001755
R17018 n1_M8_112380_6460 n1_M8_113460_6460 0.001755
R17019 n1_M8_113460_6460 n1_M8_114540_6460 0.001755
R17020 n1_M8_114540_6460 n1_M8_115620_6460 0.001755
R17021 n1_M8_115620_6460 n1_M8_116700_6460 0.001755
R17022 n1_M8_116700_6460 n1_M8_117780_6460 0.001755
R17023 n1_M8_117780_6460 n1_M8_118860_6460 0.001755
R17024 n1_M8_118860_6460 n1_M8_119940_6460 0.001755
R17025 n1_M8_119940_6460 n1_M8_121020_6460 0.001755
R17026 n1_M8_121020_6460 n1_M8_122100_6460 0.001755
R17027 n1_M8_122100_6460 n1_M8_123180_6460 0.001755
R17028 n1_M8_123180_6460 n1_M8_124260_6460 0.001755
R17029 n1_M8_124260_6460 n1_M8_125340_6460 0.001755
R17030 n1_M8_125340_6460 n1_M8_126420_6460 0.001755
R17031 n1_M8_126420_6460 n1_M8_127500_6460 0.001755
R17032 n1_M8_127500_6460 n1_M8_128580_6460 0.001755
R17033 n1_M8_128580_6460 n1_M8_129660_6460 0.001755
R17034 n1_M8_60_12860 n1_M8_1140_12860 0.001755
R17035 n1_M8_1140_12860 n1_M8_2220_12860 0.001755
R17036 n1_M8_2220_12860 n1_M8_3300_12860 0.001755
R17037 n1_M8_3300_12860 n1_M8_4380_12860 0.001755
R17038 n1_M8_4380_12860 n1_M8_5460_12860 0.001755
R17039 n1_M8_5460_12860 n1_M8_6540_12860 0.001755
R17040 n1_M8_6540_12860 n1_M8_7620_12860 0.001755
R17041 n1_M8_7620_12860 n1_M8_8700_12860 0.001755
R17042 n1_M8_8700_12860 n1_M8_9780_12860 0.001755
R17043 n1_M8_9780_12860 n1_M8_10860_12860 0.001755
R17044 n1_M8_10860_12860 n1_M8_11940_12860 0.001755
R17045 n1_M8_11940_12860 n1_M8_13020_12860 0.001755
R17046 n1_M8_13020_12860 n1_M8_14100_12860 0.001755
R17047 n1_M8_14100_12860 n1_M8_15180_12860 0.001755
R17048 n1_M8_15180_12860 n1_M8_16260_12860 0.001755
R17049 n1_M8_16260_12860 n1_M8_17340_12860 0.001755
R17050 n1_M8_17340_12860 n1_M8_18420_12860 0.001755
R17051 n1_M8_18420_12860 n1_M8_19500_12860 0.001755
R17052 n1_M8_19500_12860 n1_M8_20580_12860 0.001755
R17053 n1_M8_20580_12860 n1_M8_21660_12860 0.001755
R17054 n1_M8_21660_12860 n1_M8_22740_12860 0.001755
R17055 n1_M8_22740_12860 n1_M8_23820_12860 0.001755
R17056 n1_M8_23820_12860 n1_M8_24900_12860 0.001755
R17057 n1_M8_24900_12860 n1_M8_25980_12860 0.001755
R17058 n1_M8_25980_12860 n1_M8_27060_12860 0.001755
R17059 n1_M8_27060_12860 n1_M8_28140_12860 0.001755
R17060 n1_M8_28140_12860 n1_M8_29220_12860 0.001755
R17061 n1_M8_29220_12860 n1_M8_30300_12860 0.001755
R17062 n1_M8_30300_12860 n1_M8_31380_12860 0.001755
R17063 n1_M8_31380_12860 n1_M8_32460_12860 0.001755
R17064 n1_M8_32460_12860 n1_M8_33540_12860 0.001755
R17065 n1_M8_33540_12860 n1_M8_34620_12860 0.001755
R17066 n1_M8_34620_12860 n1_M8_35700_12860 0.001755
R17067 n1_M8_35700_12860 n1_M8_36780_12860 0.001755
R17068 n1_M8_36780_12860 n1_M8_37860_12860 0.001755
R17069 n1_M8_37860_12860 n1_M8_38940_12860 0.001755
R17070 n1_M8_38940_12860 n1_M8_40020_12860 0.001755
R17071 n1_M8_40020_12860 n1_M8_41100_12860 0.001755
R17072 n1_M8_41100_12860 n1_M8_42180_12860 0.001755
R17073 n1_M8_42180_12860 n1_M8_43260_12860 0.001755
R17074 n1_M8_43260_12860 n1_M8_44340_12860 0.001755
R17075 n1_M8_44340_12860 n1_M8_45420_12860 0.001755
R17076 n1_M8_45420_12860 n1_M8_46500_12860 0.001755
R17077 n1_M8_46500_12860 n1_M8_47580_12860 0.001755
R17078 n1_M8_47580_12860 n1_M8_48660_12860 0.001755
R17079 n1_M8_48660_12860 n1_M8_49740_12860 0.001755
R17080 n1_M8_49740_12860 n1_M8_50820_12860 0.001755
R17081 n1_M8_50820_12860 n1_M8_51900_12860 0.001755
R17082 n1_M8_51900_12860 n1_M8_52980_12860 0.001755
R17083 n1_M8_52980_12860 n1_M8_54060_12860 0.001755
R17084 n1_M8_54060_12860 n1_M8_55140_12860 0.001755
R17085 n1_M8_55140_12860 n1_M8_56220_12860 0.001755
R17086 n1_M8_56220_12860 n1_M8_57300_12860 0.001755
R17087 n1_M8_57300_12860 n1_M8_58380_12860 0.001755
R17088 n1_M8_58380_12860 n1_M8_59460_12860 0.001755
R17089 n1_M8_59460_12860 n1_M8_60540_12860 0.001755
R17090 n1_M8_60540_12860 n1_M8_61620_12860 0.001755
R17091 n1_M8_61620_12860 n1_M8_62700_12860 0.001755
R17092 n1_M8_62700_12860 n1_M8_63780_12860 0.001755
R17093 n1_M8_63780_12860 n1_M8_64860_12860 0.001755
R17094 n1_M8_64860_12860 n1_M8_65940_12860 0.001755
R17095 n1_M8_65940_12860 n1_M8_67020_12860 0.001755
R17096 n1_M8_67020_12860 n1_M8_68100_12860 0.001755
R17097 n1_M8_68100_12860 n1_M8_69180_12860 0.001755
R17098 n1_M8_69180_12860 n1_M8_70260_12860 0.001755
R17099 n1_M8_70260_12860 n1_M8_71340_12860 0.001755
R17100 n1_M8_71340_12860 n1_M8_72420_12860 0.001755
R17101 n1_M8_72420_12860 n1_M8_73500_12860 0.001755
R17102 n1_M8_73500_12860 n1_M8_74580_12860 0.001755
R17103 n1_M8_74580_12860 n1_M8_75660_12860 0.001755
R17104 n1_M8_75660_12860 n1_M8_76740_12860 0.001755
R17105 n1_M8_76740_12860 n1_M8_77820_12860 0.001755
R17106 n1_M8_77820_12860 n1_M8_78900_12860 0.001755
R17107 n1_M8_78900_12860 n1_M8_79980_12860 0.001755
R17108 n1_M8_79980_12860 n1_M8_81060_12860 0.001755
R17109 n1_M8_81060_12860 n1_M8_82140_12860 0.001755
R17110 n1_M8_82140_12860 n1_M8_83220_12860 0.001755
R17111 n1_M8_83220_12860 n1_M8_84300_12860 0.001755
R17112 n1_M8_84300_12860 n1_M8_85380_12860 0.001755
R17113 n1_M8_85380_12860 n1_M8_86460_12860 0.001755
R17114 n1_M8_86460_12860 n1_M8_87540_12860 0.001755
R17115 n1_M8_87540_12860 n1_M8_88620_12860 0.001755
R17116 n1_M8_88620_12860 n1_M8_89700_12860 0.001755
R17117 n1_M8_89700_12860 n1_M8_90780_12860 0.001755
R17118 n1_M8_90780_12860 n1_M8_91860_12860 0.001755
R17119 n1_M8_91860_12860 n1_M8_92940_12860 0.001755
R17120 n1_M8_92940_12860 n1_M8_94020_12860 0.001755
R17121 n1_M8_94020_12860 n1_M8_95100_12860 0.001755
R17122 n1_M8_95100_12860 n1_M8_96180_12860 0.001755
R17123 n1_M8_96180_12860 n1_M8_97260_12860 0.001755
R17124 n1_M8_97260_12860 n1_M8_98340_12860 0.001755
R17125 n1_M8_98340_12860 n1_M8_99420_12860 0.001755
R17126 n1_M8_99420_12860 n1_M8_100500_12860 0.001755
R17127 n1_M8_100500_12860 n1_M8_101580_12860 0.001755
R17128 n1_M8_101580_12860 n1_M8_102660_12860 0.001755
R17129 n1_M8_102660_12860 n1_M8_103740_12860 0.001755
R17130 n1_M8_103740_12860 n1_M8_104820_12860 0.001755
R17131 n1_M8_104820_12860 n1_M8_105900_12860 0.001755
R17132 n1_M8_105900_12860 n1_M8_106980_12860 0.001755
R17133 n1_M8_106980_12860 n1_M8_108060_12860 0.001755
R17134 n1_M8_108060_12860 n1_M8_109140_12860 0.001755
R17135 n1_M8_109140_12860 n1_M8_110220_12860 0.001755
R17136 n1_M8_110220_12860 n1_M8_111300_12860 0.001755
R17137 n1_M8_111300_12860 n1_M8_112380_12860 0.001755
R17138 n1_M8_112380_12860 n1_M8_113460_12860 0.001755
R17139 n1_M8_113460_12860 n1_M8_114540_12860 0.001755
R17140 n1_M8_114540_12860 n1_M8_115620_12860 0.001755
R17141 n1_M8_115620_12860 n1_M8_116700_12860 0.001755
R17142 n1_M8_116700_12860 n1_M8_117780_12860 0.001755
R17143 n1_M8_117780_12860 n1_M8_118860_12860 0.001755
R17144 n1_M8_118860_12860 n1_M8_119940_12860 0.001755
R17145 n1_M8_119940_12860 n1_M8_121020_12860 0.001755
R17146 n1_M8_121020_12860 n1_M8_122100_12860 0.001755
R17147 n1_M8_122100_12860 n1_M8_123180_12860 0.001755
R17148 n1_M8_123180_12860 n1_M8_124260_12860 0.001755
R17149 n1_M8_124260_12860 n1_M8_125340_12860 0.001755
R17150 n1_M8_125340_12860 n1_M8_126420_12860 0.001755
R17151 n1_M8_126420_12860 n1_M8_127500_12860 0.001755
R17152 n1_M8_127500_12860 n1_M8_128580_12860 0.001755
R17153 n1_M8_128580_12860 n1_M8_129660_12860 0.001755
R17154 n1_M8_60_19260 n1_M8_1140_19260 0.001755
R17155 n1_M8_1140_19260 n1_M8_2220_19260 0.001755
R17156 n1_M8_2220_19260 n1_M8_3300_19260 0.001755
R17157 n1_M8_3300_19260 n1_M8_4380_19260 0.001755
R17158 n1_M8_4380_19260 n1_M8_5460_19260 0.001755
R17159 n1_M8_5460_19260 n1_M8_6540_19260 0.001755
R17160 n1_M8_6540_19260 n1_M8_7620_19260 0.001755
R17161 n1_M8_7620_19260 n1_M8_8700_19260 0.001755
R17162 n1_M8_8700_19260 n1_M8_9780_19260 0.001755
R17163 n1_M8_9780_19260 n1_M8_10860_19260 0.001755
R17164 n1_M8_10860_19260 n1_M8_11940_19260 0.001755
R17165 n1_M8_11940_19260 n1_M8_13020_19260 0.001755
R17166 n1_M8_13020_19260 n1_M8_14100_19260 0.001755
R17167 n1_M8_14100_19260 n1_M8_15180_19260 0.001755
R17168 n1_M8_15180_19260 n1_M8_16260_19260 0.001755
R17169 n1_M8_16260_19260 n1_M8_17340_19260 0.001755
R17170 n1_M8_17340_19260 n1_M8_18420_19260 0.001755
R17171 n1_M8_18420_19260 n1_M8_19500_19260 0.001755
R17172 n1_M8_19500_19260 n1_M8_20580_19260 0.001755
R17173 n1_M8_20580_19260 n1_M8_21660_19260 0.001755
R17174 n1_M8_21660_19260 n1_M8_22740_19260 0.001755
R17175 n1_M8_22740_19260 n1_M8_23820_19260 0.001755
R17176 n1_M8_23820_19260 n1_M8_24900_19260 0.001755
R17177 n1_M8_24900_19260 n1_M8_25980_19260 0.001755
R17178 n1_M8_25980_19260 n1_M8_27060_19260 0.001755
R17179 n1_M8_27060_19260 n1_M8_28140_19260 0.001755
R17180 n1_M8_28140_19260 n1_M8_29220_19260 0.001755
R17181 n1_M8_29220_19260 n1_M8_30300_19260 0.001755
R17182 n1_M8_30300_19260 n1_M8_31380_19260 0.001755
R17183 n1_M8_31380_19260 n1_M8_32460_19260 0.001755
R17184 n1_M8_32460_19260 n1_M8_33540_19260 0.001755
R17185 n1_M8_33540_19260 n1_M8_34620_19260 0.001755
R17186 n1_M8_34620_19260 n1_M8_35700_19260 0.001755
R17187 n1_M8_35700_19260 n1_M8_36780_19260 0.001755
R17188 n1_M8_36780_19260 n1_M8_37860_19260 0.001755
R17189 n1_M8_37860_19260 n1_M8_38940_19260 0.001755
R17190 n1_M8_38940_19260 n1_M8_40020_19260 0.001755
R17191 n1_M8_40020_19260 n1_M8_41100_19260 0.001755
R17192 n1_M8_41100_19260 n1_M8_42180_19260 0.001755
R17193 n1_M8_42180_19260 n1_M8_43260_19260 0.001755
R17194 n1_M8_43260_19260 n1_M8_44340_19260 0.001755
R17195 n1_M8_44340_19260 n1_M8_45420_19260 0.001755
R17196 n1_M8_45420_19260 n1_M8_46500_19260 0.001755
R17197 n1_M8_46500_19260 n1_M8_47580_19260 0.001755
R17198 n1_M8_47580_19260 n1_M8_48660_19260 0.001755
R17199 n1_M8_48660_19260 n1_M8_49740_19260 0.001755
R17200 n1_M8_49740_19260 n1_M8_50820_19260 0.001755
R17201 n1_M8_50820_19260 n1_M8_51900_19260 0.001755
R17202 n1_M8_51900_19260 n1_M8_52980_19260 0.001755
R17203 n1_M8_52980_19260 n1_M8_54060_19260 0.001755
R17204 n1_M8_54060_19260 n1_M8_55140_19260 0.001755
R17205 n1_M8_55140_19260 n1_M8_56220_19260 0.001755
R17206 n1_M8_56220_19260 n1_M8_57300_19260 0.001755
R17207 n1_M8_57300_19260 n1_M8_58380_19260 0.001755
R17208 n1_M8_58380_19260 n1_M8_59460_19260 0.001755
R17209 n1_M8_59460_19260 n1_M8_60540_19260 0.001755
R17210 n1_M8_60540_19260 n1_M8_61620_19260 0.001755
R17211 n1_M8_61620_19260 n1_M8_62700_19260 0.001755
R17212 n1_M8_62700_19260 n1_M8_63780_19260 0.001755
R17213 n1_M8_63780_19260 n1_M8_64860_19260 0.001755
R17214 n1_M8_64860_19260 n1_M8_65940_19260 0.001755
R17215 n1_M8_65940_19260 n1_M8_67020_19260 0.001755
R17216 n1_M8_67020_19260 n1_M8_68100_19260 0.001755
R17217 n1_M8_68100_19260 n1_M8_69180_19260 0.001755
R17218 n1_M8_69180_19260 n1_M8_70260_19260 0.001755
R17219 n1_M8_70260_19260 n1_M8_71340_19260 0.001755
R17220 n1_M8_71340_19260 n1_M8_72420_19260 0.001755
R17221 n1_M8_72420_19260 n1_M8_73500_19260 0.001755
R17222 n1_M8_73500_19260 n1_M8_74580_19260 0.001755
R17223 n1_M8_74580_19260 n1_M8_75660_19260 0.001755
R17224 n1_M8_75660_19260 n1_M8_76740_19260 0.001755
R17225 n1_M8_76740_19260 n1_M8_77820_19260 0.001755
R17226 n1_M8_77820_19260 n1_M8_78900_19260 0.001755
R17227 n1_M8_78900_19260 n1_M8_79980_19260 0.001755
R17228 n1_M8_79980_19260 n1_M8_81060_19260 0.001755
R17229 n1_M8_81060_19260 n1_M8_82140_19260 0.001755
R17230 n1_M8_82140_19260 n1_M8_83220_19260 0.001755
R17231 n1_M8_83220_19260 n1_M8_84300_19260 0.001755
R17232 n1_M8_84300_19260 n1_M8_85380_19260 0.001755
R17233 n1_M8_85380_19260 n1_M8_86460_19260 0.001755
R17234 n1_M8_86460_19260 n1_M8_87540_19260 0.001755
R17235 n1_M8_87540_19260 n1_M8_88620_19260 0.001755
R17236 n1_M8_88620_19260 n1_M8_89700_19260 0.001755
R17237 n1_M8_89700_19260 n1_M8_90780_19260 0.001755
R17238 n1_M8_90780_19260 n1_M8_91860_19260 0.001755
R17239 n1_M8_91860_19260 n1_M8_92940_19260 0.001755
R17240 n1_M8_92940_19260 n1_M8_94020_19260 0.001755
R17241 n1_M8_94020_19260 n1_M8_95100_19260 0.001755
R17242 n1_M8_95100_19260 n1_M8_96180_19260 0.001755
R17243 n1_M8_96180_19260 n1_M8_97260_19260 0.001755
R17244 n1_M8_97260_19260 n1_M8_98340_19260 0.001755
R17245 n1_M8_98340_19260 n1_M8_99420_19260 0.001755
R17246 n1_M8_99420_19260 n1_M8_100500_19260 0.001755
R17247 n1_M8_100500_19260 n1_M8_101580_19260 0.001755
R17248 n1_M8_101580_19260 n1_M8_102660_19260 0.001755
R17249 n1_M8_102660_19260 n1_M8_103740_19260 0.001755
R17250 n1_M8_103740_19260 n1_M8_104820_19260 0.001755
R17251 n1_M8_104820_19260 n1_M8_105900_19260 0.001755
R17252 n1_M8_105900_19260 n1_M8_106980_19260 0.001755
R17253 n1_M8_106980_19260 n1_M8_108060_19260 0.001755
R17254 n1_M8_108060_19260 n1_M8_109140_19260 0.001755
R17255 n1_M8_109140_19260 n1_M8_110220_19260 0.001755
R17256 n1_M8_110220_19260 n1_M8_111300_19260 0.001755
R17257 n1_M8_111300_19260 n1_M8_112380_19260 0.001755
R17258 n1_M8_112380_19260 n1_M8_113460_19260 0.001755
R17259 n1_M8_113460_19260 n1_M8_114540_19260 0.001755
R17260 n1_M8_114540_19260 n1_M8_115620_19260 0.001755
R17261 n1_M8_115620_19260 n1_M8_116700_19260 0.001755
R17262 n1_M8_116700_19260 n1_M8_117780_19260 0.001755
R17263 n1_M8_117780_19260 n1_M8_118860_19260 0.001755
R17264 n1_M8_118860_19260 n1_M8_119940_19260 0.001755
R17265 n1_M8_119940_19260 n1_M8_121020_19260 0.001755
R17266 n1_M8_121020_19260 n1_M8_122100_19260 0.001755
R17267 n1_M8_122100_19260 n1_M8_123180_19260 0.001755
R17268 n1_M8_123180_19260 n1_M8_124260_19260 0.001755
R17269 n1_M8_124260_19260 n1_M8_125340_19260 0.001755
R17270 n1_M8_125340_19260 n1_M8_126420_19260 0.001755
R17271 n1_M8_126420_19260 n1_M8_127500_19260 0.001755
R17272 n1_M8_127500_19260 n1_M8_128580_19260 0.001755
R17273 n1_M8_128580_19260 n1_M8_129660_19260 0.001755
R17274 n1_M8_60_25660 n1_M8_1140_25660 0.001755
R17275 n1_M8_1140_25660 n1_M8_2220_25660 0.001755
R17276 n1_M8_2220_25660 n1_M8_3300_25660 0.001755
R17277 n1_M8_3300_25660 n1_M8_4380_25660 0.001755
R17278 n1_M8_4380_25660 n1_M8_5460_25660 0.001755
R17279 n1_M8_5460_25660 n1_M8_6540_25660 0.001755
R17280 n1_M8_6540_25660 n1_M8_7620_25660 0.001755
R17281 n1_M8_7620_25660 n1_M8_8700_25660 0.001755
R17282 n1_M8_8700_25660 n1_M8_9780_25660 0.001755
R17283 n1_M8_9780_25660 n1_M8_10860_25660 0.001755
R17284 n1_M8_10860_25660 n1_M8_11940_25660 0.001755
R17285 n1_M8_11940_25660 n1_M8_13020_25660 0.001755
R17286 n1_M8_13020_25660 n1_M8_14100_25660 0.001755
R17287 n1_M8_14100_25660 n1_M8_15180_25660 0.001755
R17288 n1_M8_15180_25660 n1_M8_16260_25660 0.001755
R17289 n1_M8_16260_25660 n1_M8_17340_25660 0.001755
R17290 n1_M8_17340_25660 n1_M8_18420_25660 0.001755
R17291 n1_M8_18420_25660 n1_M8_19500_25660 0.001755
R17292 n1_M8_19500_25660 n1_M8_20580_25660 0.001755
R17293 n1_M8_20580_25660 n1_M8_21660_25660 0.001755
R17294 n1_M8_21660_25660 n1_M8_22740_25660 0.001755
R17295 n1_M8_22740_25660 n1_M8_23820_25660 0.001755
R17296 n1_M8_23820_25660 n1_M8_24900_25660 0.001755
R17297 n1_M8_24900_25660 n1_M8_25980_25660 0.001755
R17298 n1_M8_25980_25660 n1_M8_27060_25660 0.001755
R17299 n1_M8_27060_25660 n1_M8_28140_25660 0.001755
R17300 n1_M8_28140_25660 n1_M8_29220_25660 0.001755
R17301 n1_M8_29220_25660 n1_M8_30300_25660 0.001755
R17302 n1_M8_30300_25660 n1_M8_31380_25660 0.001755
R17303 n1_M8_31380_25660 n1_M8_32460_25660 0.001755
R17304 n1_M8_32460_25660 n1_M8_33540_25660 0.001755
R17305 n1_M8_33540_25660 n1_M8_34620_25660 0.001755
R17306 n1_M8_34620_25660 n1_M8_35700_25660 0.001755
R17307 n1_M8_35700_25660 n1_M8_36780_25660 0.001755
R17308 n1_M8_36780_25660 n1_M8_37860_25660 0.001755
R17309 n1_M8_37860_25660 n1_M8_38940_25660 0.001755
R17310 n1_M8_38940_25660 n1_M8_40020_25660 0.001755
R17311 n1_M8_40020_25660 n1_M8_41100_25660 0.001755
R17312 n1_M8_41100_25660 n1_M8_42180_25660 0.001755
R17313 n1_M8_42180_25660 n1_M8_43260_25660 0.001755
R17314 n1_M8_43260_25660 n1_M8_44340_25660 0.001755
R17315 n1_M8_44340_25660 n1_M8_45420_25660 0.001755
R17316 n1_M8_45420_25660 n1_M8_46500_25660 0.001755
R17317 n1_M8_46500_25660 n1_M8_47580_25660 0.001755
R17318 n1_M8_47580_25660 n1_M8_48660_25660 0.001755
R17319 n1_M8_48660_25660 n1_M8_49740_25660 0.001755
R17320 n1_M8_49740_25660 n1_M8_50820_25660 0.001755
R17321 n1_M8_50820_25660 n1_M8_51900_25660 0.001755
R17322 n1_M8_51900_25660 n1_M8_52980_25660 0.001755
R17323 n1_M8_52980_25660 n1_M8_54060_25660 0.001755
R17324 n1_M8_54060_25660 n1_M8_55140_25660 0.001755
R17325 n1_M8_55140_25660 n1_M8_56220_25660 0.001755
R17326 n1_M8_56220_25660 n1_M8_57300_25660 0.001755
R17327 n1_M8_57300_25660 n1_M8_58380_25660 0.001755
R17328 n1_M8_58380_25660 n1_M8_59460_25660 0.001755
R17329 n1_M8_59460_25660 n1_M8_60540_25660 0.001755
R17330 n1_M8_60540_25660 n1_M8_61620_25660 0.001755
R17331 n1_M8_61620_25660 n1_M8_62700_25660 0.001755
R17332 n1_M8_62700_25660 n1_M8_63780_25660 0.001755
R17333 n1_M8_63780_25660 n1_M8_64860_25660 0.001755
R17334 n1_M8_64860_25660 n1_M8_65940_25660 0.001755
R17335 n1_M8_65940_25660 n1_M8_67020_25660 0.001755
R17336 n1_M8_67020_25660 n1_M8_68100_25660 0.001755
R17337 n1_M8_68100_25660 n1_M8_69180_25660 0.001755
R17338 n1_M8_69180_25660 n1_M8_70260_25660 0.001755
R17339 n1_M8_70260_25660 n1_M8_71340_25660 0.001755
R17340 n1_M8_71340_25660 n1_M8_72420_25660 0.001755
R17341 n1_M8_72420_25660 n1_M8_73500_25660 0.001755
R17342 n1_M8_73500_25660 n1_M8_74580_25660 0.001755
R17343 n1_M8_74580_25660 n1_M8_75660_25660 0.001755
R17344 n1_M8_75660_25660 n1_M8_76740_25660 0.001755
R17345 n1_M8_76740_25660 n1_M8_77820_25660 0.001755
R17346 n1_M8_77820_25660 n1_M8_78900_25660 0.001755
R17347 n1_M8_78900_25660 n1_M8_79980_25660 0.001755
R17348 n1_M8_79980_25660 n1_M8_81060_25660 0.001755
R17349 n1_M8_81060_25660 n1_M8_82140_25660 0.001755
R17350 n1_M8_82140_25660 n1_M8_83220_25660 0.001755
R17351 n1_M8_83220_25660 n1_M8_84300_25660 0.001755
R17352 n1_M8_84300_25660 n1_M8_85380_25660 0.001755
R17353 n1_M8_85380_25660 n1_M8_86460_25660 0.001755
R17354 n1_M8_86460_25660 n1_M8_87540_25660 0.001755
R17355 n1_M8_87540_25660 n1_M8_88620_25660 0.001755
R17356 n1_M8_88620_25660 n1_M8_89700_25660 0.001755
R17357 n1_M8_89700_25660 n1_M8_90780_25660 0.001755
R17358 n1_M8_90780_25660 n1_M8_91860_25660 0.001755
R17359 n1_M8_91860_25660 n1_M8_92940_25660 0.001755
R17360 n1_M8_92940_25660 n1_M8_94020_25660 0.001755
R17361 n1_M8_94020_25660 n1_M8_95100_25660 0.001755
R17362 n1_M8_95100_25660 n1_M8_96180_25660 0.001755
R17363 n1_M8_96180_25660 n1_M8_97260_25660 0.001755
R17364 n1_M8_97260_25660 n1_M8_98340_25660 0.001755
R17365 n1_M8_98340_25660 n1_M8_99420_25660 0.001755
R17366 n1_M8_99420_25660 n1_M8_100500_25660 0.001755
R17367 n1_M8_100500_25660 n1_M8_101580_25660 0.001755
R17368 n1_M8_101580_25660 n1_M8_102660_25660 0.001755
R17369 n1_M8_102660_25660 n1_M8_103740_25660 0.001755
R17370 n1_M8_103740_25660 n1_M8_104820_25660 0.001755
R17371 n1_M8_104820_25660 n1_M8_105900_25660 0.001755
R17372 n1_M8_105900_25660 n1_M8_106980_25660 0.001755
R17373 n1_M8_106980_25660 n1_M8_108060_25660 0.001755
R17374 n1_M8_108060_25660 n1_M8_109140_25660 0.001755
R17375 n1_M8_109140_25660 n1_M8_110220_25660 0.001755
R17376 n1_M8_110220_25660 n1_M8_111300_25660 0.001755
R17377 n1_M8_111300_25660 n1_M8_112380_25660 0.001755
R17378 n1_M8_112380_25660 n1_M8_113460_25660 0.001755
R17379 n1_M8_113460_25660 n1_M8_114540_25660 0.001755
R17380 n1_M8_114540_25660 n1_M8_115620_25660 0.001755
R17381 n1_M8_115620_25660 n1_M8_116700_25660 0.001755
R17382 n1_M8_116700_25660 n1_M8_117780_25660 0.001755
R17383 n1_M8_117780_25660 n1_M8_118860_25660 0.001755
R17384 n1_M8_118860_25660 n1_M8_119940_25660 0.001755
R17385 n1_M8_119940_25660 n1_M8_121020_25660 0.001755
R17386 n1_M8_121020_25660 n1_M8_122100_25660 0.001755
R17387 n1_M8_122100_25660 n1_M8_123180_25660 0.001755
R17388 n1_M8_123180_25660 n1_M8_124260_25660 0.001755
R17389 n1_M8_124260_25660 n1_M8_125340_25660 0.001755
R17390 n1_M8_125340_25660 n1_M8_126420_25660 0.001755
R17391 n1_M8_126420_25660 n1_M8_127500_25660 0.001755
R17392 n1_M8_127500_25660 n1_M8_128580_25660 0.001755
R17393 n1_M8_128580_25660 n1_M8_129660_25660 0.001755
R17394 n1_M8_60_32060 n1_M8_1140_32060 0.001755
R17395 n1_M8_1140_32060 n1_M8_2220_32060 0.001755
R17396 n1_M8_2220_32060 n1_M8_3300_32060 0.001755
R17397 n1_M8_3300_32060 n1_M8_4380_32060 0.001755
R17398 n1_M8_4380_32060 n1_M8_5460_32060 0.001755
R17399 n1_M8_5460_32060 n1_M8_6540_32060 0.001755
R17400 n1_M8_6540_32060 n1_M8_7620_32060 0.001755
R17401 n1_M8_7620_32060 n1_M8_8700_32060 0.001755
R17402 n1_M8_8700_32060 n1_M8_9780_32060 0.001755
R17403 n1_M8_9780_32060 n1_M8_10860_32060 0.001755
R17404 n1_M8_10860_32060 n1_M8_11940_32060 0.001755
R17405 n1_M8_11940_32060 n1_M8_13020_32060 0.001755
R17406 n1_M8_13020_32060 n1_M8_14100_32060 0.001755
R17407 n1_M8_14100_32060 n1_M8_15180_32060 0.001755
R17408 n1_M8_15180_32060 n1_M8_16260_32060 0.001755
R17409 n1_M8_16260_32060 n1_M8_17340_32060 0.001755
R17410 n1_M8_17340_32060 n1_M8_18420_32060 0.001755
R17411 n1_M8_18420_32060 n1_M8_19500_32060 0.001755
R17412 n1_M8_19500_32060 n1_M8_20580_32060 0.001755
R17413 n1_M8_20580_32060 n1_M8_21660_32060 0.001755
R17414 n1_M8_21660_32060 n1_M8_22740_32060 0.001755
R17415 n1_M8_22740_32060 n1_M8_23820_32060 0.001755
R17416 n1_M8_23820_32060 n1_M8_24900_32060 0.001755
R17417 n1_M8_24900_32060 n1_M8_25980_32060 0.001755
R17418 n1_M8_25980_32060 n1_M8_27060_32060 0.001755
R17419 n1_M8_27060_32060 n1_M8_28140_32060 0.001755
R17420 n1_M8_28140_32060 n1_M8_29220_32060 0.001755
R17421 n1_M8_29220_32060 n1_M8_30300_32060 0.001755
R17422 n1_M8_30300_32060 n1_M8_31380_32060 0.001755
R17423 n1_M8_31380_32060 n1_M8_32460_32060 0.001755
R17424 n1_M8_32460_32060 n1_M8_33540_32060 0.001755
R17425 n1_M8_33540_32060 n1_M8_34620_32060 0.001755
R17426 n1_M8_34620_32060 n1_M8_35700_32060 0.001755
R17427 n1_M8_35700_32060 n1_M8_36780_32060 0.001755
R17428 n1_M8_36780_32060 n1_M8_37860_32060 0.001755
R17429 n1_M8_37860_32060 n1_M8_38940_32060 0.001755
R17430 n1_M8_38940_32060 n1_M8_40020_32060 0.001755
R17431 n1_M8_40020_32060 n1_M8_41100_32060 0.001755
R17432 n1_M8_41100_32060 n1_M8_42180_32060 0.001755
R17433 n1_M8_42180_32060 n1_M8_43260_32060 0.001755
R17434 n1_M8_43260_32060 n1_M8_44340_32060 0.001755
R17435 n1_M8_44340_32060 n1_M8_45420_32060 0.001755
R17436 n1_M8_45420_32060 n1_M8_46500_32060 0.001755
R17437 n1_M8_46500_32060 n1_M8_47580_32060 0.001755
R17438 n1_M8_47580_32060 n1_M8_48660_32060 0.001755
R17439 n1_M8_48660_32060 n1_M8_49740_32060 0.001755
R17440 n1_M8_49740_32060 n1_M8_50820_32060 0.001755
R17441 n1_M8_50820_32060 n1_M8_51900_32060 0.001755
R17442 n1_M8_51900_32060 n1_M8_52980_32060 0.001755
R17443 n1_M8_52980_32060 n1_M8_54060_32060 0.001755
R17444 n1_M8_54060_32060 n1_M8_55140_32060 0.001755
R17445 n1_M8_55140_32060 n1_M8_56220_32060 0.001755
R17446 n1_M8_56220_32060 n1_M8_57300_32060 0.001755
R17447 n1_M8_57300_32060 n1_M8_58380_32060 0.001755
R17448 n1_M8_58380_32060 n1_M8_59460_32060 0.001755
R17449 n1_M8_59460_32060 n1_M8_60540_32060 0.001755
R17450 n1_M8_60540_32060 n1_M8_61620_32060 0.001755
R17451 n1_M8_61620_32060 n1_M8_62700_32060 0.001755
R17452 n1_M8_62700_32060 n1_M8_63780_32060 0.001755
R17453 n1_M8_63780_32060 n1_M8_64860_32060 0.001755
R17454 n1_M8_64860_32060 n1_M8_65940_32060 0.001755
R17455 n1_M8_65940_32060 n1_M8_67020_32060 0.001755
R17456 n1_M8_67020_32060 n1_M8_68100_32060 0.001755
R17457 n1_M8_68100_32060 n1_M8_69180_32060 0.001755
R17458 n1_M8_69180_32060 n1_M8_70260_32060 0.001755
R17459 n1_M8_70260_32060 n1_M8_71340_32060 0.001755
R17460 n1_M8_71340_32060 n1_M8_72420_32060 0.001755
R17461 n1_M8_72420_32060 n1_M8_73500_32060 0.001755
R17462 n1_M8_73500_32060 n1_M8_74580_32060 0.001755
R17463 n1_M8_74580_32060 n1_M8_75660_32060 0.001755
R17464 n1_M8_75660_32060 n1_M8_76740_32060 0.001755
R17465 n1_M8_76740_32060 n1_M8_77820_32060 0.001755
R17466 n1_M8_77820_32060 n1_M8_78900_32060 0.001755
R17467 n1_M8_78900_32060 n1_M8_79980_32060 0.001755
R17468 n1_M8_79980_32060 n1_M8_81060_32060 0.001755
R17469 n1_M8_81060_32060 n1_M8_82140_32060 0.001755
R17470 n1_M8_82140_32060 n1_M8_83220_32060 0.001755
R17471 n1_M8_83220_32060 n1_M8_84300_32060 0.001755
R17472 n1_M8_84300_32060 n1_M8_85380_32060 0.001755
R17473 n1_M8_85380_32060 n1_M8_86460_32060 0.001755
R17474 n1_M8_86460_32060 n1_M8_87540_32060 0.001755
R17475 n1_M8_87540_32060 n1_M8_88620_32060 0.001755
R17476 n1_M8_88620_32060 n1_M8_89700_32060 0.001755
R17477 n1_M8_89700_32060 n1_M8_90780_32060 0.001755
R17478 n1_M8_90780_32060 n1_M8_91860_32060 0.001755
R17479 n1_M8_91860_32060 n1_M8_92940_32060 0.001755
R17480 n1_M8_92940_32060 n1_M8_94020_32060 0.001755
R17481 n1_M8_94020_32060 n1_M8_95100_32060 0.001755
R17482 n1_M8_95100_32060 n1_M8_96180_32060 0.001755
R17483 n1_M8_96180_32060 n1_M8_97260_32060 0.001755
R17484 n1_M8_97260_32060 n1_M8_98340_32060 0.001755
R17485 n1_M8_98340_32060 n1_M8_99420_32060 0.001755
R17486 n1_M8_99420_32060 n1_M8_100500_32060 0.001755
R17487 n1_M8_100500_32060 n1_M8_101580_32060 0.001755
R17488 n1_M8_101580_32060 n1_M8_102660_32060 0.001755
R17489 n1_M8_102660_32060 n1_M8_103740_32060 0.001755
R17490 n1_M8_103740_32060 n1_M8_104820_32060 0.001755
R17491 n1_M8_104820_32060 n1_M8_105900_32060 0.001755
R17492 n1_M8_105900_32060 n1_M8_106980_32060 0.001755
R17493 n1_M8_106980_32060 n1_M8_108060_32060 0.001755
R17494 n1_M8_108060_32060 n1_M8_109140_32060 0.001755
R17495 n1_M8_109140_32060 n1_M8_110220_32060 0.001755
R17496 n1_M8_110220_32060 n1_M8_111300_32060 0.001755
R17497 n1_M8_111300_32060 n1_M8_112380_32060 0.001755
R17498 n1_M8_112380_32060 n1_M8_113460_32060 0.001755
R17499 n1_M8_113460_32060 n1_M8_114540_32060 0.001755
R17500 n1_M8_114540_32060 n1_M8_115620_32060 0.001755
R17501 n1_M8_115620_32060 n1_M8_116700_32060 0.001755
R17502 n1_M8_116700_32060 n1_M8_117780_32060 0.001755
R17503 n1_M8_117780_32060 n1_M8_118860_32060 0.001755
R17504 n1_M8_118860_32060 n1_M8_119940_32060 0.001755
R17505 n1_M8_119940_32060 n1_M8_121020_32060 0.001755
R17506 n1_M8_121020_32060 n1_M8_122100_32060 0.001755
R17507 n1_M8_122100_32060 n1_M8_123180_32060 0.001755
R17508 n1_M8_123180_32060 n1_M8_124260_32060 0.001755
R17509 n1_M8_124260_32060 n1_M8_125340_32060 0.001755
R17510 n1_M8_125340_32060 n1_M8_126420_32060 0.001755
R17511 n1_M8_126420_32060 n1_M8_127500_32060 0.001755
R17512 n1_M8_127500_32060 n1_M8_128580_32060 0.001755
R17513 n1_M8_128580_32060 n1_M8_129660_32060 0.001755
R17514 n1_M8_60_38460 n1_M8_1140_38460 0.001755
R17515 n1_M8_1140_38460 n1_M8_2220_38460 0.001755
R17516 n1_M8_2220_38460 n1_M8_3300_38460 0.001755
R17517 n1_M8_3300_38460 n1_M8_4380_38460 0.001755
R17518 n1_M8_4380_38460 n1_M8_5460_38460 0.001755
R17519 n1_M8_5460_38460 n1_M8_6540_38460 0.001755
R17520 n1_M8_6540_38460 n1_M8_7620_38460 0.001755
R17521 n1_M8_7620_38460 n1_M8_8700_38460 0.001755
R17522 n1_M8_8700_38460 n1_M8_9780_38460 0.001755
R17523 n1_M8_9780_38460 n1_M8_10860_38460 0.001755
R17524 n1_M8_10860_38460 n1_M8_11940_38460 0.001755
R17525 n1_M8_11940_38460 n1_M8_13020_38460 0.001755
R17526 n1_M8_13020_38460 n1_M8_14100_38460 0.001755
R17527 n1_M8_14100_38460 n1_M8_15180_38460 0.001755
R17528 n1_M8_15180_38460 n1_M8_16260_38460 0.001755
R17529 n1_M8_16260_38460 n1_M8_17340_38460 0.001755
R17530 n1_M8_17340_38460 n1_M8_18420_38460 0.001755
R17531 n1_M8_18420_38460 n1_M8_19500_38460 0.001755
R17532 n1_M8_19500_38460 n1_M8_20580_38460 0.001755
R17533 n1_M8_20580_38460 n1_M8_21660_38460 0.001755
R17534 n1_M8_21660_38460 n1_M8_22740_38460 0.001755
R17535 n1_M8_22740_38460 n1_M8_23820_38460 0.001755
R17536 n1_M8_23820_38460 n1_M8_24900_38460 0.001755
R17537 n1_M8_24900_38460 n1_M8_25980_38460 0.001755
R17538 n1_M8_25980_38460 n1_M8_27060_38460 0.001755
R17539 n1_M8_27060_38460 n1_M8_28140_38460 0.001755
R17540 n1_M8_28140_38460 n1_M8_29220_38460 0.001755
R17541 n1_M8_29220_38460 n1_M8_30300_38460 0.001755
R17542 n1_M8_30300_38460 n1_M8_31380_38460 0.001755
R17543 n1_M8_31380_38460 n1_M8_32460_38460 0.001755
R17544 n1_M8_32460_38460 n1_M8_33540_38460 0.001755
R17545 n1_M8_33540_38460 n1_M8_34620_38460 0.001755
R17546 n1_M8_34620_38460 n1_M8_35700_38460 0.001755
R17547 n1_M8_35700_38460 n1_M8_36780_38460 0.001755
R17548 n1_M8_36780_38460 n1_M8_37860_38460 0.001755
R17549 n1_M8_37860_38460 n1_M8_38940_38460 0.001755
R17550 n1_M8_38940_38460 n1_M8_40020_38460 0.001755
R17551 n1_M8_40020_38460 n1_M8_41100_38460 0.001755
R17552 n1_M8_41100_38460 n1_M8_42180_38460 0.001755
R17553 n1_M8_42180_38460 n1_M8_43260_38460 0.001755
R17554 n1_M8_43260_38460 n1_M8_44340_38460 0.001755
R17555 n1_M8_44340_38460 n1_M8_45420_38460 0.001755
R17556 n1_M8_45420_38460 n1_M8_46500_38460 0.001755
R17557 n1_M8_46500_38460 n1_M8_47580_38460 0.001755
R17558 n1_M8_47580_38460 n1_M8_48660_38460 0.001755
R17559 n1_M8_48660_38460 n1_M8_49740_38460 0.001755
R17560 n1_M8_49740_38460 n1_M8_50820_38460 0.001755
R17561 n1_M8_50820_38460 n1_M8_51900_38460 0.001755
R17562 n1_M8_51900_38460 n1_M8_52980_38460 0.001755
R17563 n1_M8_52980_38460 n1_M8_54060_38460 0.001755
R17564 n1_M8_54060_38460 n1_M8_55140_38460 0.001755
R17565 n1_M8_55140_38460 n1_M8_56220_38460 0.001755
R17566 n1_M8_56220_38460 n1_M8_57300_38460 0.001755
R17567 n1_M8_57300_38460 n1_M8_58380_38460 0.001755
R17568 n1_M8_58380_38460 n1_M8_59460_38460 0.001755
R17569 n1_M8_59460_38460 n1_M8_60540_38460 0.001755
R17570 n1_M8_60540_38460 n1_M8_61620_38460 0.001755
R17571 n1_M8_61620_38460 n1_M8_62700_38460 0.001755
R17572 n1_M8_62700_38460 n1_M8_63780_38460 0.001755
R17573 n1_M8_63780_38460 n1_M8_64860_38460 0.001755
R17574 n1_M8_64860_38460 n1_M8_65940_38460 0.001755
R17575 n1_M8_65940_38460 n1_M8_67020_38460 0.001755
R17576 n1_M8_67020_38460 n1_M8_68100_38460 0.001755
R17577 n1_M8_68100_38460 n1_M8_69180_38460 0.001755
R17578 n1_M8_69180_38460 n1_M8_70260_38460 0.001755
R17579 n1_M8_70260_38460 n1_M8_71340_38460 0.001755
R17580 n1_M8_71340_38460 n1_M8_72420_38460 0.001755
R17581 n1_M8_72420_38460 n1_M8_73500_38460 0.001755
R17582 n1_M8_73500_38460 n1_M8_74580_38460 0.001755
R17583 n1_M8_74580_38460 n1_M8_75660_38460 0.001755
R17584 n1_M8_75660_38460 n1_M8_76740_38460 0.001755
R17585 n1_M8_76740_38460 n1_M8_77820_38460 0.001755
R17586 n1_M8_77820_38460 n1_M8_78900_38460 0.001755
R17587 n1_M8_78900_38460 n1_M8_79980_38460 0.001755
R17588 n1_M8_79980_38460 n1_M8_81060_38460 0.001755
R17589 n1_M8_81060_38460 n1_M8_82140_38460 0.001755
R17590 n1_M8_82140_38460 n1_M8_83220_38460 0.001755
R17591 n1_M8_83220_38460 n1_M8_84300_38460 0.001755
R17592 n1_M8_84300_38460 n1_M8_85380_38460 0.001755
R17593 n1_M8_85380_38460 n1_M8_86460_38460 0.001755
R17594 n1_M8_86460_38460 n1_M8_87540_38460 0.001755
R17595 n1_M8_87540_38460 n1_M8_88620_38460 0.001755
R17596 n1_M8_88620_38460 n1_M8_89700_38460 0.001755
R17597 n1_M8_89700_38460 n1_M8_90780_38460 0.001755
R17598 n1_M8_90780_38460 n1_M8_91860_38460 0.001755
R17599 n1_M8_91860_38460 n1_M8_92940_38460 0.001755
R17600 n1_M8_92940_38460 n1_M8_94020_38460 0.001755
R17601 n1_M8_94020_38460 n1_M8_95100_38460 0.001755
R17602 n1_M8_95100_38460 n1_M8_96180_38460 0.001755
R17603 n1_M8_96180_38460 n1_M8_97260_38460 0.001755
R17604 n1_M8_97260_38460 n1_M8_98340_38460 0.001755
R17605 n1_M8_98340_38460 n1_M8_99420_38460 0.001755
R17606 n1_M8_99420_38460 n1_M8_100500_38460 0.001755
R17607 n1_M8_100500_38460 n1_M8_101580_38460 0.001755
R17608 n1_M8_101580_38460 n1_M8_102660_38460 0.001755
R17609 n1_M8_102660_38460 n1_M8_103740_38460 0.001755
R17610 n1_M8_103740_38460 n1_M8_104820_38460 0.001755
R17611 n1_M8_104820_38460 n1_M8_105900_38460 0.001755
R17612 n1_M8_105900_38460 n1_M8_106980_38460 0.001755
R17613 n1_M8_106980_38460 n1_M8_108060_38460 0.001755
R17614 n1_M8_108060_38460 n1_M8_109140_38460 0.001755
R17615 n1_M8_109140_38460 n1_M8_110220_38460 0.001755
R17616 n1_M8_110220_38460 n1_M8_111300_38460 0.001755
R17617 n1_M8_111300_38460 n1_M8_112380_38460 0.001755
R17618 n1_M8_112380_38460 n1_M8_113460_38460 0.001755
R17619 n1_M8_113460_38460 n1_M8_114540_38460 0.001755
R17620 n1_M8_114540_38460 n1_M8_115620_38460 0.001755
R17621 n1_M8_115620_38460 n1_M8_116700_38460 0.001755
R17622 n1_M8_116700_38460 n1_M8_117780_38460 0.001755
R17623 n1_M8_117780_38460 n1_M8_118860_38460 0.001755
R17624 n1_M8_118860_38460 n1_M8_119940_38460 0.001755
R17625 n1_M8_119940_38460 n1_M8_121020_38460 0.001755
R17626 n1_M8_121020_38460 n1_M8_122100_38460 0.001755
R17627 n1_M8_122100_38460 n1_M8_123180_38460 0.001755
R17628 n1_M8_123180_38460 n1_M8_124260_38460 0.001755
R17629 n1_M8_124260_38460 n1_M8_125340_38460 0.001755
R17630 n1_M8_125340_38460 n1_M8_126420_38460 0.001755
R17631 n1_M8_126420_38460 n1_M8_127500_38460 0.001755
R17632 n1_M8_127500_38460 n1_M8_128580_38460 0.001755
R17633 n1_M8_128580_38460 n1_M8_129660_38460 0.001755
R17634 n1_M8_60_44860 n1_M8_1140_44860 0.001755
R17635 n1_M8_1140_44860 n1_M8_2220_44860 0.001755
R17636 n1_M8_2220_44860 n1_M8_3300_44860 0.001755
R17637 n1_M8_3300_44860 n1_M8_4380_44860 0.001755
R17638 n1_M8_4380_44860 n1_M8_5460_44860 0.001755
R17639 n1_M8_5460_44860 n1_M8_6540_44860 0.001755
R17640 n1_M8_6540_44860 n1_M8_7620_44860 0.001755
R17641 n1_M8_7620_44860 n1_M8_8700_44860 0.001755
R17642 n1_M8_8700_44860 n1_M8_9780_44860 0.001755
R17643 n1_M8_9780_44860 n1_M8_10860_44860 0.001755
R17644 n1_M8_10860_44860 n1_M8_11940_44860 0.001755
R17645 n1_M8_11940_44860 n1_M8_13020_44860 0.001755
R17646 n1_M8_13020_44860 n1_M8_14100_44860 0.001755
R17647 n1_M8_14100_44860 n1_M8_15180_44860 0.001755
R17648 n1_M8_15180_44860 n1_M8_16260_44860 0.001755
R17649 n1_M8_16260_44860 n1_M8_17340_44860 0.001755
R17650 n1_M8_17340_44860 n1_M8_18420_44860 0.001755
R17651 n1_M8_18420_44860 n1_M8_19500_44860 0.001755
R17652 n1_M8_19500_44860 n1_M8_20580_44860 0.001755
R17653 n1_M8_20580_44860 n1_M8_21660_44860 0.001755
R17654 n1_M8_21660_44860 n1_M8_22740_44860 0.001755
R17655 n1_M8_22740_44860 n1_M8_23820_44860 0.001755
R17656 n1_M8_23820_44860 n1_M8_24900_44860 0.001755
R17657 n1_M8_24900_44860 n1_M8_25980_44860 0.001755
R17658 n1_M8_25980_44860 n1_M8_27060_44860 0.001755
R17659 n1_M8_27060_44860 n1_M8_28140_44860 0.001755
R17660 n1_M8_28140_44860 n1_M8_29220_44860 0.001755
R17661 n1_M8_29220_44860 n1_M8_30300_44860 0.001755
R17662 n1_M8_30300_44860 n1_M8_31380_44860 0.001755
R17663 n1_M8_31380_44860 n1_M8_32460_44860 0.001755
R17664 n1_M8_32460_44860 n1_M8_33540_44860 0.001755
R17665 n1_M8_33540_44860 n1_M8_34620_44860 0.001755
R17666 n1_M8_34620_44860 n1_M8_35700_44860 0.001755
R17667 n1_M8_35700_44860 n1_M8_36780_44860 0.001755
R17668 n1_M8_36780_44860 n1_M8_37860_44860 0.001755
R17669 n1_M8_37860_44860 n1_M8_38940_44860 0.001755
R17670 n1_M8_38940_44860 n1_M8_40020_44860 0.001755
R17671 n1_M8_40020_44860 n1_M8_41100_44860 0.001755
R17672 n1_M8_41100_44860 n1_M8_42180_44860 0.001755
R17673 n1_M8_42180_44860 n1_M8_43260_44860 0.001755
R17674 n1_M8_43260_44860 n1_M8_44340_44860 0.001755
R17675 n1_M8_44340_44860 n1_M8_45420_44860 0.001755
R17676 n1_M8_45420_44860 n1_M8_46500_44860 0.001755
R17677 n1_M8_46500_44860 n1_M8_47580_44860 0.001755
R17678 n1_M8_47580_44860 n1_M8_48660_44860 0.001755
R17679 n1_M8_48660_44860 n1_M8_49740_44860 0.001755
R17680 n1_M8_49740_44860 n1_M8_50820_44860 0.001755
R17681 n1_M8_50820_44860 n1_M8_51900_44860 0.001755
R17682 n1_M8_51900_44860 n1_M8_52980_44860 0.001755
R17683 n1_M8_52980_44860 n1_M8_54060_44860 0.001755
R17684 n1_M8_54060_44860 n1_M8_55140_44860 0.001755
R17685 n1_M8_55140_44860 n1_M8_56220_44860 0.001755
R17686 n1_M8_56220_44860 n1_M8_57300_44860 0.001755
R17687 n1_M8_57300_44860 n1_M8_58380_44860 0.001755
R17688 n1_M8_58380_44860 n1_M8_59460_44860 0.001755
R17689 n1_M8_59460_44860 n1_M8_60540_44860 0.001755
R17690 n1_M8_60540_44860 n1_M8_61620_44860 0.001755
R17691 n1_M8_61620_44860 n1_M8_62700_44860 0.001755
R17692 n1_M8_62700_44860 n1_M8_63780_44860 0.001755
R17693 n1_M8_63780_44860 n1_M8_64860_44860 0.001755
R17694 n1_M8_64860_44860 n1_M8_65940_44860 0.001755
R17695 n1_M8_65940_44860 n1_M8_67020_44860 0.001755
R17696 n1_M8_67020_44860 n1_M8_68100_44860 0.001755
R17697 n1_M8_68100_44860 n1_M8_69180_44860 0.001755
R17698 n1_M8_69180_44860 n1_M8_70260_44860 0.001755
R17699 n1_M8_70260_44860 n1_M8_71340_44860 0.001755
R17700 n1_M8_71340_44860 n1_M8_72420_44860 0.001755
R17701 n1_M8_72420_44860 n1_M8_73500_44860 0.001755
R17702 n1_M8_73500_44860 n1_M8_74580_44860 0.001755
R17703 n1_M8_74580_44860 n1_M8_75660_44860 0.001755
R17704 n1_M8_75660_44860 n1_M8_76740_44860 0.001755
R17705 n1_M8_76740_44860 n1_M8_77820_44860 0.001755
R17706 n1_M8_77820_44860 n1_M8_78900_44860 0.001755
R17707 n1_M8_78900_44860 n1_M8_79980_44860 0.001755
R17708 n1_M8_79980_44860 n1_M8_81060_44860 0.001755
R17709 n1_M8_81060_44860 n1_M8_82140_44860 0.001755
R17710 n1_M8_82140_44860 n1_M8_83220_44860 0.001755
R17711 n1_M8_83220_44860 n1_M8_84300_44860 0.001755
R17712 n1_M8_84300_44860 n1_M8_85380_44860 0.001755
R17713 n1_M8_85380_44860 n1_M8_86460_44860 0.001755
R17714 n1_M8_86460_44860 n1_M8_87540_44860 0.001755
R17715 n1_M8_87540_44860 n1_M8_88620_44860 0.001755
R17716 n1_M8_88620_44860 n1_M8_89700_44860 0.001755
R17717 n1_M8_89700_44860 n1_M8_90780_44860 0.001755
R17718 n1_M8_90780_44860 n1_M8_91860_44860 0.001755
R17719 n1_M8_91860_44860 n1_M8_92940_44860 0.001755
R17720 n1_M8_92940_44860 n1_M8_94020_44860 0.001755
R17721 n1_M8_94020_44860 n1_M8_95100_44860 0.001755
R17722 n1_M8_95100_44860 n1_M8_96180_44860 0.001755
R17723 n1_M8_96180_44860 n1_M8_97260_44860 0.001755
R17724 n1_M8_97260_44860 n1_M8_98340_44860 0.001755
R17725 n1_M8_98340_44860 n1_M8_99420_44860 0.001755
R17726 n1_M8_99420_44860 n1_M8_100500_44860 0.001755
R17727 n1_M8_100500_44860 n1_M8_101580_44860 0.001755
R17728 n1_M8_101580_44860 n1_M8_102660_44860 0.001755
R17729 n1_M8_102660_44860 n1_M8_103740_44860 0.001755
R17730 n1_M8_103740_44860 n1_M8_104820_44860 0.001755
R17731 n1_M8_104820_44860 n1_M8_105900_44860 0.001755
R17732 n1_M8_105900_44860 n1_M8_106980_44860 0.001755
R17733 n1_M8_106980_44860 n1_M8_108060_44860 0.001755
R17734 n1_M8_108060_44860 n1_M8_109140_44860 0.001755
R17735 n1_M8_109140_44860 n1_M8_110220_44860 0.001755
R17736 n1_M8_110220_44860 n1_M8_111300_44860 0.001755
R17737 n1_M8_111300_44860 n1_M8_112380_44860 0.001755
R17738 n1_M8_112380_44860 n1_M8_113460_44860 0.001755
R17739 n1_M8_113460_44860 n1_M8_114540_44860 0.001755
R17740 n1_M8_114540_44860 n1_M8_115620_44860 0.001755
R17741 n1_M8_115620_44860 n1_M8_116700_44860 0.001755
R17742 n1_M8_116700_44860 n1_M8_117780_44860 0.001755
R17743 n1_M8_117780_44860 n1_M8_118860_44860 0.001755
R17744 n1_M8_118860_44860 n1_M8_119940_44860 0.001755
R17745 n1_M8_119940_44860 n1_M8_121020_44860 0.001755
R17746 n1_M8_121020_44860 n1_M8_122100_44860 0.001755
R17747 n1_M8_122100_44860 n1_M8_123180_44860 0.001755
R17748 n1_M8_123180_44860 n1_M8_124260_44860 0.001755
R17749 n1_M8_124260_44860 n1_M8_125340_44860 0.001755
R17750 n1_M8_125340_44860 n1_M8_126420_44860 0.001755
R17751 n1_M8_126420_44860 n1_M8_127500_44860 0.001755
R17752 n1_M8_127500_44860 n1_M8_128580_44860 0.001755
R17753 n1_M8_128580_44860 n1_M8_129660_44860 0.001755
R17754 n1_M8_60_51260 n1_M8_1140_51260 0.001755
R17755 n1_M8_1140_51260 n1_M8_2220_51260 0.001755
R17756 n1_M8_2220_51260 n1_M8_3300_51260 0.001755
R17757 n1_M8_3300_51260 n1_M8_4380_51260 0.001755
R17758 n1_M8_4380_51260 n1_M8_5460_51260 0.001755
R17759 n1_M8_5460_51260 n1_M8_6540_51260 0.001755
R17760 n1_M8_6540_51260 n1_M8_7620_51260 0.001755
R17761 n1_M8_7620_51260 n1_M8_8700_51260 0.001755
R17762 n1_M8_8700_51260 n1_M8_9780_51260 0.001755
R17763 n1_M8_9780_51260 n1_M8_10860_51260 0.001755
R17764 n1_M8_10860_51260 n1_M8_11940_51260 0.001755
R17765 n1_M8_11940_51260 n1_M8_13020_51260 0.001755
R17766 n1_M8_13020_51260 n1_M8_14100_51260 0.001755
R17767 n1_M8_14100_51260 n1_M8_15180_51260 0.001755
R17768 n1_M8_15180_51260 n1_M8_16260_51260 0.001755
R17769 n1_M8_16260_51260 n1_M8_17340_51260 0.001755
R17770 n1_M8_17340_51260 n1_M8_18420_51260 0.001755
R17771 n1_M8_18420_51260 n1_M8_19500_51260 0.001755
R17772 n1_M8_19500_51260 n1_M8_20580_51260 0.001755
R17773 n1_M8_20580_51260 n1_M8_21660_51260 0.001755
R17774 n1_M8_21660_51260 n1_M8_22740_51260 0.001755
R17775 n1_M8_22740_51260 n1_M8_23820_51260 0.001755
R17776 n1_M8_23820_51260 n1_M8_24900_51260 0.001755
R17777 n1_M8_24900_51260 n1_M8_25980_51260 0.001755
R17778 n1_M8_25980_51260 n1_M8_27060_51260 0.001755
R17779 n1_M8_27060_51260 n1_M8_28140_51260 0.001755
R17780 n1_M8_28140_51260 n1_M8_29220_51260 0.001755
R17781 n1_M8_29220_51260 n1_M8_30300_51260 0.001755
R17782 n1_M8_30300_51260 n1_M8_31380_51260 0.001755
R17783 n1_M8_31380_51260 n1_M8_32460_51260 0.001755
R17784 n1_M8_32460_51260 n1_M8_33540_51260 0.001755
R17785 n1_M8_33540_51260 n1_M8_34620_51260 0.001755
R17786 n1_M8_34620_51260 n1_M8_35700_51260 0.001755
R17787 n1_M8_35700_51260 n1_M8_36780_51260 0.001755
R17788 n1_M8_36780_51260 n1_M8_37860_51260 0.001755
R17789 n1_M8_37860_51260 n1_M8_38940_51260 0.001755
R17790 n1_M8_38940_51260 n1_M8_40020_51260 0.001755
R17791 n1_M8_40020_51260 n1_M8_41100_51260 0.001755
R17792 n1_M8_41100_51260 n1_M8_42180_51260 0.001755
R17793 n1_M8_42180_51260 n1_M8_43260_51260 0.001755
R17794 n1_M8_43260_51260 n1_M8_44340_51260 0.001755
R17795 n1_M8_44340_51260 n1_M8_45420_51260 0.001755
R17796 n1_M8_45420_51260 n1_M8_46500_51260 0.001755
R17797 n1_M8_46500_51260 n1_M8_47580_51260 0.001755
R17798 n1_M8_47580_51260 n1_M8_48660_51260 0.001755
R17799 n1_M8_48660_51260 n1_M8_49740_51260 0.001755
R17800 n1_M8_49740_51260 n1_M8_50820_51260 0.001755
R17801 n1_M8_50820_51260 n1_M8_51900_51260 0.001755
R17802 n1_M8_51900_51260 n1_M8_52980_51260 0.001755
R17803 n1_M8_52980_51260 n1_M8_54060_51260 0.001755
R17804 n1_M8_54060_51260 n1_M8_55140_51260 0.001755
R17805 n1_M8_55140_51260 n1_M8_56220_51260 0.001755
R17806 n1_M8_56220_51260 n1_M8_57300_51260 0.001755
R17807 n1_M8_57300_51260 n1_M8_58380_51260 0.001755
R17808 n1_M8_58380_51260 n1_M8_59460_51260 0.001755
R17809 n1_M8_59460_51260 n1_M8_60540_51260 0.001755
R17810 n1_M8_60540_51260 n1_M8_61620_51260 0.001755
R17811 n1_M8_61620_51260 n1_M8_62700_51260 0.001755
R17812 n1_M8_62700_51260 n1_M8_63780_51260 0.001755
R17813 n1_M8_63780_51260 n1_M8_64860_51260 0.001755
R17814 n1_M8_64860_51260 n1_M8_65940_51260 0.001755
R17815 n1_M8_65940_51260 n1_M8_67020_51260 0.001755
R17816 n1_M8_67020_51260 n1_M8_68100_51260 0.001755
R17817 n1_M8_68100_51260 n1_M8_69180_51260 0.001755
R17818 n1_M8_69180_51260 n1_M8_70260_51260 0.001755
R17819 n1_M8_70260_51260 n1_M8_71340_51260 0.001755
R17820 n1_M8_71340_51260 n1_M8_72420_51260 0.001755
R17821 n1_M8_72420_51260 n1_M8_73500_51260 0.001755
R17822 n1_M8_73500_51260 n1_M8_74580_51260 0.001755
R17823 n1_M8_74580_51260 n1_M8_75660_51260 0.001755
R17824 n1_M8_75660_51260 n1_M8_76740_51260 0.001755
R17825 n1_M8_76740_51260 n1_M8_77820_51260 0.001755
R17826 n1_M8_77820_51260 n1_M8_78900_51260 0.001755
R17827 n1_M8_78900_51260 n1_M8_79980_51260 0.001755
R17828 n1_M8_79980_51260 n1_M8_81060_51260 0.001755
R17829 n1_M8_81060_51260 n1_M8_82140_51260 0.001755
R17830 n1_M8_82140_51260 n1_M8_83220_51260 0.001755
R17831 n1_M8_83220_51260 n1_M8_84300_51260 0.001755
R17832 n1_M8_84300_51260 n1_M8_85380_51260 0.001755
R17833 n1_M8_85380_51260 n1_M8_86460_51260 0.001755
R17834 n1_M8_86460_51260 n1_M8_87540_51260 0.001755
R17835 n1_M8_87540_51260 n1_M8_88620_51260 0.001755
R17836 n1_M8_88620_51260 n1_M8_89700_51260 0.001755
R17837 n1_M8_89700_51260 n1_M8_90780_51260 0.001755
R17838 n1_M8_90780_51260 n1_M8_91860_51260 0.001755
R17839 n1_M8_91860_51260 n1_M8_92940_51260 0.001755
R17840 n1_M8_92940_51260 n1_M8_94020_51260 0.001755
R17841 n1_M8_94020_51260 n1_M8_95100_51260 0.001755
R17842 n1_M8_95100_51260 n1_M8_96180_51260 0.001755
R17843 n1_M8_96180_51260 n1_M8_97260_51260 0.001755
R17844 n1_M8_97260_51260 n1_M8_98340_51260 0.001755
R17845 n1_M8_98340_51260 n1_M8_99420_51260 0.001755
R17846 n1_M8_99420_51260 n1_M8_100500_51260 0.001755
R17847 n1_M8_100500_51260 n1_M8_101580_51260 0.001755
R17848 n1_M8_101580_51260 n1_M8_102660_51260 0.001755
R17849 n1_M8_102660_51260 n1_M8_103740_51260 0.001755
R17850 n1_M8_103740_51260 n1_M8_104820_51260 0.001755
R17851 n1_M8_104820_51260 n1_M8_105900_51260 0.001755
R17852 n1_M8_105900_51260 n1_M8_106980_51260 0.001755
R17853 n1_M8_106980_51260 n1_M8_108060_51260 0.001755
R17854 n1_M8_108060_51260 n1_M8_109140_51260 0.001755
R17855 n1_M8_109140_51260 n1_M8_110220_51260 0.001755
R17856 n1_M8_110220_51260 n1_M8_111300_51260 0.001755
R17857 n1_M8_111300_51260 n1_M8_112380_51260 0.001755
R17858 n1_M8_112380_51260 n1_M8_113460_51260 0.001755
R17859 n1_M8_113460_51260 n1_M8_114540_51260 0.001755
R17860 n1_M8_114540_51260 n1_M8_115620_51260 0.001755
R17861 n1_M8_115620_51260 n1_M8_116700_51260 0.001755
R17862 n1_M8_116700_51260 n1_M8_117780_51260 0.001755
R17863 n1_M8_117780_51260 n1_M8_118860_51260 0.001755
R17864 n1_M8_118860_51260 n1_M8_119940_51260 0.001755
R17865 n1_M8_119940_51260 n1_M8_121020_51260 0.001755
R17866 n1_M8_121020_51260 n1_M8_122100_51260 0.001755
R17867 n1_M8_122100_51260 n1_M8_123180_51260 0.001755
R17868 n1_M8_123180_51260 n1_M8_124260_51260 0.001755
R17869 n1_M8_124260_51260 n1_M8_125340_51260 0.001755
R17870 n1_M8_125340_51260 n1_M8_126420_51260 0.001755
R17871 n1_M8_126420_51260 n1_M8_127500_51260 0.001755
R17872 n1_M8_127500_51260 n1_M8_128580_51260 0.001755
R17873 n1_M8_128580_51260 n1_M8_129660_51260 0.001755
R17874 n1_M8_60_57660 n1_M8_1140_57660 0.001755
R17875 n1_M8_1140_57660 n1_M8_2220_57660 0.001755
R17876 n1_M8_2220_57660 n1_M8_3300_57660 0.001755
R17877 n1_M8_3300_57660 n1_M8_4380_57660 0.001755
R17878 n1_M8_4380_57660 n1_M8_5460_57660 0.001755
R17879 n1_M8_5460_57660 n1_M8_6540_57660 0.001755
R17880 n1_M8_6540_57660 n1_M8_7620_57660 0.001755
R17881 n1_M8_7620_57660 n1_M8_8700_57660 0.001755
R17882 n1_M8_8700_57660 n1_M8_9780_57660 0.001755
R17883 n1_M8_9780_57660 n1_M8_10860_57660 0.001755
R17884 n1_M8_10860_57660 n1_M8_11940_57660 0.001755
R17885 n1_M8_11940_57660 n1_M8_13020_57660 0.001755
R17886 n1_M8_13020_57660 n1_M8_14100_57660 0.001755
R17887 n1_M8_14100_57660 n1_M8_15180_57660 0.001755
R17888 n1_M8_15180_57660 n1_M8_16260_57660 0.001755
R17889 n1_M8_16260_57660 n1_M8_17340_57660 0.001755
R17890 n1_M8_17340_57660 n1_M8_18420_57660 0.001755
R17891 n1_M8_18420_57660 n1_M8_19500_57660 0.001755
R17892 n1_M8_19500_57660 n1_M8_20580_57660 0.001755
R17893 n1_M8_20580_57660 n1_M8_21660_57660 0.001755
R17894 n1_M8_21660_57660 n1_M8_22740_57660 0.001755
R17895 n1_M8_22740_57660 n1_M8_23820_57660 0.001755
R17896 n1_M8_23820_57660 n1_M8_24900_57660 0.001755
R17897 n1_M8_24900_57660 n1_M8_25980_57660 0.001755
R17898 n1_M8_25980_57660 n1_M8_27060_57660 0.001755
R17899 n1_M8_27060_57660 n1_M8_28140_57660 0.001755
R17900 n1_M8_28140_57660 n1_M8_29220_57660 0.001755
R17901 n1_M8_29220_57660 n1_M8_30300_57660 0.001755
R17902 n1_M8_30300_57660 n1_M8_31380_57660 0.001755
R17903 n1_M8_31380_57660 n1_M8_32460_57660 0.001755
R17904 n1_M8_32460_57660 n1_M8_33540_57660 0.001755
R17905 n1_M8_33540_57660 n1_M8_34620_57660 0.001755
R17906 n1_M8_34620_57660 n1_M8_35700_57660 0.001755
R17907 n1_M8_35700_57660 n1_M8_36780_57660 0.001755
R17908 n1_M8_36780_57660 n1_M8_37860_57660 0.001755
R17909 n1_M8_37860_57660 n1_M8_38940_57660 0.001755
R17910 n1_M8_38940_57660 n1_M8_40020_57660 0.001755
R17911 n1_M8_40020_57660 n1_M8_41100_57660 0.001755
R17912 n1_M8_41100_57660 n1_M8_42180_57660 0.001755
R17913 n1_M8_42180_57660 n1_M8_43260_57660 0.001755
R17914 n1_M8_43260_57660 n1_M8_44340_57660 0.001755
R17915 n1_M8_44340_57660 n1_M8_45420_57660 0.001755
R17916 n1_M8_45420_57660 n1_M8_46500_57660 0.001755
R17917 n1_M8_46500_57660 n1_M8_47580_57660 0.001755
R17918 n1_M8_47580_57660 n1_M8_48660_57660 0.001755
R17919 n1_M8_48660_57660 n1_M8_49740_57660 0.001755
R17920 n1_M8_49740_57660 n1_M8_50820_57660 0.001755
R17921 n1_M8_50820_57660 n1_M8_51900_57660 0.001755
R17922 n1_M8_51900_57660 n1_M8_52980_57660 0.001755
R17923 n1_M8_52980_57660 n1_M8_54060_57660 0.001755
R17924 n1_M8_54060_57660 n1_M8_55140_57660 0.001755
R17925 n1_M8_55140_57660 n1_M8_56220_57660 0.001755
R17926 n1_M8_56220_57660 n1_M8_57300_57660 0.001755
R17927 n1_M8_57300_57660 n1_M8_58380_57660 0.001755
R17928 n1_M8_58380_57660 n1_M8_59460_57660 0.001755
R17929 n1_M8_59460_57660 n1_M8_60540_57660 0.001755
R17930 n1_M8_60540_57660 n1_M8_61620_57660 0.001755
R17931 n1_M8_61620_57660 n1_M8_62700_57660 0.001755
R17932 n1_M8_62700_57660 n1_M8_63780_57660 0.001755
R17933 n1_M8_63780_57660 n1_M8_64860_57660 0.001755
R17934 n1_M8_64860_57660 n1_M8_65940_57660 0.001755
R17935 n1_M8_65940_57660 n1_M8_67020_57660 0.001755
R17936 n1_M8_67020_57660 n1_M8_68100_57660 0.001755
R17937 n1_M8_68100_57660 n1_M8_69180_57660 0.001755
R17938 n1_M8_69180_57660 n1_M8_70260_57660 0.001755
R17939 n1_M8_70260_57660 n1_M8_71340_57660 0.001755
R17940 n1_M8_71340_57660 n1_M8_72420_57660 0.001755
R17941 n1_M8_72420_57660 n1_M8_73500_57660 0.001755
R17942 n1_M8_73500_57660 n1_M8_74580_57660 0.001755
R17943 n1_M8_74580_57660 n1_M8_75660_57660 0.001755
R17944 n1_M8_75660_57660 n1_M8_76740_57660 0.001755
R17945 n1_M8_76740_57660 n1_M8_77820_57660 0.001755
R17946 n1_M8_77820_57660 n1_M8_78900_57660 0.001755
R17947 n1_M8_78900_57660 n1_M8_79980_57660 0.001755
R17948 n1_M8_79980_57660 n1_M8_81060_57660 0.001755
R17949 n1_M8_81060_57660 n1_M8_82140_57660 0.001755
R17950 n1_M8_82140_57660 n1_M8_83220_57660 0.001755
R17951 n1_M8_83220_57660 n1_M8_84300_57660 0.001755
R17952 n1_M8_84300_57660 n1_M8_85380_57660 0.001755
R17953 n1_M8_85380_57660 n1_M8_86460_57660 0.001755
R17954 n1_M8_86460_57660 n1_M8_87540_57660 0.001755
R17955 n1_M8_87540_57660 n1_M8_88620_57660 0.001755
R17956 n1_M8_88620_57660 n1_M8_89700_57660 0.001755
R17957 n1_M8_89700_57660 n1_M8_90780_57660 0.001755
R17958 n1_M8_90780_57660 n1_M8_91860_57660 0.001755
R17959 n1_M8_91860_57660 n1_M8_92940_57660 0.001755
R17960 n1_M8_92940_57660 n1_M8_94020_57660 0.001755
R17961 n1_M8_94020_57660 n1_M8_95100_57660 0.001755
R17962 n1_M8_95100_57660 n1_M8_96180_57660 0.001755
R17963 n1_M8_96180_57660 n1_M8_97260_57660 0.001755
R17964 n1_M8_97260_57660 n1_M8_98340_57660 0.001755
R17965 n1_M8_98340_57660 n1_M8_99420_57660 0.001755
R17966 n1_M8_99420_57660 n1_M8_100500_57660 0.001755
R17967 n1_M8_100500_57660 n1_M8_101580_57660 0.001755
R17968 n1_M8_101580_57660 n1_M8_102660_57660 0.001755
R17969 n1_M8_102660_57660 n1_M8_103740_57660 0.001755
R17970 n1_M8_103740_57660 n1_M8_104820_57660 0.001755
R17971 n1_M8_104820_57660 n1_M8_105900_57660 0.001755
R17972 n1_M8_105900_57660 n1_M8_106980_57660 0.001755
R17973 n1_M8_106980_57660 n1_M8_108060_57660 0.001755
R17974 n1_M8_108060_57660 n1_M8_109140_57660 0.001755
R17975 n1_M8_109140_57660 n1_M8_110220_57660 0.001755
R17976 n1_M8_110220_57660 n1_M8_111300_57660 0.001755
R17977 n1_M8_111300_57660 n1_M8_112380_57660 0.001755
R17978 n1_M8_112380_57660 n1_M8_113460_57660 0.001755
R17979 n1_M8_113460_57660 n1_M8_114540_57660 0.001755
R17980 n1_M8_114540_57660 n1_M8_115620_57660 0.001755
R17981 n1_M8_115620_57660 n1_M8_116700_57660 0.001755
R17982 n1_M8_116700_57660 n1_M8_117780_57660 0.001755
R17983 n1_M8_117780_57660 n1_M8_118860_57660 0.001755
R17984 n1_M8_118860_57660 n1_M8_119940_57660 0.001755
R17985 n1_M8_119940_57660 n1_M8_121020_57660 0.001755
R17986 n1_M8_121020_57660 n1_M8_122100_57660 0.001755
R17987 n1_M8_122100_57660 n1_M8_123180_57660 0.001755
R17988 n1_M8_123180_57660 n1_M8_124260_57660 0.001755
R17989 n1_M8_124260_57660 n1_M8_125340_57660 0.001755
R17990 n1_M8_125340_57660 n1_M8_126420_57660 0.001755
R17991 n1_M8_126420_57660 n1_M8_127500_57660 0.001755
R17992 n1_M8_127500_57660 n1_M8_128580_57660 0.001755
R17993 n1_M8_128580_57660 n1_M8_129660_57660 0.001755
R17994 n1_M8_60_64060 n1_M8_1140_64060 0.001755
R17995 n1_M8_1140_64060 n1_M8_2220_64060 0.001755
R17996 n1_M8_2220_64060 n1_M8_3300_64060 0.001755
R17997 n1_M8_3300_64060 n1_M8_4380_64060 0.001755
R17998 n1_M8_4380_64060 n1_M8_5460_64060 0.001755
R17999 n1_M8_5460_64060 n1_M8_6540_64060 0.001755
R18000 n1_M8_6540_64060 n1_M8_7620_64060 0.001755
R18001 n1_M8_7620_64060 n1_M8_8700_64060 0.001755
R18002 n1_M8_8700_64060 n1_M8_9780_64060 0.001755
R18003 n1_M8_9780_64060 n1_M8_10860_64060 0.001755
R18004 n1_M8_10860_64060 n1_M8_11940_64060 0.001755
R18005 n1_M8_11940_64060 n1_M8_13020_64060 0.001755
R18006 n1_M8_13020_64060 n1_M8_14100_64060 0.001755
R18007 n1_M8_14100_64060 n1_M8_15180_64060 0.001755
R18008 n1_M8_15180_64060 n1_M8_16260_64060 0.001755
R18009 n1_M8_16260_64060 n1_M8_17340_64060 0.001755
R18010 n1_M8_17340_64060 n1_M8_18420_64060 0.001755
R18011 n1_M8_18420_64060 n1_M8_19500_64060 0.001755
R18012 n1_M8_19500_64060 n1_M8_20580_64060 0.001755
R18013 n1_M8_20580_64060 n1_M8_21660_64060 0.001755
R18014 n1_M8_21660_64060 n1_M8_22740_64060 0.001755
R18015 n1_M8_22740_64060 n1_M8_23820_64060 0.001755
R18016 n1_M8_23820_64060 n1_M8_24900_64060 0.001755
R18017 n1_M8_24900_64060 n1_M8_25980_64060 0.001755
R18018 n1_M8_25980_64060 n1_M8_27060_64060 0.001755
R18019 n1_M8_27060_64060 n1_M8_28140_64060 0.001755
R18020 n1_M8_28140_64060 n1_M8_29220_64060 0.001755
R18021 n1_M8_29220_64060 n1_M8_30300_64060 0.001755
R18022 n1_M8_30300_64060 n1_M8_31380_64060 0.001755
R18023 n1_M8_31380_64060 n1_M8_32460_64060 0.001755
R18024 n1_M8_32460_64060 n1_M8_33540_64060 0.001755
R18025 n1_M8_33540_64060 n1_M8_34620_64060 0.001755
R18026 n1_M8_34620_64060 n1_M8_35700_64060 0.001755
R18027 n1_M8_35700_64060 n1_M8_36780_64060 0.001755
R18028 n1_M8_36780_64060 n1_M8_37860_64060 0.001755
R18029 n1_M8_37860_64060 n1_M8_38940_64060 0.001755
R18030 n1_M8_38940_64060 n1_M8_40020_64060 0.001755
R18031 n1_M8_40020_64060 n1_M8_41100_64060 0.001755
R18032 n1_M8_41100_64060 n1_M8_42180_64060 0.001755
R18033 n1_M8_42180_64060 n1_M8_43260_64060 0.001755
R18034 n1_M8_43260_64060 n1_M8_44340_64060 0.001755
R18035 n1_M8_44340_64060 n1_M8_45420_64060 0.001755
R18036 n1_M8_45420_64060 n1_M8_46500_64060 0.001755
R18037 n1_M8_46500_64060 n1_M8_47580_64060 0.001755
R18038 n1_M8_47580_64060 n1_M8_48660_64060 0.001755
R18039 n1_M8_48660_64060 n1_M8_49740_64060 0.001755
R18040 n1_M8_49740_64060 n1_M8_50820_64060 0.001755
R18041 n1_M8_50820_64060 n1_M8_51900_64060 0.001755
R18042 n1_M8_51900_64060 n1_M8_52980_64060 0.001755
R18043 n1_M8_52980_64060 n1_M8_54060_64060 0.001755
R18044 n1_M8_54060_64060 n1_M8_55140_64060 0.001755
R18045 n1_M8_55140_64060 n1_M8_56220_64060 0.001755
R18046 n1_M8_56220_64060 n1_M8_57300_64060 0.001755
R18047 n1_M8_57300_64060 n1_M8_58380_64060 0.001755
R18048 n1_M8_58380_64060 n1_M8_59460_64060 0.001755
R18049 n1_M8_59460_64060 n1_M8_60540_64060 0.001755
R18050 n1_M8_60540_64060 n1_M8_61620_64060 0.001755
R18051 n1_M8_61620_64060 n1_M8_62700_64060 0.001755
R18052 n1_M8_62700_64060 n1_M8_63780_64060 0.001755
R18053 n1_M8_63780_64060 n1_M8_64860_64060 0.001755
R18054 n1_M8_64860_64060 n1_M8_65940_64060 0.001755
R18055 n1_M8_65940_64060 n1_M8_67020_64060 0.001755
R18056 n1_M8_67020_64060 n1_M8_68100_64060 0.001755
R18057 n1_M8_68100_64060 n1_M8_69180_64060 0.001755
R18058 n1_M8_69180_64060 n1_M8_70260_64060 0.001755
R18059 n1_M8_70260_64060 n1_M8_71340_64060 0.001755
R18060 n1_M8_71340_64060 n1_M8_72420_64060 0.001755
R18061 n1_M8_72420_64060 n1_M8_73500_64060 0.001755
R18062 n1_M8_73500_64060 n1_M8_74580_64060 0.001755
R18063 n1_M8_74580_64060 n1_M8_75660_64060 0.001755
R18064 n1_M8_75660_64060 n1_M8_76740_64060 0.001755
R18065 n1_M8_76740_64060 n1_M8_77820_64060 0.001755
R18066 n1_M8_77820_64060 n1_M8_78900_64060 0.001755
R18067 n1_M8_78900_64060 n1_M8_79980_64060 0.001755
R18068 n1_M8_79980_64060 n1_M8_81060_64060 0.001755
R18069 n1_M8_81060_64060 n1_M8_82140_64060 0.001755
R18070 n1_M8_82140_64060 n1_M8_83220_64060 0.001755
R18071 n1_M8_83220_64060 n1_M8_84300_64060 0.001755
R18072 n1_M8_84300_64060 n1_M8_85380_64060 0.001755
R18073 n1_M8_85380_64060 n1_M8_86460_64060 0.001755
R18074 n1_M8_86460_64060 n1_M8_87540_64060 0.001755
R18075 n1_M8_87540_64060 n1_M8_88620_64060 0.001755
R18076 n1_M8_88620_64060 n1_M8_89700_64060 0.001755
R18077 n1_M8_89700_64060 n1_M8_90780_64060 0.001755
R18078 n1_M8_90780_64060 n1_M8_91860_64060 0.001755
R18079 n1_M8_91860_64060 n1_M8_92940_64060 0.001755
R18080 n1_M8_92940_64060 n1_M8_94020_64060 0.001755
R18081 n1_M8_94020_64060 n1_M8_95100_64060 0.001755
R18082 n1_M8_95100_64060 n1_M8_96180_64060 0.001755
R18083 n1_M8_96180_64060 n1_M8_97260_64060 0.001755
R18084 n1_M8_97260_64060 n1_M8_98340_64060 0.001755
R18085 n1_M8_98340_64060 n1_M8_99420_64060 0.001755
R18086 n1_M8_99420_64060 n1_M8_100500_64060 0.001755
R18087 n1_M8_100500_64060 n1_M8_101580_64060 0.001755
R18088 n1_M8_101580_64060 n1_M8_102660_64060 0.001755
R18089 n1_M8_102660_64060 n1_M8_103740_64060 0.001755
R18090 n1_M8_103740_64060 n1_M8_104820_64060 0.001755
R18091 n1_M8_104820_64060 n1_M8_105900_64060 0.001755
R18092 n1_M8_105900_64060 n1_M8_106980_64060 0.001755
R18093 n1_M8_106980_64060 n1_M8_108060_64060 0.001755
R18094 n1_M8_108060_64060 n1_M8_109140_64060 0.001755
R18095 n1_M8_109140_64060 n1_M8_110220_64060 0.001755
R18096 n1_M8_110220_64060 n1_M8_111300_64060 0.001755
R18097 n1_M8_111300_64060 n1_M8_112380_64060 0.001755
R18098 n1_M8_112380_64060 n1_M8_113460_64060 0.001755
R18099 n1_M8_113460_64060 n1_M8_114540_64060 0.001755
R18100 n1_M8_114540_64060 n1_M8_115620_64060 0.001755
R18101 n1_M8_115620_64060 n1_M8_116700_64060 0.001755
R18102 n1_M8_116700_64060 n1_M8_117780_64060 0.001755
R18103 n1_M8_117780_64060 n1_M8_118860_64060 0.001755
R18104 n1_M8_118860_64060 n1_M8_119940_64060 0.001755
R18105 n1_M8_119940_64060 n1_M8_121020_64060 0.001755
R18106 n1_M8_121020_64060 n1_M8_122100_64060 0.001755
R18107 n1_M8_122100_64060 n1_M8_123180_64060 0.001755
R18108 n1_M8_123180_64060 n1_M8_124260_64060 0.001755
R18109 n1_M8_124260_64060 n1_M8_125340_64060 0.001755
R18110 n1_M8_125340_64060 n1_M8_126420_64060 0.001755
R18111 n1_M8_126420_64060 n1_M8_127500_64060 0.001755
R18112 n1_M8_127500_64060 n1_M8_128580_64060 0.001755
R18113 n1_M8_128580_64060 n1_M8_129660_64060 0.001755
R18114 n1_M8_60_70460 n1_M8_1140_70460 0.001755
R18115 n1_M8_1140_70460 n1_M8_2220_70460 0.001755
R18116 n1_M8_2220_70460 n1_M8_3300_70460 0.001755
R18117 n1_M8_3300_70460 n1_M8_4380_70460 0.001755
R18118 n1_M8_4380_70460 n1_M8_5460_70460 0.001755
R18119 n1_M8_5460_70460 n1_M8_6540_70460 0.001755
R18120 n1_M8_6540_70460 n1_M8_7620_70460 0.001755
R18121 n1_M8_7620_70460 n1_M8_8700_70460 0.001755
R18122 n1_M8_8700_70460 n1_M8_9780_70460 0.001755
R18123 n1_M8_9780_70460 n1_M8_10860_70460 0.001755
R18124 n1_M8_10860_70460 n1_M8_11940_70460 0.001755
R18125 n1_M8_11940_70460 n1_M8_13020_70460 0.001755
R18126 n1_M8_13020_70460 n1_M8_14100_70460 0.001755
R18127 n1_M8_14100_70460 n1_M8_15180_70460 0.001755
R18128 n1_M8_15180_70460 n1_M8_16260_70460 0.001755
R18129 n1_M8_16260_70460 n1_M8_17340_70460 0.001755
R18130 n1_M8_17340_70460 n1_M8_18420_70460 0.001755
R18131 n1_M8_18420_70460 n1_M8_19500_70460 0.001755
R18132 n1_M8_19500_70460 n1_M8_20580_70460 0.001755
R18133 n1_M8_20580_70460 n1_M8_21660_70460 0.001755
R18134 n1_M8_21660_70460 n1_M8_22740_70460 0.001755
R18135 n1_M8_22740_70460 n1_M8_23820_70460 0.001755
R18136 n1_M8_23820_70460 n1_M8_24900_70460 0.001755
R18137 n1_M8_24900_70460 n1_M8_25980_70460 0.001755
R18138 n1_M8_25980_70460 n1_M8_27060_70460 0.001755
R18139 n1_M8_27060_70460 n1_M8_28140_70460 0.001755
R18140 n1_M8_28140_70460 n1_M8_29220_70460 0.001755
R18141 n1_M8_29220_70460 n1_M8_30300_70460 0.001755
R18142 n1_M8_30300_70460 n1_M8_31380_70460 0.001755
R18143 n1_M8_31380_70460 n1_M8_32460_70460 0.001755
R18144 n1_M8_32460_70460 n1_M8_33540_70460 0.001755
R18145 n1_M8_33540_70460 n1_M8_34620_70460 0.001755
R18146 n1_M8_34620_70460 n1_M8_35700_70460 0.001755
R18147 n1_M8_35700_70460 n1_M8_36780_70460 0.001755
R18148 n1_M8_36780_70460 n1_M8_37860_70460 0.001755
R18149 n1_M8_37860_70460 n1_M8_38940_70460 0.001755
R18150 n1_M8_38940_70460 n1_M8_40020_70460 0.001755
R18151 n1_M8_40020_70460 n1_M8_41100_70460 0.001755
R18152 n1_M8_41100_70460 n1_M8_42180_70460 0.001755
R18153 n1_M8_42180_70460 n1_M8_43260_70460 0.001755
R18154 n1_M8_43260_70460 n1_M8_44340_70460 0.001755
R18155 n1_M8_44340_70460 n1_M8_45420_70460 0.001755
R18156 n1_M8_45420_70460 n1_M8_46500_70460 0.001755
R18157 n1_M8_46500_70460 n1_M8_47580_70460 0.001755
R18158 n1_M8_47580_70460 n1_M8_48660_70460 0.001755
R18159 n1_M8_48660_70460 n1_M8_49740_70460 0.001755
R18160 n1_M8_49740_70460 n1_M8_50820_70460 0.001755
R18161 n1_M8_50820_70460 n1_M8_51900_70460 0.001755
R18162 n1_M8_51900_70460 n1_M8_52980_70460 0.001755
R18163 n1_M8_52980_70460 n1_M8_54060_70460 0.001755
R18164 n1_M8_54060_70460 n1_M8_55140_70460 0.001755
R18165 n1_M8_55140_70460 n1_M8_56220_70460 0.001755
R18166 n1_M8_56220_70460 n1_M8_57300_70460 0.001755
R18167 n1_M8_57300_70460 n1_M8_58380_70460 0.001755
R18168 n1_M8_58380_70460 n1_M8_59460_70460 0.001755
R18169 n1_M8_59460_70460 n1_M8_60540_70460 0.001755
R18170 n1_M8_60540_70460 n1_M8_61620_70460 0.001755
R18171 n1_M8_61620_70460 n1_M8_62700_70460 0.001755
R18172 n1_M8_62700_70460 n1_M8_63780_70460 0.001755
R18173 n1_M8_63780_70460 n1_M8_64860_70460 0.001755
R18174 n1_M8_64860_70460 n1_M8_65940_70460 0.001755
R18175 n1_M8_65940_70460 n1_M8_67020_70460 0.001755
R18176 n1_M8_67020_70460 n1_M8_68100_70460 0.001755
R18177 n1_M8_68100_70460 n1_M8_69180_70460 0.001755
R18178 n1_M8_69180_70460 n1_M8_70260_70460 0.001755
R18179 n1_M8_70260_70460 n1_M8_71340_70460 0.001755
R18180 n1_M8_71340_70460 n1_M8_72420_70460 0.001755
R18181 n1_M8_72420_70460 n1_M8_73500_70460 0.001755
R18182 n1_M8_73500_70460 n1_M8_74580_70460 0.001755
R18183 n1_M8_74580_70460 n1_M8_75660_70460 0.001755
R18184 n1_M8_75660_70460 n1_M8_76740_70460 0.001755
R18185 n1_M8_76740_70460 n1_M8_77820_70460 0.001755
R18186 n1_M8_77820_70460 n1_M8_78900_70460 0.001755
R18187 n1_M8_78900_70460 n1_M8_79980_70460 0.001755
R18188 n1_M8_79980_70460 n1_M8_81060_70460 0.001755
R18189 n1_M8_81060_70460 n1_M8_82140_70460 0.001755
R18190 n1_M8_82140_70460 n1_M8_83220_70460 0.001755
R18191 n1_M8_83220_70460 n1_M8_84300_70460 0.001755
R18192 n1_M8_84300_70460 n1_M8_85380_70460 0.001755
R18193 n1_M8_85380_70460 n1_M8_86460_70460 0.001755
R18194 n1_M8_86460_70460 n1_M8_87540_70460 0.001755
R18195 n1_M8_87540_70460 n1_M8_88620_70460 0.001755
R18196 n1_M8_88620_70460 n1_M8_89700_70460 0.001755
R18197 n1_M8_89700_70460 n1_M8_90780_70460 0.001755
R18198 n1_M8_90780_70460 n1_M8_91860_70460 0.001755
R18199 n1_M8_91860_70460 n1_M8_92940_70460 0.001755
R18200 n1_M8_92940_70460 n1_M8_94020_70460 0.001755
R18201 n1_M8_94020_70460 n1_M8_95100_70460 0.001755
R18202 n1_M8_95100_70460 n1_M8_96180_70460 0.001755
R18203 n1_M8_96180_70460 n1_M8_97260_70460 0.001755
R18204 n1_M8_97260_70460 n1_M8_98340_70460 0.001755
R18205 n1_M8_98340_70460 n1_M8_99420_70460 0.001755
R18206 n1_M8_99420_70460 n1_M8_100500_70460 0.001755
R18207 n1_M8_100500_70460 n1_M8_101580_70460 0.001755
R18208 n1_M8_101580_70460 n1_M8_102660_70460 0.001755
R18209 n1_M8_102660_70460 n1_M8_103740_70460 0.001755
R18210 n1_M8_103740_70460 n1_M8_104820_70460 0.001755
R18211 n1_M8_104820_70460 n1_M8_105900_70460 0.001755
R18212 n1_M8_105900_70460 n1_M8_106980_70460 0.001755
R18213 n1_M8_106980_70460 n1_M8_108060_70460 0.001755
R18214 n1_M8_108060_70460 n1_M8_109140_70460 0.001755
R18215 n1_M8_109140_70460 n1_M8_110220_70460 0.001755
R18216 n1_M8_110220_70460 n1_M8_111300_70460 0.001755
R18217 n1_M8_111300_70460 n1_M8_112380_70460 0.001755
R18218 n1_M8_112380_70460 n1_M8_113460_70460 0.001755
R18219 n1_M8_113460_70460 n1_M8_114540_70460 0.001755
R18220 n1_M8_114540_70460 n1_M8_115620_70460 0.001755
R18221 n1_M8_115620_70460 n1_M8_116700_70460 0.001755
R18222 n1_M8_116700_70460 n1_M8_117780_70460 0.001755
R18223 n1_M8_117780_70460 n1_M8_118860_70460 0.001755
R18224 n1_M8_118860_70460 n1_M8_119940_70460 0.001755
R18225 n1_M8_119940_70460 n1_M8_121020_70460 0.001755
R18226 n1_M8_121020_70460 n1_M8_122100_70460 0.001755
R18227 n1_M8_122100_70460 n1_M8_123180_70460 0.001755
R18228 n1_M8_123180_70460 n1_M8_124260_70460 0.001755
R18229 n1_M8_124260_70460 n1_M8_125340_70460 0.001755
R18230 n1_M8_125340_70460 n1_M8_126420_70460 0.001755
R18231 n1_M8_126420_70460 n1_M8_127500_70460 0.001755
R18232 n1_M8_127500_70460 n1_M8_128580_70460 0.001755
R18233 n1_M8_128580_70460 n1_M8_129660_70460 0.001755
R18234 n1_M8_60_76860 n1_M8_1140_76860 0.001755
R18235 n1_M8_1140_76860 n1_M8_2220_76860 0.001755
R18236 n1_M8_2220_76860 n1_M8_3300_76860 0.001755
R18237 n1_M8_3300_76860 n1_M8_4380_76860 0.001755
R18238 n1_M8_4380_76860 n1_M8_5460_76860 0.001755
R18239 n1_M8_5460_76860 n1_M8_6540_76860 0.001755
R18240 n1_M8_6540_76860 n1_M8_7620_76860 0.001755
R18241 n1_M8_7620_76860 n1_M8_8700_76860 0.001755
R18242 n1_M8_8700_76860 n1_M8_9780_76860 0.001755
R18243 n1_M8_9780_76860 n1_M8_10860_76860 0.001755
R18244 n1_M8_10860_76860 n1_M8_11940_76860 0.001755
R18245 n1_M8_11940_76860 n1_M8_13020_76860 0.001755
R18246 n1_M8_13020_76860 n1_M8_14100_76860 0.001755
R18247 n1_M8_14100_76860 n1_M8_15180_76860 0.001755
R18248 n1_M8_15180_76860 n1_M8_16260_76860 0.001755
R18249 n1_M8_16260_76860 n1_M8_17340_76860 0.001755
R18250 n1_M8_17340_76860 n1_M8_18420_76860 0.001755
R18251 n1_M8_18420_76860 n1_M8_19500_76860 0.001755
R18252 n1_M8_19500_76860 n1_M8_20580_76860 0.001755
R18253 n1_M8_20580_76860 n1_M8_21660_76860 0.001755
R18254 n1_M8_21660_76860 n1_M8_22740_76860 0.001755
R18255 n1_M8_22740_76860 n1_M8_23820_76860 0.001755
R18256 n1_M8_23820_76860 n1_M8_24900_76860 0.001755
R18257 n1_M8_24900_76860 n1_M8_25980_76860 0.001755
R18258 n1_M8_25980_76860 n1_M8_27060_76860 0.001755
R18259 n1_M8_27060_76860 n1_M8_28140_76860 0.001755
R18260 n1_M8_28140_76860 n1_M8_29220_76860 0.001755
R18261 n1_M8_29220_76860 n1_M8_30300_76860 0.001755
R18262 n1_M8_30300_76860 n1_M8_31380_76860 0.001755
R18263 n1_M8_31380_76860 n1_M8_32460_76860 0.001755
R18264 n1_M8_32460_76860 n1_M8_33540_76860 0.001755
R18265 n1_M8_33540_76860 n1_M8_34620_76860 0.001755
R18266 n1_M8_34620_76860 n1_M8_35700_76860 0.001755
R18267 n1_M8_35700_76860 n1_M8_36780_76860 0.001755
R18268 n1_M8_36780_76860 n1_M8_37860_76860 0.001755
R18269 n1_M8_37860_76860 n1_M8_38940_76860 0.001755
R18270 n1_M8_38940_76860 n1_M8_40020_76860 0.001755
R18271 n1_M8_40020_76860 n1_M8_41100_76860 0.001755
R18272 n1_M8_41100_76860 n1_M8_42180_76860 0.001755
R18273 n1_M8_42180_76860 n1_M8_43260_76860 0.001755
R18274 n1_M8_43260_76860 n1_M8_44340_76860 0.001755
R18275 n1_M8_44340_76860 n1_M8_45420_76860 0.001755
R18276 n1_M8_45420_76860 n1_M8_46500_76860 0.001755
R18277 n1_M8_46500_76860 n1_M8_47580_76860 0.001755
R18278 n1_M8_47580_76860 n1_M8_48660_76860 0.001755
R18279 n1_M8_48660_76860 n1_M8_49740_76860 0.001755
R18280 n1_M8_49740_76860 n1_M8_50820_76860 0.001755
R18281 n1_M8_50820_76860 n1_M8_51900_76860 0.001755
R18282 n1_M8_51900_76860 n1_M8_52980_76860 0.001755
R18283 n1_M8_52980_76860 n1_M8_54060_76860 0.001755
R18284 n1_M8_54060_76860 n1_M8_55140_76860 0.001755
R18285 n1_M8_55140_76860 n1_M8_56220_76860 0.001755
R18286 n1_M8_56220_76860 n1_M8_57300_76860 0.001755
R18287 n1_M8_57300_76860 n1_M8_58380_76860 0.001755
R18288 n1_M8_58380_76860 n1_M8_59460_76860 0.001755
R18289 n1_M8_59460_76860 n1_M8_60540_76860 0.001755
R18290 n1_M8_60540_76860 n1_M8_61620_76860 0.001755
R18291 n1_M8_61620_76860 n1_M8_62700_76860 0.001755
R18292 n1_M8_62700_76860 n1_M8_63780_76860 0.001755
R18293 n1_M8_63780_76860 n1_M8_64860_76860 0.001755
R18294 n1_M8_64860_76860 n1_M8_65940_76860 0.001755
R18295 n1_M8_65940_76860 n1_M8_67020_76860 0.001755
R18296 n1_M8_67020_76860 n1_M8_68100_76860 0.001755
R18297 n1_M8_68100_76860 n1_M8_69180_76860 0.001755
R18298 n1_M8_69180_76860 n1_M8_70260_76860 0.001755
R18299 n1_M8_70260_76860 n1_M8_71340_76860 0.001755
R18300 n1_M8_71340_76860 n1_M8_72420_76860 0.001755
R18301 n1_M8_72420_76860 n1_M8_73500_76860 0.001755
R18302 n1_M8_73500_76860 n1_M8_74580_76860 0.001755
R18303 n1_M8_74580_76860 n1_M8_75660_76860 0.001755
R18304 n1_M8_75660_76860 n1_M8_76740_76860 0.001755
R18305 n1_M8_76740_76860 n1_M8_77820_76860 0.001755
R18306 n1_M8_77820_76860 n1_M8_78900_76860 0.001755
R18307 n1_M8_78900_76860 n1_M8_79980_76860 0.001755
R18308 n1_M8_79980_76860 n1_M8_81060_76860 0.001755
R18309 n1_M8_81060_76860 n1_M8_82140_76860 0.001755
R18310 n1_M8_82140_76860 n1_M8_83220_76860 0.001755
R18311 n1_M8_83220_76860 n1_M8_84300_76860 0.001755
R18312 n1_M8_84300_76860 n1_M8_85380_76860 0.001755
R18313 n1_M8_85380_76860 n1_M8_86460_76860 0.001755
R18314 n1_M8_86460_76860 n1_M8_87540_76860 0.001755
R18315 n1_M8_87540_76860 n1_M8_88620_76860 0.001755
R18316 n1_M8_88620_76860 n1_M8_89700_76860 0.001755
R18317 n1_M8_89700_76860 n1_M8_90780_76860 0.001755
R18318 n1_M8_90780_76860 n1_M8_91860_76860 0.001755
R18319 n1_M8_91860_76860 n1_M8_92940_76860 0.001755
R18320 n1_M8_92940_76860 n1_M8_94020_76860 0.001755
R18321 n1_M8_94020_76860 n1_M8_95100_76860 0.001755
R18322 n1_M8_95100_76860 n1_M8_96180_76860 0.001755
R18323 n1_M8_96180_76860 n1_M8_97260_76860 0.001755
R18324 n1_M8_97260_76860 n1_M8_98340_76860 0.001755
R18325 n1_M8_98340_76860 n1_M8_99420_76860 0.001755
R18326 n1_M8_99420_76860 n1_M8_100500_76860 0.001755
R18327 n1_M8_100500_76860 n1_M8_101580_76860 0.001755
R18328 n1_M8_101580_76860 n1_M8_102660_76860 0.001755
R18329 n1_M8_102660_76860 n1_M8_103740_76860 0.001755
R18330 n1_M8_103740_76860 n1_M8_104820_76860 0.001755
R18331 n1_M8_104820_76860 n1_M8_105900_76860 0.001755
R18332 n1_M8_105900_76860 n1_M8_106980_76860 0.001755
R18333 n1_M8_106980_76860 n1_M8_108060_76860 0.001755
R18334 n1_M8_108060_76860 n1_M8_109140_76860 0.001755
R18335 n1_M8_109140_76860 n1_M8_110220_76860 0.001755
R18336 n1_M8_110220_76860 n1_M8_111300_76860 0.001755
R18337 n1_M8_111300_76860 n1_M8_112380_76860 0.001755
R18338 n1_M8_112380_76860 n1_M8_113460_76860 0.001755
R18339 n1_M8_113460_76860 n1_M8_114540_76860 0.001755
R18340 n1_M8_114540_76860 n1_M8_115620_76860 0.001755
R18341 n1_M8_115620_76860 n1_M8_116700_76860 0.001755
R18342 n1_M8_116700_76860 n1_M8_117780_76860 0.001755
R18343 n1_M8_117780_76860 n1_M8_118860_76860 0.001755
R18344 n1_M8_118860_76860 n1_M8_119940_76860 0.001755
R18345 n1_M8_119940_76860 n1_M8_121020_76860 0.001755
R18346 n1_M8_121020_76860 n1_M8_122100_76860 0.001755
R18347 n1_M8_122100_76860 n1_M8_123180_76860 0.001755
R18348 n1_M8_123180_76860 n1_M8_124260_76860 0.001755
R18349 n1_M8_124260_76860 n1_M8_125340_76860 0.001755
R18350 n1_M8_125340_76860 n1_M8_126420_76860 0.001755
R18351 n1_M8_126420_76860 n1_M8_127500_76860 0.001755
R18352 n1_M8_127500_76860 n1_M8_128580_76860 0.001755
R18353 n1_M8_128580_76860 n1_M8_129660_76860 0.001755
R18354 n1_M8_60_83260 n1_M8_1140_83260 0.001755
R18355 n1_M8_1140_83260 n1_M8_2220_83260 0.001755
R18356 n1_M8_2220_83260 n1_M8_3300_83260 0.001755
R18357 n1_M8_3300_83260 n1_M8_4380_83260 0.001755
R18358 n1_M8_4380_83260 n1_M8_5460_83260 0.001755
R18359 n1_M8_5460_83260 n1_M8_6540_83260 0.001755
R18360 n1_M8_6540_83260 n1_M8_7620_83260 0.001755
R18361 n1_M8_7620_83260 n1_M8_8700_83260 0.001755
R18362 n1_M8_8700_83260 n1_M8_9780_83260 0.001755
R18363 n1_M8_9780_83260 n1_M8_10860_83260 0.001755
R18364 n1_M8_10860_83260 n1_M8_11940_83260 0.001755
R18365 n1_M8_11940_83260 n1_M8_13020_83260 0.001755
R18366 n1_M8_13020_83260 n1_M8_14100_83260 0.001755
R18367 n1_M8_14100_83260 n1_M8_15180_83260 0.001755
R18368 n1_M8_15180_83260 n1_M8_16260_83260 0.001755
R18369 n1_M8_16260_83260 n1_M8_17340_83260 0.001755
R18370 n1_M8_17340_83260 n1_M8_18420_83260 0.001755
R18371 n1_M8_18420_83260 n1_M8_19500_83260 0.001755
R18372 n1_M8_19500_83260 n1_M8_20580_83260 0.001755
R18373 n1_M8_20580_83260 n1_M8_21660_83260 0.001755
R18374 n1_M8_21660_83260 n1_M8_22740_83260 0.001755
R18375 n1_M8_22740_83260 n1_M8_23820_83260 0.001755
R18376 n1_M8_23820_83260 n1_M8_24900_83260 0.001755
R18377 n1_M8_24900_83260 n1_M8_25980_83260 0.001755
R18378 n1_M8_25980_83260 n1_M8_27060_83260 0.001755
R18379 n1_M8_27060_83260 n1_M8_28140_83260 0.001755
R18380 n1_M8_28140_83260 n1_M8_29220_83260 0.001755
R18381 n1_M8_29220_83260 n1_M8_30300_83260 0.001755
R18382 n1_M8_30300_83260 n1_M8_31380_83260 0.001755
R18383 n1_M8_31380_83260 n1_M8_32460_83260 0.001755
R18384 n1_M8_32460_83260 n1_M8_33540_83260 0.001755
R18385 n1_M8_33540_83260 n1_M8_34620_83260 0.001755
R18386 n1_M8_34620_83260 n1_M8_35700_83260 0.001755
R18387 n1_M8_35700_83260 n1_M8_36780_83260 0.001755
R18388 n1_M8_36780_83260 n1_M8_37860_83260 0.001755
R18389 n1_M8_37860_83260 n1_M8_38940_83260 0.001755
R18390 n1_M8_38940_83260 n1_M8_40020_83260 0.001755
R18391 n1_M8_40020_83260 n1_M8_41100_83260 0.001755
R18392 n1_M8_41100_83260 n1_M8_42180_83260 0.001755
R18393 n1_M8_42180_83260 n1_M8_43260_83260 0.001755
R18394 n1_M8_43260_83260 n1_M8_44340_83260 0.001755
R18395 n1_M8_44340_83260 n1_M8_45420_83260 0.001755
R18396 n1_M8_45420_83260 n1_M8_46500_83260 0.001755
R18397 n1_M8_46500_83260 n1_M8_47580_83260 0.001755
R18398 n1_M8_47580_83260 n1_M8_48660_83260 0.001755
R18399 n1_M8_48660_83260 n1_M8_49740_83260 0.001755
R18400 n1_M8_49740_83260 n1_M8_50820_83260 0.001755
R18401 n1_M8_50820_83260 n1_M8_51900_83260 0.001755
R18402 n1_M8_51900_83260 n1_M8_52980_83260 0.001755
R18403 n1_M8_52980_83260 n1_M8_54060_83260 0.001755
R18404 n1_M8_54060_83260 n1_M8_55140_83260 0.001755
R18405 n1_M8_55140_83260 n1_M8_56220_83260 0.001755
R18406 n1_M8_56220_83260 n1_M8_57300_83260 0.001755
R18407 n1_M8_57300_83260 n1_M8_58380_83260 0.001755
R18408 n1_M8_58380_83260 n1_M8_59460_83260 0.001755
R18409 n1_M8_59460_83260 n1_M8_60540_83260 0.001755
R18410 n1_M8_60540_83260 n1_M8_61620_83260 0.001755
R18411 n1_M8_61620_83260 n1_M8_62700_83260 0.001755
R18412 n1_M8_62700_83260 n1_M8_63780_83260 0.001755
R18413 n1_M8_63780_83260 n1_M8_64860_83260 0.001755
R18414 n1_M8_64860_83260 n1_M8_65940_83260 0.001755
R18415 n1_M8_65940_83260 n1_M8_67020_83260 0.001755
R18416 n1_M8_67020_83260 n1_M8_68100_83260 0.001755
R18417 n1_M8_68100_83260 n1_M8_69180_83260 0.001755
R18418 n1_M8_69180_83260 n1_M8_70260_83260 0.001755
R18419 n1_M8_70260_83260 n1_M8_71340_83260 0.001755
R18420 n1_M8_71340_83260 n1_M8_72420_83260 0.001755
R18421 n1_M8_72420_83260 n1_M8_73500_83260 0.001755
R18422 n1_M8_73500_83260 n1_M8_74580_83260 0.001755
R18423 n1_M8_74580_83260 n1_M8_75660_83260 0.001755
R18424 n1_M8_75660_83260 n1_M8_76740_83260 0.001755
R18425 n1_M8_76740_83260 n1_M8_77820_83260 0.001755
R18426 n1_M8_77820_83260 n1_M8_78900_83260 0.001755
R18427 n1_M8_78900_83260 n1_M8_79980_83260 0.001755
R18428 n1_M8_79980_83260 n1_M8_81060_83260 0.001755
R18429 n1_M8_81060_83260 n1_M8_82140_83260 0.001755
R18430 n1_M8_82140_83260 n1_M8_83220_83260 0.001755
R18431 n1_M8_83220_83260 n1_M8_84300_83260 0.001755
R18432 n1_M8_84300_83260 n1_M8_85380_83260 0.001755
R18433 n1_M8_85380_83260 n1_M8_86460_83260 0.001755
R18434 n1_M8_86460_83260 n1_M8_87540_83260 0.001755
R18435 n1_M8_87540_83260 n1_M8_88620_83260 0.001755
R18436 n1_M8_88620_83260 n1_M8_89700_83260 0.001755
R18437 n1_M8_89700_83260 n1_M8_90780_83260 0.001755
R18438 n1_M8_90780_83260 n1_M8_91860_83260 0.001755
R18439 n1_M8_91860_83260 n1_M8_92940_83260 0.001755
R18440 n1_M8_92940_83260 n1_M8_94020_83260 0.001755
R18441 n1_M8_94020_83260 n1_M8_95100_83260 0.001755
R18442 n1_M8_95100_83260 n1_M8_96180_83260 0.001755
R18443 n1_M8_96180_83260 n1_M8_97260_83260 0.001755
R18444 n1_M8_97260_83260 n1_M8_98340_83260 0.001755
R18445 n1_M8_98340_83260 n1_M8_99420_83260 0.001755
R18446 n1_M8_99420_83260 n1_M8_100500_83260 0.001755
R18447 n1_M8_100500_83260 n1_M8_101580_83260 0.001755
R18448 n1_M8_101580_83260 n1_M8_102660_83260 0.001755
R18449 n1_M8_102660_83260 n1_M8_103740_83260 0.001755
R18450 n1_M8_103740_83260 n1_M8_104820_83260 0.001755
R18451 n1_M8_104820_83260 n1_M8_105900_83260 0.001755
R18452 n1_M8_105900_83260 n1_M8_106980_83260 0.001755
R18453 n1_M8_106980_83260 n1_M8_108060_83260 0.001755
R18454 n1_M8_108060_83260 n1_M8_109140_83260 0.001755
R18455 n1_M8_109140_83260 n1_M8_110220_83260 0.001755
R18456 n1_M8_110220_83260 n1_M8_111300_83260 0.001755
R18457 n1_M8_111300_83260 n1_M8_112380_83260 0.001755
R18458 n1_M8_112380_83260 n1_M8_113460_83260 0.001755
R18459 n1_M8_113460_83260 n1_M8_114540_83260 0.001755
R18460 n1_M8_114540_83260 n1_M8_115620_83260 0.001755
R18461 n1_M8_115620_83260 n1_M8_116700_83260 0.001755
R18462 n1_M8_116700_83260 n1_M8_117780_83260 0.001755
R18463 n1_M8_117780_83260 n1_M8_118860_83260 0.001755
R18464 n1_M8_118860_83260 n1_M8_119940_83260 0.001755
R18465 n1_M8_119940_83260 n1_M8_121020_83260 0.001755
R18466 n1_M8_121020_83260 n1_M8_122100_83260 0.001755
R18467 n1_M8_122100_83260 n1_M8_123180_83260 0.001755
R18468 n1_M8_123180_83260 n1_M8_124260_83260 0.001755
R18469 n1_M8_124260_83260 n1_M8_125340_83260 0.001755
R18470 n1_M8_125340_83260 n1_M8_126420_83260 0.001755
R18471 n1_M8_126420_83260 n1_M8_127500_83260 0.001755
R18472 n1_M8_127500_83260 n1_M8_128580_83260 0.001755
R18473 n1_M8_128580_83260 n1_M8_129660_83260 0.001755
R18474 n1_M8_60_89660 n1_M8_1140_89660 0.001755
R18475 n1_M8_1140_89660 n1_M8_2220_89660 0.001755
R18476 n1_M8_2220_89660 n1_M8_3300_89660 0.001755
R18477 n1_M8_3300_89660 n1_M8_4380_89660 0.001755
R18478 n1_M8_4380_89660 n1_M8_5460_89660 0.001755
R18479 n1_M8_5460_89660 n1_M8_6540_89660 0.001755
R18480 n1_M8_6540_89660 n1_M8_7620_89660 0.001755
R18481 n1_M8_7620_89660 n1_M8_8700_89660 0.001755
R18482 n1_M8_8700_89660 n1_M8_9780_89660 0.001755
R18483 n1_M8_9780_89660 n1_M8_10860_89660 0.001755
R18484 n1_M8_10860_89660 n1_M8_11940_89660 0.001755
R18485 n1_M8_11940_89660 n1_M8_13020_89660 0.001755
R18486 n1_M8_13020_89660 n1_M8_14100_89660 0.001755
R18487 n1_M8_14100_89660 n1_M8_15180_89660 0.001755
R18488 n1_M8_15180_89660 n1_M8_16260_89660 0.001755
R18489 n1_M8_16260_89660 n1_M8_17340_89660 0.001755
R18490 n1_M8_17340_89660 n1_M8_18420_89660 0.001755
R18491 n1_M8_18420_89660 n1_M8_19500_89660 0.001755
R18492 n1_M8_19500_89660 n1_M8_20580_89660 0.001755
R18493 n1_M8_20580_89660 n1_M8_21660_89660 0.001755
R18494 n1_M8_21660_89660 n1_M8_22740_89660 0.001755
R18495 n1_M8_22740_89660 n1_M8_23820_89660 0.001755
R18496 n1_M8_23820_89660 n1_M8_24900_89660 0.001755
R18497 n1_M8_24900_89660 n1_M8_25980_89660 0.001755
R18498 n1_M8_25980_89660 n1_M8_27060_89660 0.001755
R18499 n1_M8_27060_89660 n1_M8_28140_89660 0.001755
R18500 n1_M8_28140_89660 n1_M8_29220_89660 0.001755
R18501 n1_M8_29220_89660 n1_M8_30300_89660 0.001755
R18502 n1_M8_30300_89660 n1_M8_31380_89660 0.001755
R18503 n1_M8_31380_89660 n1_M8_32460_89660 0.001755
R18504 n1_M8_32460_89660 n1_M8_33540_89660 0.001755
R18505 n1_M8_33540_89660 n1_M8_34620_89660 0.001755
R18506 n1_M8_34620_89660 n1_M8_35700_89660 0.001755
R18507 n1_M8_35700_89660 n1_M8_36780_89660 0.001755
R18508 n1_M8_36780_89660 n1_M8_37860_89660 0.001755
R18509 n1_M8_37860_89660 n1_M8_38940_89660 0.001755
R18510 n1_M8_38940_89660 n1_M8_40020_89660 0.001755
R18511 n1_M8_40020_89660 n1_M8_41100_89660 0.001755
R18512 n1_M8_41100_89660 n1_M8_42180_89660 0.001755
R18513 n1_M8_42180_89660 n1_M8_43260_89660 0.001755
R18514 n1_M8_43260_89660 n1_M8_44340_89660 0.001755
R18515 n1_M8_44340_89660 n1_M8_45420_89660 0.001755
R18516 n1_M8_45420_89660 n1_M8_46500_89660 0.001755
R18517 n1_M8_46500_89660 n1_M8_47580_89660 0.001755
R18518 n1_M8_47580_89660 n1_M8_48660_89660 0.001755
R18519 n1_M8_48660_89660 n1_M8_49740_89660 0.001755
R18520 n1_M8_49740_89660 n1_M8_50820_89660 0.001755
R18521 n1_M8_50820_89660 n1_M8_51900_89660 0.001755
R18522 n1_M8_51900_89660 n1_M8_52980_89660 0.001755
R18523 n1_M8_52980_89660 n1_M8_54060_89660 0.001755
R18524 n1_M8_54060_89660 n1_M8_55140_89660 0.001755
R18525 n1_M8_55140_89660 n1_M8_56220_89660 0.001755
R18526 n1_M8_56220_89660 n1_M8_57300_89660 0.001755
R18527 n1_M8_57300_89660 n1_M8_58380_89660 0.001755
R18528 n1_M8_58380_89660 n1_M8_59460_89660 0.001755
R18529 n1_M8_59460_89660 n1_M8_60540_89660 0.001755
R18530 n1_M8_60540_89660 n1_M8_61620_89660 0.001755
R18531 n1_M8_61620_89660 n1_M8_62700_89660 0.001755
R18532 n1_M8_62700_89660 n1_M8_63780_89660 0.001755
R18533 n1_M8_63780_89660 n1_M8_64860_89660 0.001755
R18534 n1_M8_64860_89660 n1_M8_65940_89660 0.001755
R18535 n1_M8_65940_89660 n1_M8_67020_89660 0.001755
R18536 n1_M8_67020_89660 n1_M8_68100_89660 0.001755
R18537 n1_M8_68100_89660 n1_M8_69180_89660 0.001755
R18538 n1_M8_69180_89660 n1_M8_70260_89660 0.001755
R18539 n1_M8_70260_89660 n1_M8_71340_89660 0.001755
R18540 n1_M8_71340_89660 n1_M8_72420_89660 0.001755
R18541 n1_M8_72420_89660 n1_M8_73500_89660 0.001755
R18542 n1_M8_73500_89660 n1_M8_74580_89660 0.001755
R18543 n1_M8_74580_89660 n1_M8_75660_89660 0.001755
R18544 n1_M8_75660_89660 n1_M8_76740_89660 0.001755
R18545 n1_M8_76740_89660 n1_M8_77820_89660 0.001755
R18546 n1_M8_77820_89660 n1_M8_78900_89660 0.001755
R18547 n1_M8_78900_89660 n1_M8_79980_89660 0.001755
R18548 n1_M8_79980_89660 n1_M8_81060_89660 0.001755
R18549 n1_M8_81060_89660 n1_M8_82140_89660 0.001755
R18550 n1_M8_82140_89660 n1_M8_83220_89660 0.001755
R18551 n1_M8_83220_89660 n1_M8_84300_89660 0.001755
R18552 n1_M8_84300_89660 n1_M8_85380_89660 0.001755
R18553 n1_M8_85380_89660 n1_M8_86460_89660 0.001755
R18554 n1_M8_86460_89660 n1_M8_87540_89660 0.001755
R18555 n1_M8_87540_89660 n1_M8_88620_89660 0.001755
R18556 n1_M8_88620_89660 n1_M8_89700_89660 0.001755
R18557 n1_M8_89700_89660 n1_M8_90780_89660 0.001755
R18558 n1_M8_90780_89660 n1_M8_91860_89660 0.001755
R18559 n1_M8_91860_89660 n1_M8_92940_89660 0.001755
R18560 n1_M8_92940_89660 n1_M8_94020_89660 0.001755
R18561 n1_M8_94020_89660 n1_M8_95100_89660 0.001755
R18562 n1_M8_95100_89660 n1_M8_96180_89660 0.001755
R18563 n1_M8_96180_89660 n1_M8_97260_89660 0.001755
R18564 n1_M8_97260_89660 n1_M8_98340_89660 0.001755
R18565 n1_M8_98340_89660 n1_M8_99420_89660 0.001755
R18566 n1_M8_99420_89660 n1_M8_100500_89660 0.001755
R18567 n1_M8_100500_89660 n1_M8_101580_89660 0.001755
R18568 n1_M8_101580_89660 n1_M8_102660_89660 0.001755
R18569 n1_M8_102660_89660 n1_M8_103740_89660 0.001755
R18570 n1_M8_103740_89660 n1_M8_104820_89660 0.001755
R18571 n1_M8_104820_89660 n1_M8_105900_89660 0.001755
R18572 n1_M8_105900_89660 n1_M8_106980_89660 0.001755
R18573 n1_M8_106980_89660 n1_M8_108060_89660 0.001755
R18574 n1_M8_108060_89660 n1_M8_109140_89660 0.001755
R18575 n1_M8_109140_89660 n1_M8_110220_89660 0.001755
R18576 n1_M8_110220_89660 n1_M8_111300_89660 0.001755
R18577 n1_M8_111300_89660 n1_M8_112380_89660 0.001755
R18578 n1_M8_112380_89660 n1_M8_113460_89660 0.001755
R18579 n1_M8_113460_89660 n1_M8_114540_89660 0.001755
R18580 n1_M8_114540_89660 n1_M8_115620_89660 0.001755
R18581 n1_M8_115620_89660 n1_M8_116700_89660 0.001755
R18582 n1_M8_116700_89660 n1_M8_117780_89660 0.001755
R18583 n1_M8_117780_89660 n1_M8_118860_89660 0.001755
R18584 n1_M8_118860_89660 n1_M8_119940_89660 0.001755
R18585 n1_M8_119940_89660 n1_M8_121020_89660 0.001755
R18586 n1_M8_121020_89660 n1_M8_122100_89660 0.001755
R18587 n1_M8_122100_89660 n1_M8_123180_89660 0.001755
R18588 n1_M8_123180_89660 n1_M8_124260_89660 0.001755
R18589 n1_M8_124260_89660 n1_M8_125340_89660 0.001755
R18590 n1_M8_125340_89660 n1_M8_126420_89660 0.001755
R18591 n1_M8_126420_89660 n1_M8_127500_89660 0.001755
R18592 n1_M8_127500_89660 n1_M8_128580_89660 0.001755
R18593 n1_M8_128580_89660 n1_M8_129660_89660 0.001755
R18594 n1_M8_60_96060 n1_M8_1140_96060 0.001755
R18595 n1_M8_1140_96060 n1_M8_2220_96060 0.001755
R18596 n1_M8_2220_96060 n1_M8_3300_96060 0.001755
R18597 n1_M8_3300_96060 n1_M8_4380_96060 0.001755
R18598 n1_M8_4380_96060 n1_M8_5460_96060 0.001755
R18599 n1_M8_5460_96060 n1_M8_6540_96060 0.001755
R18600 n1_M8_6540_96060 n1_M8_7620_96060 0.001755
R18601 n1_M8_7620_96060 n1_M8_8700_96060 0.001755
R18602 n1_M8_8700_96060 n1_M8_9780_96060 0.001755
R18603 n1_M8_9780_96060 n1_M8_10860_96060 0.001755
R18604 n1_M8_10860_96060 n1_M8_11940_96060 0.001755
R18605 n1_M8_11940_96060 n1_M8_13020_96060 0.001755
R18606 n1_M8_13020_96060 n1_M8_14100_96060 0.001755
R18607 n1_M8_14100_96060 n1_M8_15180_96060 0.001755
R18608 n1_M8_15180_96060 n1_M8_16260_96060 0.001755
R18609 n1_M8_16260_96060 n1_M8_17340_96060 0.001755
R18610 n1_M8_17340_96060 n1_M8_18420_96060 0.001755
R18611 n1_M8_18420_96060 n1_M8_19500_96060 0.001755
R18612 n1_M8_19500_96060 n1_M8_20580_96060 0.001755
R18613 n1_M8_20580_96060 n1_M8_21660_96060 0.001755
R18614 n1_M8_21660_96060 n1_M8_22740_96060 0.001755
R18615 n1_M8_22740_96060 n1_M8_23820_96060 0.001755
R18616 n1_M8_23820_96060 n1_M8_24900_96060 0.001755
R18617 n1_M8_24900_96060 n1_M8_25980_96060 0.001755
R18618 n1_M8_25980_96060 n1_M8_27060_96060 0.001755
R18619 n1_M8_27060_96060 n1_M8_28140_96060 0.001755
R18620 n1_M8_28140_96060 n1_M8_29220_96060 0.001755
R18621 n1_M8_29220_96060 n1_M8_30300_96060 0.001755
R18622 n1_M8_30300_96060 n1_M8_31380_96060 0.001755
R18623 n1_M8_31380_96060 n1_M8_32460_96060 0.001755
R18624 n1_M8_32460_96060 n1_M8_33540_96060 0.001755
R18625 n1_M8_33540_96060 n1_M8_34620_96060 0.001755
R18626 n1_M8_34620_96060 n1_M8_35700_96060 0.001755
R18627 n1_M8_35700_96060 n1_M8_36780_96060 0.001755
R18628 n1_M8_36780_96060 n1_M8_37860_96060 0.001755
R18629 n1_M8_37860_96060 n1_M8_38940_96060 0.001755
R18630 n1_M8_38940_96060 n1_M8_40020_96060 0.001755
R18631 n1_M8_40020_96060 n1_M8_41100_96060 0.001755
R18632 n1_M8_41100_96060 n1_M8_42180_96060 0.001755
R18633 n1_M8_42180_96060 n1_M8_43260_96060 0.001755
R18634 n1_M8_43260_96060 n1_M8_44340_96060 0.001755
R18635 n1_M8_44340_96060 n1_M8_45420_96060 0.001755
R18636 n1_M8_45420_96060 n1_M8_46500_96060 0.001755
R18637 n1_M8_46500_96060 n1_M8_47580_96060 0.001755
R18638 n1_M8_47580_96060 n1_M8_48660_96060 0.001755
R18639 n1_M8_48660_96060 n1_M8_49740_96060 0.001755
R18640 n1_M8_49740_96060 n1_M8_50820_96060 0.001755
R18641 n1_M8_50820_96060 n1_M8_51900_96060 0.001755
R18642 n1_M8_51900_96060 n1_M8_52980_96060 0.001755
R18643 n1_M8_52980_96060 n1_M8_54060_96060 0.001755
R18644 n1_M8_54060_96060 n1_M8_55140_96060 0.001755
R18645 n1_M8_55140_96060 n1_M8_56220_96060 0.001755
R18646 n1_M8_56220_96060 n1_M8_57300_96060 0.001755
R18647 n1_M8_57300_96060 n1_M8_58380_96060 0.001755
R18648 n1_M8_58380_96060 n1_M8_59460_96060 0.001755
R18649 n1_M8_59460_96060 n1_M8_60540_96060 0.001755
R18650 n1_M8_60540_96060 n1_M8_61620_96060 0.001755
R18651 n1_M8_61620_96060 n1_M8_62700_96060 0.001755
R18652 n1_M8_62700_96060 n1_M8_63780_96060 0.001755
R18653 n1_M8_63780_96060 n1_M8_64860_96060 0.001755
R18654 n1_M8_64860_96060 n1_M8_65940_96060 0.001755
R18655 n1_M8_65940_96060 n1_M8_67020_96060 0.001755
R18656 n1_M8_67020_96060 n1_M8_68100_96060 0.001755
R18657 n1_M8_68100_96060 n1_M8_69180_96060 0.001755
R18658 n1_M8_69180_96060 n1_M8_70260_96060 0.001755
R18659 n1_M8_70260_96060 n1_M8_71340_96060 0.001755
R18660 n1_M8_71340_96060 n1_M8_72420_96060 0.001755
R18661 n1_M8_72420_96060 n1_M8_73500_96060 0.001755
R18662 n1_M8_73500_96060 n1_M8_74580_96060 0.001755
R18663 n1_M8_74580_96060 n1_M8_75660_96060 0.001755
R18664 n1_M8_75660_96060 n1_M8_76740_96060 0.001755
R18665 n1_M8_76740_96060 n1_M8_77820_96060 0.001755
R18666 n1_M8_77820_96060 n1_M8_78900_96060 0.001755
R18667 n1_M8_78900_96060 n1_M8_79980_96060 0.001755
R18668 n1_M8_79980_96060 n1_M8_81060_96060 0.001755
R18669 n1_M8_81060_96060 n1_M8_82140_96060 0.001755
R18670 n1_M8_82140_96060 n1_M8_83220_96060 0.001755
R18671 n1_M8_83220_96060 n1_M8_84300_96060 0.001755
R18672 n1_M8_84300_96060 n1_M8_85380_96060 0.001755
R18673 n1_M8_85380_96060 n1_M8_86460_96060 0.001755
R18674 n1_M8_86460_96060 n1_M8_87540_96060 0.001755
R18675 n1_M8_87540_96060 n1_M8_88620_96060 0.001755
R18676 n1_M8_88620_96060 n1_M8_89700_96060 0.001755
R18677 n1_M8_89700_96060 n1_M8_90780_96060 0.001755
R18678 n1_M8_90780_96060 n1_M8_91860_96060 0.001755
R18679 n1_M8_91860_96060 n1_M8_92940_96060 0.001755
R18680 n1_M8_92940_96060 n1_M8_94020_96060 0.001755
R18681 n1_M8_94020_96060 n1_M8_95100_96060 0.001755
R18682 n1_M8_95100_96060 n1_M8_96180_96060 0.001755
R18683 n1_M8_96180_96060 n1_M8_97260_96060 0.001755
R18684 n1_M8_97260_96060 n1_M8_98340_96060 0.001755
R18685 n1_M8_98340_96060 n1_M8_99420_96060 0.001755
R18686 n1_M8_99420_96060 n1_M8_100500_96060 0.001755
R18687 n1_M8_100500_96060 n1_M8_101580_96060 0.001755
R18688 n1_M8_101580_96060 n1_M8_102660_96060 0.001755
R18689 n1_M8_102660_96060 n1_M8_103740_96060 0.001755
R18690 n1_M8_103740_96060 n1_M8_104820_96060 0.001755
R18691 n1_M8_104820_96060 n1_M8_105900_96060 0.001755
R18692 n1_M8_105900_96060 n1_M8_106980_96060 0.001755
R18693 n1_M8_106980_96060 n1_M8_108060_96060 0.001755
R18694 n1_M8_108060_96060 n1_M8_109140_96060 0.001755
R18695 n1_M8_109140_96060 n1_M8_110220_96060 0.001755
R18696 n1_M8_110220_96060 n1_M8_111300_96060 0.001755
R18697 n1_M8_111300_96060 n1_M8_112380_96060 0.001755
R18698 n1_M8_112380_96060 n1_M8_113460_96060 0.001755
R18699 n1_M8_113460_96060 n1_M8_114540_96060 0.001755
R18700 n1_M8_114540_96060 n1_M8_115620_96060 0.001755
R18701 n1_M8_115620_96060 n1_M8_116700_96060 0.001755
R18702 n1_M8_116700_96060 n1_M8_117780_96060 0.001755
R18703 n1_M8_117780_96060 n1_M8_118860_96060 0.001755
R18704 n1_M8_118860_96060 n1_M8_119940_96060 0.001755
R18705 n1_M8_119940_96060 n1_M8_121020_96060 0.001755
R18706 n1_M8_121020_96060 n1_M8_122100_96060 0.001755
R18707 n1_M8_122100_96060 n1_M8_123180_96060 0.001755
R18708 n1_M8_123180_96060 n1_M8_124260_96060 0.001755
R18709 n1_M8_124260_96060 n1_M8_125340_96060 0.001755
R18710 n1_M8_125340_96060 n1_M8_126420_96060 0.001755
R18711 n1_M8_126420_96060 n1_M8_127500_96060 0.001755
R18712 n1_M8_127500_96060 n1_M8_128580_96060 0.001755
R18713 n1_M8_128580_96060 n1_M8_129660_96060 0.001755
R18714 n1_M8_60_102460 n1_M8_1140_102460 0.001755
R18715 n1_M8_1140_102460 n1_M8_2220_102460 0.001755
R18716 n1_M8_2220_102460 n1_M8_3300_102460 0.001755
R18717 n1_M8_3300_102460 n1_M8_4380_102460 0.001755
R18718 n1_M8_4380_102460 n1_M8_5460_102460 0.001755
R18719 n1_M8_5460_102460 n1_M8_6540_102460 0.001755
R18720 n1_M8_6540_102460 n1_M8_7620_102460 0.001755
R18721 n1_M8_7620_102460 n1_M8_8700_102460 0.001755
R18722 n1_M8_8700_102460 n1_M8_9780_102460 0.001755
R18723 n1_M8_9780_102460 n1_M8_10860_102460 0.001755
R18724 n1_M8_10860_102460 n1_M8_11940_102460 0.001755
R18725 n1_M8_11940_102460 n1_M8_13020_102460 0.001755
R18726 n1_M8_13020_102460 n1_M8_14100_102460 0.001755
R18727 n1_M8_14100_102460 n1_M8_15180_102460 0.001755
R18728 n1_M8_15180_102460 n1_M8_16260_102460 0.001755
R18729 n1_M8_16260_102460 n1_M8_17340_102460 0.001755
R18730 n1_M8_17340_102460 n1_M8_18420_102460 0.001755
R18731 n1_M8_18420_102460 n1_M8_19500_102460 0.001755
R18732 n1_M8_19500_102460 n1_M8_20580_102460 0.001755
R18733 n1_M8_20580_102460 n1_M8_21660_102460 0.001755
R18734 n1_M8_21660_102460 n1_M8_22740_102460 0.001755
R18735 n1_M8_22740_102460 n1_M8_23820_102460 0.001755
R18736 n1_M8_23820_102460 n1_M8_24900_102460 0.001755
R18737 n1_M8_24900_102460 n1_M8_25980_102460 0.001755
R18738 n1_M8_25980_102460 n1_M8_27060_102460 0.001755
R18739 n1_M8_27060_102460 n1_M8_28140_102460 0.001755
R18740 n1_M8_28140_102460 n1_M8_29220_102460 0.001755
R18741 n1_M8_29220_102460 n1_M8_30300_102460 0.001755
R18742 n1_M8_30300_102460 n1_M8_31380_102460 0.001755
R18743 n1_M8_31380_102460 n1_M8_32460_102460 0.001755
R18744 n1_M8_32460_102460 n1_M8_33540_102460 0.001755
R18745 n1_M8_33540_102460 n1_M8_34620_102460 0.001755
R18746 n1_M8_34620_102460 n1_M8_35700_102460 0.001755
R18747 n1_M8_35700_102460 n1_M8_36780_102460 0.001755
R18748 n1_M8_36780_102460 n1_M8_37860_102460 0.001755
R18749 n1_M8_37860_102460 n1_M8_38940_102460 0.001755
R18750 n1_M8_38940_102460 n1_M8_40020_102460 0.001755
R18751 n1_M8_40020_102460 n1_M8_41100_102460 0.001755
R18752 n1_M8_41100_102460 n1_M8_42180_102460 0.001755
R18753 n1_M8_42180_102460 n1_M8_43260_102460 0.001755
R18754 n1_M8_43260_102460 n1_M8_44340_102460 0.001755
R18755 n1_M8_44340_102460 n1_M8_45420_102460 0.001755
R18756 n1_M8_45420_102460 n1_M8_46500_102460 0.001755
R18757 n1_M8_46500_102460 n1_M8_47580_102460 0.001755
R18758 n1_M8_47580_102460 n1_M8_48660_102460 0.001755
R18759 n1_M8_48660_102460 n1_M8_49740_102460 0.001755
R18760 n1_M8_49740_102460 n1_M8_50820_102460 0.001755
R18761 n1_M8_50820_102460 n1_M8_51900_102460 0.001755
R18762 n1_M8_51900_102460 n1_M8_52980_102460 0.001755
R18763 n1_M8_52980_102460 n1_M8_54060_102460 0.001755
R18764 n1_M8_54060_102460 n1_M8_55140_102460 0.001755
R18765 n1_M8_55140_102460 n1_M8_56220_102460 0.001755
R18766 n1_M8_56220_102460 n1_M8_57300_102460 0.001755
R18767 n1_M8_57300_102460 n1_M8_58380_102460 0.001755
R18768 n1_M8_58380_102460 n1_M8_59460_102460 0.001755
R18769 n1_M8_59460_102460 n1_M8_60540_102460 0.001755
R18770 n1_M8_60540_102460 n1_M8_61620_102460 0.001755
R18771 n1_M8_61620_102460 n1_M8_62700_102460 0.001755
R18772 n1_M8_62700_102460 n1_M8_63780_102460 0.001755
R18773 n1_M8_63780_102460 n1_M8_64860_102460 0.001755
R18774 n1_M8_64860_102460 n1_M8_65940_102460 0.001755
R18775 n1_M8_65940_102460 n1_M8_67020_102460 0.001755
R18776 n1_M8_67020_102460 n1_M8_68100_102460 0.001755
R18777 n1_M8_68100_102460 n1_M8_69180_102460 0.001755
R18778 n1_M8_69180_102460 n1_M8_70260_102460 0.001755
R18779 n1_M8_70260_102460 n1_M8_71340_102460 0.001755
R18780 n1_M8_71340_102460 n1_M8_72420_102460 0.001755
R18781 n1_M8_72420_102460 n1_M8_73500_102460 0.001755
R18782 n1_M8_73500_102460 n1_M8_74580_102460 0.001755
R18783 n1_M8_74580_102460 n1_M8_75660_102460 0.001755
R18784 n1_M8_75660_102460 n1_M8_76740_102460 0.001755
R18785 n1_M8_76740_102460 n1_M8_77820_102460 0.001755
R18786 n1_M8_77820_102460 n1_M8_78900_102460 0.001755
R18787 n1_M8_78900_102460 n1_M8_79980_102460 0.001755
R18788 n1_M8_79980_102460 n1_M8_81060_102460 0.001755
R18789 n1_M8_81060_102460 n1_M8_82140_102460 0.001755
R18790 n1_M8_82140_102460 n1_M8_83220_102460 0.001755
R18791 n1_M8_83220_102460 n1_M8_84300_102460 0.001755
R18792 n1_M8_84300_102460 n1_M8_85380_102460 0.001755
R18793 n1_M8_85380_102460 n1_M8_86460_102460 0.001755
R18794 n1_M8_86460_102460 n1_M8_87540_102460 0.001755
R18795 n1_M8_87540_102460 n1_M8_88620_102460 0.001755
R18796 n1_M8_88620_102460 n1_M8_89700_102460 0.001755
R18797 n1_M8_89700_102460 n1_M8_90780_102460 0.001755
R18798 n1_M8_90780_102460 n1_M8_91860_102460 0.001755
R18799 n1_M8_91860_102460 n1_M8_92940_102460 0.001755
R18800 n1_M8_92940_102460 n1_M8_94020_102460 0.001755
R18801 n1_M8_94020_102460 n1_M8_95100_102460 0.001755
R18802 n1_M8_95100_102460 n1_M8_96180_102460 0.001755
R18803 n1_M8_96180_102460 n1_M8_97260_102460 0.001755
R18804 n1_M8_97260_102460 n1_M8_98340_102460 0.001755
R18805 n1_M8_98340_102460 n1_M8_99420_102460 0.001755
R18806 n1_M8_99420_102460 n1_M8_100500_102460 0.001755
R18807 n1_M8_100500_102460 n1_M8_101580_102460 0.001755
R18808 n1_M8_101580_102460 n1_M8_102660_102460 0.001755
R18809 n1_M8_102660_102460 n1_M8_103740_102460 0.001755
R18810 n1_M8_103740_102460 n1_M8_104820_102460 0.001755
R18811 n1_M8_104820_102460 n1_M8_105900_102460 0.001755
R18812 n1_M8_105900_102460 n1_M8_106980_102460 0.001755
R18813 n1_M8_106980_102460 n1_M8_108060_102460 0.001755
R18814 n1_M8_108060_102460 n1_M8_109140_102460 0.001755
R18815 n1_M8_109140_102460 n1_M8_110220_102460 0.001755
R18816 n1_M8_110220_102460 n1_M8_111300_102460 0.001755
R18817 n1_M8_111300_102460 n1_M8_112380_102460 0.001755
R18818 n1_M8_112380_102460 n1_M8_113460_102460 0.001755
R18819 n1_M8_113460_102460 n1_M8_114540_102460 0.001755
R18820 n1_M8_114540_102460 n1_M8_115620_102460 0.001755
R18821 n1_M8_115620_102460 n1_M8_116700_102460 0.001755
R18822 n1_M8_116700_102460 n1_M8_117780_102460 0.001755
R18823 n1_M8_117780_102460 n1_M8_118860_102460 0.001755
R18824 n1_M8_118860_102460 n1_M8_119940_102460 0.001755
R18825 n1_M8_119940_102460 n1_M8_121020_102460 0.001755
R18826 n1_M8_121020_102460 n1_M8_122100_102460 0.001755
R18827 n1_M8_122100_102460 n1_M8_123180_102460 0.001755
R18828 n1_M8_123180_102460 n1_M8_124260_102460 0.001755
R18829 n1_M8_124260_102460 n1_M8_125340_102460 0.001755
R18830 n1_M8_125340_102460 n1_M8_126420_102460 0.001755
R18831 n1_M8_126420_102460 n1_M8_127500_102460 0.001755
R18832 n1_M8_127500_102460 n1_M8_128580_102460 0.001755
R18833 n1_M8_128580_102460 n1_M8_129660_102460 0.001755
R18834 n1_M8_60_108860 n1_M8_1140_108860 0.001755
R18835 n1_M8_1140_108860 n1_M8_2220_108860 0.001755
R18836 n1_M8_2220_108860 n1_M8_3300_108860 0.001755
R18837 n1_M8_3300_108860 n1_M8_4380_108860 0.001755
R18838 n1_M8_4380_108860 n1_M8_5460_108860 0.001755
R18839 n1_M8_5460_108860 n1_M8_6540_108860 0.001755
R18840 n1_M8_6540_108860 n1_M8_7620_108860 0.001755
R18841 n1_M8_7620_108860 n1_M8_8700_108860 0.001755
R18842 n1_M8_8700_108860 n1_M8_9780_108860 0.001755
R18843 n1_M8_9780_108860 n1_M8_10860_108860 0.001755
R18844 n1_M8_10860_108860 n1_M8_11940_108860 0.001755
R18845 n1_M8_11940_108860 n1_M8_13020_108860 0.001755
R18846 n1_M8_13020_108860 n1_M8_14100_108860 0.001755
R18847 n1_M8_14100_108860 n1_M8_15180_108860 0.001755
R18848 n1_M8_15180_108860 n1_M8_16260_108860 0.001755
R18849 n1_M8_16260_108860 n1_M8_17340_108860 0.001755
R18850 n1_M8_17340_108860 n1_M8_18420_108860 0.001755
R18851 n1_M8_18420_108860 n1_M8_19500_108860 0.001755
R18852 n1_M8_19500_108860 n1_M8_20580_108860 0.001755
R18853 n1_M8_20580_108860 n1_M8_21660_108860 0.001755
R18854 n1_M8_21660_108860 n1_M8_22740_108860 0.001755
R18855 n1_M8_22740_108860 n1_M8_23820_108860 0.001755
R18856 n1_M8_23820_108860 n1_M8_24900_108860 0.001755
R18857 n1_M8_24900_108860 n1_M8_25980_108860 0.001755
R18858 n1_M8_25980_108860 n1_M8_27060_108860 0.001755
R18859 n1_M8_27060_108860 n1_M8_28140_108860 0.001755
R18860 n1_M8_28140_108860 n1_M8_29220_108860 0.001755
R18861 n1_M8_29220_108860 n1_M8_30300_108860 0.001755
R18862 n1_M8_30300_108860 n1_M8_31380_108860 0.001755
R18863 n1_M8_31380_108860 n1_M8_32460_108860 0.001755
R18864 n1_M8_32460_108860 n1_M8_33540_108860 0.001755
R18865 n1_M8_33540_108860 n1_M8_34620_108860 0.001755
R18866 n1_M8_34620_108860 n1_M8_35700_108860 0.001755
R18867 n1_M8_35700_108860 n1_M8_36780_108860 0.001755
R18868 n1_M8_36780_108860 n1_M8_37860_108860 0.001755
R18869 n1_M8_37860_108860 n1_M8_38940_108860 0.001755
R18870 n1_M8_38940_108860 n1_M8_40020_108860 0.001755
R18871 n1_M8_40020_108860 n1_M8_41100_108860 0.001755
R18872 n1_M8_41100_108860 n1_M8_42180_108860 0.001755
R18873 n1_M8_42180_108860 n1_M8_43260_108860 0.001755
R18874 n1_M8_43260_108860 n1_M8_44340_108860 0.001755
R18875 n1_M8_44340_108860 n1_M8_45420_108860 0.001755
R18876 n1_M8_45420_108860 n1_M8_46500_108860 0.001755
R18877 n1_M8_46500_108860 n1_M8_47580_108860 0.001755
R18878 n1_M8_47580_108860 n1_M8_48660_108860 0.001755
R18879 n1_M8_48660_108860 n1_M8_49740_108860 0.001755
R18880 n1_M8_49740_108860 n1_M8_50820_108860 0.001755
R18881 n1_M8_50820_108860 n1_M8_51900_108860 0.001755
R18882 n1_M8_51900_108860 n1_M8_52980_108860 0.001755
R18883 n1_M8_52980_108860 n1_M8_54060_108860 0.001755
R18884 n1_M8_54060_108860 n1_M8_55140_108860 0.001755
R18885 n1_M8_55140_108860 n1_M8_56220_108860 0.001755
R18886 n1_M8_56220_108860 n1_M8_57300_108860 0.001755
R18887 n1_M8_57300_108860 n1_M8_58380_108860 0.001755
R18888 n1_M8_58380_108860 n1_M8_59460_108860 0.001755
R18889 n1_M8_59460_108860 n1_M8_60540_108860 0.001755
R18890 n1_M8_60540_108860 n1_M8_61620_108860 0.001755
R18891 n1_M8_61620_108860 n1_M8_62700_108860 0.001755
R18892 n1_M8_62700_108860 n1_M8_63780_108860 0.001755
R18893 n1_M8_63780_108860 n1_M8_64860_108860 0.001755
R18894 n1_M8_64860_108860 n1_M8_65940_108860 0.001755
R18895 n1_M8_65940_108860 n1_M8_67020_108860 0.001755
R18896 n1_M8_67020_108860 n1_M8_68100_108860 0.001755
R18897 n1_M8_68100_108860 n1_M8_69180_108860 0.001755
R18898 n1_M8_69180_108860 n1_M8_70260_108860 0.001755
R18899 n1_M8_70260_108860 n1_M8_71340_108860 0.001755
R18900 n1_M8_71340_108860 n1_M8_72420_108860 0.001755
R18901 n1_M8_72420_108860 n1_M8_73500_108860 0.001755
R18902 n1_M8_73500_108860 n1_M8_74580_108860 0.001755
R18903 n1_M8_74580_108860 n1_M8_75660_108860 0.001755
R18904 n1_M8_75660_108860 n1_M8_76740_108860 0.001755
R18905 n1_M8_76740_108860 n1_M8_77820_108860 0.001755
R18906 n1_M8_77820_108860 n1_M8_78900_108860 0.001755
R18907 n1_M8_78900_108860 n1_M8_79980_108860 0.001755
R18908 n1_M8_79980_108860 n1_M8_81060_108860 0.001755
R18909 n1_M8_81060_108860 n1_M8_82140_108860 0.001755
R18910 n1_M8_82140_108860 n1_M8_83220_108860 0.001755
R18911 n1_M8_83220_108860 n1_M8_84300_108860 0.001755
R18912 n1_M8_84300_108860 n1_M8_85380_108860 0.001755
R18913 n1_M8_85380_108860 n1_M8_86460_108860 0.001755
R18914 n1_M8_86460_108860 n1_M8_87540_108860 0.001755
R18915 n1_M8_87540_108860 n1_M8_88620_108860 0.001755
R18916 n1_M8_88620_108860 n1_M8_89700_108860 0.001755
R18917 n1_M8_89700_108860 n1_M8_90780_108860 0.001755
R18918 n1_M8_90780_108860 n1_M8_91860_108860 0.001755
R18919 n1_M8_91860_108860 n1_M8_92940_108860 0.001755
R18920 n1_M8_92940_108860 n1_M8_94020_108860 0.001755
R18921 n1_M8_94020_108860 n1_M8_95100_108860 0.001755
R18922 n1_M8_95100_108860 n1_M8_96180_108860 0.001755
R18923 n1_M8_96180_108860 n1_M8_97260_108860 0.001755
R18924 n1_M8_97260_108860 n1_M8_98340_108860 0.001755
R18925 n1_M8_98340_108860 n1_M8_99420_108860 0.001755
R18926 n1_M8_99420_108860 n1_M8_100500_108860 0.001755
R18927 n1_M8_100500_108860 n1_M8_101580_108860 0.001755
R18928 n1_M8_101580_108860 n1_M8_102660_108860 0.001755
R18929 n1_M8_102660_108860 n1_M8_103740_108860 0.001755
R18930 n1_M8_103740_108860 n1_M8_104820_108860 0.001755
R18931 n1_M8_104820_108860 n1_M8_105900_108860 0.001755
R18932 n1_M8_105900_108860 n1_M8_106980_108860 0.001755
R18933 n1_M8_106980_108860 n1_M8_108060_108860 0.001755
R18934 n1_M8_108060_108860 n1_M8_109140_108860 0.001755
R18935 n1_M8_109140_108860 n1_M8_110220_108860 0.001755
R18936 n1_M8_110220_108860 n1_M8_111300_108860 0.001755
R18937 n1_M8_111300_108860 n1_M8_112380_108860 0.001755
R18938 n1_M8_112380_108860 n1_M8_113460_108860 0.001755
R18939 n1_M8_113460_108860 n1_M8_114540_108860 0.001755
R18940 n1_M8_114540_108860 n1_M8_115620_108860 0.001755
R18941 n1_M8_115620_108860 n1_M8_116700_108860 0.001755
R18942 n1_M8_116700_108860 n1_M8_117780_108860 0.001755
R18943 n1_M8_117780_108860 n1_M8_118860_108860 0.001755
R18944 n1_M8_118860_108860 n1_M8_119940_108860 0.001755
R18945 n1_M8_119940_108860 n1_M8_121020_108860 0.001755
R18946 n1_M8_121020_108860 n1_M8_122100_108860 0.001755
R18947 n1_M8_122100_108860 n1_M8_123180_108860 0.001755
R18948 n1_M8_123180_108860 n1_M8_124260_108860 0.001755
R18949 n1_M8_124260_108860 n1_M8_125340_108860 0.001755
R18950 n1_M8_125340_108860 n1_M8_126420_108860 0.001755
R18951 n1_M8_126420_108860 n1_M8_127500_108860 0.001755
R18952 n1_M8_127500_108860 n1_M8_128580_108860 0.001755
R18953 n1_M8_128580_108860 n1_M8_129660_108860 0.001755
R18954 n1_M8_60_115260 n1_M8_1140_115260 0.001755
R18955 n1_M8_1140_115260 n1_M8_2220_115260 0.001755
R18956 n1_M8_2220_115260 n1_M8_3300_115260 0.001755
R18957 n1_M8_3300_115260 n1_M8_4380_115260 0.001755
R18958 n1_M8_4380_115260 n1_M8_5460_115260 0.001755
R18959 n1_M8_5460_115260 n1_M8_6540_115260 0.001755
R18960 n1_M8_6540_115260 n1_M8_7620_115260 0.001755
R18961 n1_M8_7620_115260 n1_M8_8700_115260 0.001755
R18962 n1_M8_8700_115260 n1_M8_9780_115260 0.001755
R18963 n1_M8_9780_115260 n1_M8_10860_115260 0.001755
R18964 n1_M8_10860_115260 n1_M8_11940_115260 0.001755
R18965 n1_M8_11940_115260 n1_M8_13020_115260 0.001755
R18966 n1_M8_13020_115260 n1_M8_14100_115260 0.001755
R18967 n1_M8_14100_115260 n1_M8_15180_115260 0.001755
R18968 n1_M8_15180_115260 n1_M8_16260_115260 0.001755
R18969 n1_M8_16260_115260 n1_M8_17340_115260 0.001755
R18970 n1_M8_17340_115260 n1_M8_18420_115260 0.001755
R18971 n1_M8_18420_115260 n1_M8_19500_115260 0.001755
R18972 n1_M8_19500_115260 n1_M8_20580_115260 0.001755
R18973 n1_M8_20580_115260 n1_M8_21660_115260 0.001755
R18974 n1_M8_21660_115260 n1_M8_22740_115260 0.001755
R18975 n1_M8_22740_115260 n1_M8_23820_115260 0.001755
R18976 n1_M8_23820_115260 n1_M8_24900_115260 0.001755
R18977 n1_M8_24900_115260 n1_M8_25980_115260 0.001755
R18978 n1_M8_25980_115260 n1_M8_27060_115260 0.001755
R18979 n1_M8_27060_115260 n1_M8_28140_115260 0.001755
R18980 n1_M8_28140_115260 n1_M8_29220_115260 0.001755
R18981 n1_M8_29220_115260 n1_M8_30300_115260 0.001755
R18982 n1_M8_30300_115260 n1_M8_31380_115260 0.001755
R18983 n1_M8_31380_115260 n1_M8_32460_115260 0.001755
R18984 n1_M8_32460_115260 n1_M8_33540_115260 0.001755
R18985 n1_M8_33540_115260 n1_M8_34620_115260 0.001755
R18986 n1_M8_34620_115260 n1_M8_35700_115260 0.001755
R18987 n1_M8_35700_115260 n1_M8_36780_115260 0.001755
R18988 n1_M8_36780_115260 n1_M8_37860_115260 0.001755
R18989 n1_M8_37860_115260 n1_M8_38940_115260 0.001755
R18990 n1_M8_38940_115260 n1_M8_40020_115260 0.001755
R18991 n1_M8_40020_115260 n1_M8_41100_115260 0.001755
R18992 n1_M8_41100_115260 n1_M8_42180_115260 0.001755
R18993 n1_M8_42180_115260 n1_M8_43260_115260 0.001755
R18994 n1_M8_43260_115260 n1_M8_44340_115260 0.001755
R18995 n1_M8_44340_115260 n1_M8_45420_115260 0.001755
R18996 n1_M8_45420_115260 n1_M8_46500_115260 0.001755
R18997 n1_M8_46500_115260 n1_M8_47580_115260 0.001755
R18998 n1_M8_47580_115260 n1_M8_48660_115260 0.001755
R18999 n1_M8_48660_115260 n1_M8_49740_115260 0.001755
R19000 n1_M8_49740_115260 n1_M8_50820_115260 0.001755
R19001 n1_M8_50820_115260 n1_M8_51900_115260 0.001755
R19002 n1_M8_51900_115260 n1_M8_52980_115260 0.001755
R19003 n1_M8_52980_115260 n1_M8_54060_115260 0.001755
R19004 n1_M8_54060_115260 n1_M8_55140_115260 0.001755
R19005 n1_M8_55140_115260 n1_M8_56220_115260 0.001755
R19006 n1_M8_56220_115260 n1_M8_57300_115260 0.001755
R19007 n1_M8_57300_115260 n1_M8_58380_115260 0.001755
R19008 n1_M8_58380_115260 n1_M8_59460_115260 0.001755
R19009 n1_M8_59460_115260 n1_M8_60540_115260 0.001755
R19010 n1_M8_60540_115260 n1_M8_61620_115260 0.001755
R19011 n1_M8_61620_115260 n1_M8_62700_115260 0.001755
R19012 n1_M8_62700_115260 n1_M8_63780_115260 0.001755
R19013 n1_M8_63780_115260 n1_M8_64860_115260 0.001755
R19014 n1_M8_64860_115260 n1_M8_65940_115260 0.001755
R19015 n1_M8_65940_115260 n1_M8_67020_115260 0.001755
R19016 n1_M8_67020_115260 n1_M8_68100_115260 0.001755
R19017 n1_M8_68100_115260 n1_M8_69180_115260 0.001755
R19018 n1_M8_69180_115260 n1_M8_70260_115260 0.001755
R19019 n1_M8_70260_115260 n1_M8_71340_115260 0.001755
R19020 n1_M8_71340_115260 n1_M8_72420_115260 0.001755
R19021 n1_M8_72420_115260 n1_M8_73500_115260 0.001755
R19022 n1_M8_73500_115260 n1_M8_74580_115260 0.001755
R19023 n1_M8_74580_115260 n1_M8_75660_115260 0.001755
R19024 n1_M8_75660_115260 n1_M8_76740_115260 0.001755
R19025 n1_M8_76740_115260 n1_M8_77820_115260 0.001755
R19026 n1_M8_77820_115260 n1_M8_78900_115260 0.001755
R19027 n1_M8_78900_115260 n1_M8_79980_115260 0.001755
R19028 n1_M8_79980_115260 n1_M8_81060_115260 0.001755
R19029 n1_M8_81060_115260 n1_M8_82140_115260 0.001755
R19030 n1_M8_82140_115260 n1_M8_83220_115260 0.001755
R19031 n1_M8_83220_115260 n1_M8_84300_115260 0.001755
R19032 n1_M8_84300_115260 n1_M8_85380_115260 0.001755
R19033 n1_M8_85380_115260 n1_M8_86460_115260 0.001755
R19034 n1_M8_86460_115260 n1_M8_87540_115260 0.001755
R19035 n1_M8_87540_115260 n1_M8_88620_115260 0.001755
R19036 n1_M8_88620_115260 n1_M8_89700_115260 0.001755
R19037 n1_M8_89700_115260 n1_M8_90780_115260 0.001755
R19038 n1_M8_90780_115260 n1_M8_91860_115260 0.001755
R19039 n1_M8_91860_115260 n1_M8_92940_115260 0.001755
R19040 n1_M8_92940_115260 n1_M8_94020_115260 0.001755
R19041 n1_M8_94020_115260 n1_M8_95100_115260 0.001755
R19042 n1_M8_95100_115260 n1_M8_96180_115260 0.001755
R19043 n1_M8_96180_115260 n1_M8_97260_115260 0.001755
R19044 n1_M8_97260_115260 n1_M8_98340_115260 0.001755
R19045 n1_M8_98340_115260 n1_M8_99420_115260 0.001755
R19046 n1_M8_99420_115260 n1_M8_100500_115260 0.001755
R19047 n1_M8_100500_115260 n1_M8_101580_115260 0.001755
R19048 n1_M8_101580_115260 n1_M8_102660_115260 0.001755
R19049 n1_M8_102660_115260 n1_M8_103740_115260 0.001755
R19050 n1_M8_103740_115260 n1_M8_104820_115260 0.001755
R19051 n1_M8_104820_115260 n1_M8_105900_115260 0.001755
R19052 n1_M8_105900_115260 n1_M8_106980_115260 0.001755
R19053 n1_M8_106980_115260 n1_M8_108060_115260 0.001755
R19054 n1_M8_108060_115260 n1_M8_109140_115260 0.001755
R19055 n1_M8_109140_115260 n1_M8_110220_115260 0.001755
R19056 n1_M8_110220_115260 n1_M8_111300_115260 0.001755
R19057 n1_M8_111300_115260 n1_M8_112380_115260 0.001755
R19058 n1_M8_112380_115260 n1_M8_113460_115260 0.001755
R19059 n1_M8_113460_115260 n1_M8_114540_115260 0.001755
R19060 n1_M8_114540_115260 n1_M8_115620_115260 0.001755
R19061 n1_M8_115620_115260 n1_M8_116700_115260 0.001755
R19062 n1_M8_116700_115260 n1_M8_117780_115260 0.001755
R19063 n1_M8_117780_115260 n1_M8_118860_115260 0.001755
R19064 n1_M8_118860_115260 n1_M8_119940_115260 0.001755
R19065 n1_M8_119940_115260 n1_M8_121020_115260 0.001755
R19066 n1_M8_121020_115260 n1_M8_122100_115260 0.001755
R19067 n1_M8_122100_115260 n1_M8_123180_115260 0.001755
R19068 n1_M8_123180_115260 n1_M8_124260_115260 0.001755
R19069 n1_M8_124260_115260 n1_M8_125340_115260 0.001755
R19070 n1_M8_125340_115260 n1_M8_126420_115260 0.001755
R19071 n1_M8_126420_115260 n1_M8_127500_115260 0.001755
R19072 n1_M8_127500_115260 n1_M8_128580_115260 0.001755
R19073 n1_M8_128580_115260 n1_M8_129660_115260 0.001755
R19074 n1_M8_60_121660 n1_M8_1140_121660 0.001755
R19075 n1_M8_1140_121660 n1_M8_2220_121660 0.001755
R19076 n1_M8_2220_121660 n1_M8_3300_121660 0.001755
R19077 n1_M8_3300_121660 n1_M8_4380_121660 0.001755
R19078 n1_M8_4380_121660 n1_M8_5460_121660 0.001755
R19079 n1_M8_5460_121660 n1_M8_6540_121660 0.001755
R19080 n1_M8_6540_121660 n1_M8_7620_121660 0.001755
R19081 n1_M8_7620_121660 n1_M8_8700_121660 0.001755
R19082 n1_M8_8700_121660 n1_M8_9780_121660 0.001755
R19083 n1_M8_9780_121660 n1_M8_10860_121660 0.001755
R19084 n1_M8_10860_121660 n1_M8_11940_121660 0.001755
R19085 n1_M8_11940_121660 n1_M8_13020_121660 0.001755
R19086 n1_M8_13020_121660 n1_M8_14100_121660 0.001755
R19087 n1_M8_14100_121660 n1_M8_15180_121660 0.001755
R19088 n1_M8_15180_121660 n1_M8_16260_121660 0.001755
R19089 n1_M8_16260_121660 n1_M8_17340_121660 0.001755
R19090 n1_M8_17340_121660 n1_M8_18420_121660 0.001755
R19091 n1_M8_18420_121660 n1_M8_19500_121660 0.001755
R19092 n1_M8_19500_121660 n1_M8_20580_121660 0.001755
R19093 n1_M8_20580_121660 n1_M8_21660_121660 0.001755
R19094 n1_M8_21660_121660 n1_M8_22740_121660 0.001755
R19095 n1_M8_22740_121660 n1_M8_23820_121660 0.001755
R19096 n1_M8_23820_121660 n1_M8_24900_121660 0.001755
R19097 n1_M8_24900_121660 n1_M8_25980_121660 0.001755
R19098 n1_M8_25980_121660 n1_M8_27060_121660 0.001755
R19099 n1_M8_27060_121660 n1_M8_28140_121660 0.001755
R19100 n1_M8_28140_121660 n1_M8_29220_121660 0.001755
R19101 n1_M8_29220_121660 n1_M8_30300_121660 0.001755
R19102 n1_M8_30300_121660 n1_M8_31380_121660 0.001755
R19103 n1_M8_31380_121660 n1_M8_32460_121660 0.001755
R19104 n1_M8_32460_121660 n1_M8_33540_121660 0.001755
R19105 n1_M8_33540_121660 n1_M8_34620_121660 0.001755
R19106 n1_M8_34620_121660 n1_M8_35700_121660 0.001755
R19107 n1_M8_35700_121660 n1_M8_36780_121660 0.001755
R19108 n1_M8_36780_121660 n1_M8_37860_121660 0.001755
R19109 n1_M8_37860_121660 n1_M8_38940_121660 0.001755
R19110 n1_M8_38940_121660 n1_M8_40020_121660 0.001755
R19111 n1_M8_40020_121660 n1_M8_41100_121660 0.001755
R19112 n1_M8_41100_121660 n1_M8_42180_121660 0.001755
R19113 n1_M8_42180_121660 n1_M8_43260_121660 0.001755
R19114 n1_M8_43260_121660 n1_M8_44340_121660 0.001755
R19115 n1_M8_44340_121660 n1_M8_45420_121660 0.001755
R19116 n1_M8_45420_121660 n1_M8_46500_121660 0.001755
R19117 n1_M8_46500_121660 n1_M8_47580_121660 0.001755
R19118 n1_M8_47580_121660 n1_M8_48660_121660 0.001755
R19119 n1_M8_48660_121660 n1_M8_49740_121660 0.001755
R19120 n1_M8_49740_121660 n1_M8_50820_121660 0.001755
R19121 n1_M8_50820_121660 n1_M8_51900_121660 0.001755
R19122 n1_M8_51900_121660 n1_M8_52980_121660 0.001755
R19123 n1_M8_52980_121660 n1_M8_54060_121660 0.001755
R19124 n1_M8_54060_121660 n1_M8_55140_121660 0.001755
R19125 n1_M8_55140_121660 n1_M8_56220_121660 0.001755
R19126 n1_M8_56220_121660 n1_M8_57300_121660 0.001755
R19127 n1_M8_57300_121660 n1_M8_58380_121660 0.001755
R19128 n1_M8_58380_121660 n1_M8_59460_121660 0.001755
R19129 n1_M8_59460_121660 n1_M8_60540_121660 0.001755
R19130 n1_M8_60540_121660 n1_M8_61620_121660 0.001755
R19131 n1_M8_61620_121660 n1_M8_62700_121660 0.001755
R19132 n1_M8_62700_121660 n1_M8_63780_121660 0.001755
R19133 n1_M8_63780_121660 n1_M8_64860_121660 0.001755
R19134 n1_M8_64860_121660 n1_M8_65940_121660 0.001755
R19135 n1_M8_65940_121660 n1_M8_67020_121660 0.001755
R19136 n1_M8_67020_121660 n1_M8_68100_121660 0.001755
R19137 n1_M8_68100_121660 n1_M8_69180_121660 0.001755
R19138 n1_M8_69180_121660 n1_M8_70260_121660 0.001755
R19139 n1_M8_70260_121660 n1_M8_71340_121660 0.001755
R19140 n1_M8_71340_121660 n1_M8_72420_121660 0.001755
R19141 n1_M8_72420_121660 n1_M8_73500_121660 0.001755
R19142 n1_M8_73500_121660 n1_M8_74580_121660 0.001755
R19143 n1_M8_74580_121660 n1_M8_75660_121660 0.001755
R19144 n1_M8_75660_121660 n1_M8_76740_121660 0.001755
R19145 n1_M8_76740_121660 n1_M8_77820_121660 0.001755
R19146 n1_M8_77820_121660 n1_M8_78900_121660 0.001755
R19147 n1_M8_78900_121660 n1_M8_79980_121660 0.001755
R19148 n1_M8_79980_121660 n1_M8_81060_121660 0.001755
R19149 n1_M8_81060_121660 n1_M8_82140_121660 0.001755
R19150 n1_M8_82140_121660 n1_M8_83220_121660 0.001755
R19151 n1_M8_83220_121660 n1_M8_84300_121660 0.001755
R19152 n1_M8_84300_121660 n1_M8_85380_121660 0.001755
R19153 n1_M8_85380_121660 n1_M8_86460_121660 0.001755
R19154 n1_M8_86460_121660 n1_M8_87540_121660 0.001755
R19155 n1_M8_87540_121660 n1_M8_88620_121660 0.001755
R19156 n1_M8_88620_121660 n1_M8_89700_121660 0.001755
R19157 n1_M8_89700_121660 n1_M8_90780_121660 0.001755
R19158 n1_M8_90780_121660 n1_M8_91860_121660 0.001755
R19159 n1_M8_91860_121660 n1_M8_92940_121660 0.001755
R19160 n1_M8_92940_121660 n1_M8_94020_121660 0.001755
R19161 n1_M8_94020_121660 n1_M8_95100_121660 0.001755
R19162 n1_M8_95100_121660 n1_M8_96180_121660 0.001755
R19163 n1_M8_96180_121660 n1_M8_97260_121660 0.001755
R19164 n1_M8_97260_121660 n1_M8_98340_121660 0.001755
R19165 n1_M8_98340_121660 n1_M8_99420_121660 0.001755
R19166 n1_M8_99420_121660 n1_M8_100500_121660 0.001755
R19167 n1_M8_100500_121660 n1_M8_101580_121660 0.001755
R19168 n1_M8_101580_121660 n1_M8_102660_121660 0.001755
R19169 n1_M8_102660_121660 n1_M8_103740_121660 0.001755
R19170 n1_M8_103740_121660 n1_M8_104820_121660 0.001755
R19171 n1_M8_104820_121660 n1_M8_105900_121660 0.001755
R19172 n1_M8_105900_121660 n1_M8_106980_121660 0.001755
R19173 n1_M8_106980_121660 n1_M8_108060_121660 0.001755
R19174 n1_M8_108060_121660 n1_M8_109140_121660 0.001755
R19175 n1_M8_109140_121660 n1_M8_110220_121660 0.001755
R19176 n1_M8_110220_121660 n1_M8_111300_121660 0.001755
R19177 n1_M8_111300_121660 n1_M8_112380_121660 0.001755
R19178 n1_M8_112380_121660 n1_M8_113460_121660 0.001755
R19179 n1_M8_113460_121660 n1_M8_114540_121660 0.001755
R19180 n1_M8_114540_121660 n1_M8_115620_121660 0.001755
R19181 n1_M8_115620_121660 n1_M8_116700_121660 0.001755
R19182 n1_M8_116700_121660 n1_M8_117780_121660 0.001755
R19183 n1_M8_117780_121660 n1_M8_118860_121660 0.001755
R19184 n1_M8_118860_121660 n1_M8_119940_121660 0.001755
R19185 n1_M8_119940_121660 n1_M8_121020_121660 0.001755
R19186 n1_M8_121020_121660 n1_M8_122100_121660 0.001755
R19187 n1_M8_122100_121660 n1_M8_123180_121660 0.001755
R19188 n1_M8_123180_121660 n1_M8_124260_121660 0.001755
R19189 n1_M8_124260_121660 n1_M8_125340_121660 0.001755
R19190 n1_M8_125340_121660 n1_M8_126420_121660 0.001755
R19191 n1_M8_126420_121660 n1_M8_127500_121660 0.001755
R19192 n1_M8_127500_121660 n1_M8_128580_121660 0.001755
R19193 n1_M8_128580_121660 n1_M8_129660_121660 0.001755
R19194 n1_M8_60_128060 n1_M8_1140_128060 0.001755
R19195 n1_M8_1140_128060 n1_M8_2220_128060 0.001755
R19196 n1_M8_2220_128060 n1_M8_3300_128060 0.001755
R19197 n1_M8_3300_128060 n1_M8_4380_128060 0.001755
R19198 n1_M8_4380_128060 n1_M8_5460_128060 0.001755
R19199 n1_M8_5460_128060 n1_M8_6540_128060 0.001755
R19200 n1_M8_6540_128060 n1_M8_7620_128060 0.001755
R19201 n1_M8_7620_128060 n1_M8_8700_128060 0.001755
R19202 n1_M8_8700_128060 n1_M8_9780_128060 0.001755
R19203 n1_M8_9780_128060 n1_M8_10860_128060 0.001755
R19204 n1_M8_10860_128060 n1_M8_11940_128060 0.001755
R19205 n1_M8_11940_128060 n1_M8_13020_128060 0.001755
R19206 n1_M8_13020_128060 n1_M8_14100_128060 0.001755
R19207 n1_M8_14100_128060 n1_M8_15180_128060 0.001755
R19208 n1_M8_15180_128060 n1_M8_16260_128060 0.001755
R19209 n1_M8_16260_128060 n1_M8_17340_128060 0.001755
R19210 n1_M8_17340_128060 n1_M8_18420_128060 0.001755
R19211 n1_M8_18420_128060 n1_M8_19500_128060 0.001755
R19212 n1_M8_19500_128060 n1_M8_20580_128060 0.001755
R19213 n1_M8_20580_128060 n1_M8_21660_128060 0.001755
R19214 n1_M8_21660_128060 n1_M8_22740_128060 0.001755
R19215 n1_M8_22740_128060 n1_M8_23820_128060 0.001755
R19216 n1_M8_23820_128060 n1_M8_24900_128060 0.001755
R19217 n1_M8_24900_128060 n1_M8_25980_128060 0.001755
R19218 n1_M8_25980_128060 n1_M8_27060_128060 0.001755
R19219 n1_M8_27060_128060 n1_M8_28140_128060 0.001755
R19220 n1_M8_28140_128060 n1_M8_29220_128060 0.001755
R19221 n1_M8_29220_128060 n1_M8_30300_128060 0.001755
R19222 n1_M8_30300_128060 n1_M8_31380_128060 0.001755
R19223 n1_M8_31380_128060 n1_M8_32460_128060 0.001755
R19224 n1_M8_32460_128060 n1_M8_33540_128060 0.001755
R19225 n1_M8_33540_128060 n1_M8_34620_128060 0.001755
R19226 n1_M8_34620_128060 n1_M8_35700_128060 0.001755
R19227 n1_M8_35700_128060 n1_M8_36780_128060 0.001755
R19228 n1_M8_36780_128060 n1_M8_37860_128060 0.001755
R19229 n1_M8_37860_128060 n1_M8_38940_128060 0.001755
R19230 n1_M8_38940_128060 n1_M8_40020_128060 0.001755
R19231 n1_M8_40020_128060 n1_M8_41100_128060 0.001755
R19232 n1_M8_41100_128060 n1_M8_42180_128060 0.001755
R19233 n1_M8_42180_128060 n1_M8_43260_128060 0.001755
R19234 n1_M8_43260_128060 n1_M8_44340_128060 0.001755
R19235 n1_M8_44340_128060 n1_M8_45420_128060 0.001755
R19236 n1_M8_45420_128060 n1_M8_46500_128060 0.001755
R19237 n1_M8_46500_128060 n1_M8_47580_128060 0.001755
R19238 n1_M8_47580_128060 n1_M8_48660_128060 0.001755
R19239 n1_M8_48660_128060 n1_M8_49740_128060 0.001755
R19240 n1_M8_49740_128060 n1_M8_50820_128060 0.001755
R19241 n1_M8_50820_128060 n1_M8_51900_128060 0.001755
R19242 n1_M8_51900_128060 n1_M8_52980_128060 0.001755
R19243 n1_M8_52980_128060 n1_M8_54060_128060 0.001755
R19244 n1_M8_54060_128060 n1_M8_55140_128060 0.001755
R19245 n1_M8_55140_128060 n1_M8_56220_128060 0.001755
R19246 n1_M8_56220_128060 n1_M8_57300_128060 0.001755
R19247 n1_M8_57300_128060 n1_M8_58380_128060 0.001755
R19248 n1_M8_58380_128060 n1_M8_59460_128060 0.001755
R19249 n1_M8_59460_128060 n1_M8_60540_128060 0.001755
R19250 n1_M8_60540_128060 n1_M8_61620_128060 0.001755
R19251 n1_M8_61620_128060 n1_M8_62700_128060 0.001755
R19252 n1_M8_62700_128060 n1_M8_63780_128060 0.001755
R19253 n1_M8_63780_128060 n1_M8_64860_128060 0.001755
R19254 n1_M8_64860_128060 n1_M8_65940_128060 0.001755
R19255 n1_M8_65940_128060 n1_M8_67020_128060 0.001755
R19256 n1_M8_67020_128060 n1_M8_68100_128060 0.001755
R19257 n1_M8_68100_128060 n1_M8_69180_128060 0.001755
R19258 n1_M8_69180_128060 n1_M8_70260_128060 0.001755
R19259 n1_M8_70260_128060 n1_M8_71340_128060 0.001755
R19260 n1_M8_71340_128060 n1_M8_72420_128060 0.001755
R19261 n1_M8_72420_128060 n1_M8_73500_128060 0.001755
R19262 n1_M8_73500_128060 n1_M8_74580_128060 0.001755
R19263 n1_M8_74580_128060 n1_M8_75660_128060 0.001755
R19264 n1_M8_75660_128060 n1_M8_76740_128060 0.001755
R19265 n1_M8_76740_128060 n1_M8_77820_128060 0.001755
R19266 n1_M8_77820_128060 n1_M8_78900_128060 0.001755
R19267 n1_M8_78900_128060 n1_M8_79980_128060 0.001755
R19268 n1_M8_79980_128060 n1_M8_81060_128060 0.001755
R19269 n1_M8_81060_128060 n1_M8_82140_128060 0.001755
R19270 n1_M8_82140_128060 n1_M8_83220_128060 0.001755
R19271 n1_M8_83220_128060 n1_M8_84300_128060 0.001755
R19272 n1_M8_84300_128060 n1_M8_85380_128060 0.001755
R19273 n1_M8_85380_128060 n1_M8_86460_128060 0.001755
R19274 n1_M8_86460_128060 n1_M8_87540_128060 0.001755
R19275 n1_M8_87540_128060 n1_M8_88620_128060 0.001755
R19276 n1_M8_88620_128060 n1_M8_89700_128060 0.001755
R19277 n1_M8_89700_128060 n1_M8_90780_128060 0.001755
R19278 n1_M8_90780_128060 n1_M8_91860_128060 0.001755
R19279 n1_M8_91860_128060 n1_M8_92940_128060 0.001755
R19280 n1_M8_92940_128060 n1_M8_94020_128060 0.001755
R19281 n1_M8_94020_128060 n1_M8_95100_128060 0.001755
R19282 n1_M8_95100_128060 n1_M8_96180_128060 0.001755
R19283 n1_M8_96180_128060 n1_M8_97260_128060 0.001755
R19284 n1_M8_97260_128060 n1_M8_98340_128060 0.001755
R19285 n1_M8_98340_128060 n1_M8_99420_128060 0.001755
R19286 n1_M8_99420_128060 n1_M8_100500_128060 0.001755
R19287 n1_M8_100500_128060 n1_M8_101580_128060 0.001755
R19288 n1_M8_101580_128060 n1_M8_102660_128060 0.001755
R19289 n1_M8_102660_128060 n1_M8_103740_128060 0.001755
R19290 n1_M8_103740_128060 n1_M8_104820_128060 0.001755
R19291 n1_M8_104820_128060 n1_M8_105900_128060 0.001755
R19292 n1_M8_105900_128060 n1_M8_106980_128060 0.001755
R19293 n1_M8_106980_128060 n1_M8_108060_128060 0.001755
R19294 n1_M8_108060_128060 n1_M8_109140_128060 0.001755
R19295 n1_M8_109140_128060 n1_M8_110220_128060 0.001755
R19296 n1_M8_110220_128060 n1_M8_111300_128060 0.001755
R19297 n1_M8_111300_128060 n1_M8_112380_128060 0.001755
R19298 n1_M8_112380_128060 n1_M8_113460_128060 0.001755
R19299 n1_M8_113460_128060 n1_M8_114540_128060 0.001755
R19300 n1_M8_114540_128060 n1_M8_115620_128060 0.001755
R19301 n1_M8_115620_128060 n1_M8_116700_128060 0.001755
R19302 n1_M8_116700_128060 n1_M8_117780_128060 0.001755
R19303 n1_M8_117780_128060 n1_M8_118860_128060 0.001755
R19304 n1_M8_118860_128060 n1_M8_119940_128060 0.001755
R19305 n1_M8_119940_128060 n1_M8_121020_128060 0.001755
R19306 n1_M8_121020_128060 n1_M8_122100_128060 0.001755
R19307 n1_M8_122100_128060 n1_M8_123180_128060 0.001755
R19308 n1_M8_123180_128060 n1_M8_124260_128060 0.001755
R19309 n1_M8_124260_128060 n1_M8_125340_128060 0.001755
R19310 n1_M8_125340_128060 n1_M8_126420_128060 0.001755
R19311 n1_M8_126420_128060 n1_M8_127500_128060 0.001755
R19312 n1_M8_127500_128060 n1_M8_128580_128060 0.001755
R19313 n1_M8_128580_128060 n1_M8_129660_128060 0.001755
R19314 n1_M2_60_60 n1_M5_60_60 10.000000
R19315 n1_M2_60_1140 n1_M5_60_1140 10.000000
R19316 n1_M2_60_2220 n1_M5_60_2220 10.000000
R19317 n1_M2_60_3300 n1_M5_60_3300 10.000000
R19318 n1_M2_60_4380 n1_M5_60_4380 10.000000
R19319 n1_M2_60_5460 n1_M5_60_5460 10.000000
R19320 n1_M2_60_6540 n1_M5_60_6540 10.000000
R19321 n1_M2_60_7620 n1_M5_60_7620 10.000000
R19322 n1_M2_60_8700 n1_M5_60_8700 10.000000
R19323 n1_M2_60_9780 n1_M5_60_9780 10.000000
R19324 n1_M2_60_10860 n1_M5_60_10860 10.000000
R19325 n1_M2_60_11940 n1_M5_60_11940 10.000000
R19326 n1_M2_60_13020 n1_M5_60_13020 10.000000
R19327 n1_M2_60_14100 n1_M5_60_14100 10.000000
R19328 n1_M2_60_15180 n1_M5_60_15180 10.000000
R19329 n1_M2_60_16260 n1_M5_60_16260 10.000000
R19330 n1_M2_60_17340 n1_M5_60_17340 10.000000
R19331 n1_M2_60_18420 n1_M5_60_18420 10.000000
R19332 n1_M2_60_19500 n1_M5_60_19500 10.000000
R19333 n1_M2_60_20580 n1_M5_60_20580 10.000000
R19334 n1_M2_60_21660 n1_M5_60_21660 10.000000
R19335 n1_M2_60_22740 n1_M5_60_22740 10.000000
R19336 n1_M2_60_23820 n1_M5_60_23820 10.000000
R19337 n1_M2_60_24900 n1_M5_60_24900 10.000000
R19338 n1_M2_60_25980 n1_M5_60_25980 10.000000
R19339 n1_M2_60_27060 n1_M5_60_27060 10.000000
R19340 n1_M2_60_28140 n1_M5_60_28140 10.000000
R19341 n1_M2_60_29220 n1_M5_60_29220 10.000000
R19342 n1_M2_60_30300 n1_M5_60_30300 10.000000
R19343 n1_M2_60_31380 n1_M5_60_31380 10.000000
R19344 n1_M2_60_32460 n1_M5_60_32460 10.000000
R19345 n1_M2_60_33540 n1_M5_60_33540 10.000000
R19346 n1_M2_60_34620 n1_M5_60_34620 10.000000
R19347 n1_M2_60_35700 n1_M5_60_35700 10.000000
R19348 n1_M2_60_36780 n1_M5_60_36780 10.000000
R19349 n1_M2_60_37860 n1_M5_60_37860 10.000000
R19350 n1_M2_60_38940 n1_M5_60_38940 10.000000
R19351 n1_M2_60_40020 n1_M5_60_40020 10.000000
R19352 n1_M2_60_41100 n1_M5_60_41100 10.000000
R19353 n1_M2_60_42180 n1_M5_60_42180 10.000000
R19354 n1_M2_60_43260 n1_M5_60_43260 10.000000
R19355 n1_M2_60_44340 n1_M5_60_44340 10.000000
R19356 n1_M2_60_45420 n1_M5_60_45420 10.000000
R19357 n1_M2_60_46500 n1_M5_60_46500 10.000000
R19358 n1_M2_60_47580 n1_M5_60_47580 10.000000
R19359 n1_M2_60_48660 n1_M5_60_48660 10.000000
R19360 n1_M2_60_49740 n1_M5_60_49740 10.000000
R19361 n1_M2_60_50820 n1_M5_60_50820 10.000000
R19362 n1_M2_60_51900 n1_M5_60_51900 10.000000
R19363 n1_M2_60_52980 n1_M5_60_52980 10.000000
R19364 n1_M2_60_54060 n1_M5_60_54060 10.000000
R19365 n1_M2_60_55140 n1_M5_60_55140 10.000000
R19366 n1_M2_60_56220 n1_M5_60_56220 10.000000
R19367 n1_M2_60_57300 n1_M5_60_57300 10.000000
R19368 n1_M2_60_58380 n1_M5_60_58380 10.000000
R19369 n1_M2_60_59460 n1_M5_60_59460 10.000000
R19370 n1_M2_60_60540 n1_M5_60_60540 10.000000
R19371 n1_M2_60_61620 n1_M5_60_61620 10.000000
R19372 n1_M2_60_62700 n1_M5_60_62700 10.000000
R19373 n1_M2_60_63780 n1_M5_60_63780 10.000000
R19374 n1_M2_60_64860 n1_M5_60_64860 10.000000
R19375 n1_M2_60_65940 n1_M5_60_65940 10.000000
R19376 n1_M2_60_67020 n1_M5_60_67020 10.000000
R19377 n1_M2_60_68100 n1_M5_60_68100 10.000000
R19378 n1_M2_60_69180 n1_M5_60_69180 10.000000
R19379 n1_M2_60_70260 n1_M5_60_70260 10.000000
R19380 n1_M2_60_71340 n1_M5_60_71340 10.000000
R19381 n1_M2_60_72420 n1_M5_60_72420 10.000000
R19382 n1_M2_60_73500 n1_M5_60_73500 10.000000
R19383 n1_M2_60_74580 n1_M5_60_74580 10.000000
R19384 n1_M2_60_75660 n1_M5_60_75660 10.000000
R19385 n1_M2_60_76740 n1_M5_60_76740 10.000000
R19386 n1_M2_60_77820 n1_M5_60_77820 10.000000
R19387 n1_M2_60_78900 n1_M5_60_78900 10.000000
R19388 n1_M2_60_79980 n1_M5_60_79980 10.000000
R19389 n1_M2_60_81060 n1_M5_60_81060 10.000000
R19390 n1_M2_60_82140 n1_M5_60_82140 10.000000
R19391 n1_M2_60_83220 n1_M5_60_83220 10.000000
R19392 n1_M2_60_84300 n1_M5_60_84300 10.000000
R19393 n1_M2_60_85380 n1_M5_60_85380 10.000000
R19394 n1_M2_60_86460 n1_M5_60_86460 10.000000
R19395 n1_M2_60_87540 n1_M5_60_87540 10.000000
R19396 n1_M2_60_88620 n1_M5_60_88620 10.000000
R19397 n1_M2_60_89700 n1_M5_60_89700 10.000000
R19398 n1_M2_60_90780 n1_M5_60_90780 10.000000
R19399 n1_M2_60_91860 n1_M5_60_91860 10.000000
R19400 n1_M2_60_92940 n1_M5_60_92940 10.000000
R19401 n1_M2_60_94020 n1_M5_60_94020 10.000000
R19402 n1_M2_60_95100 n1_M5_60_95100 10.000000
R19403 n1_M2_60_96180 n1_M5_60_96180 10.000000
R19404 n1_M2_60_97260 n1_M5_60_97260 10.000000
R19405 n1_M2_60_98340 n1_M5_60_98340 10.000000
R19406 n1_M2_60_99420 n1_M5_60_99420 10.000000
R19407 n1_M2_60_100500 n1_M5_60_100500 10.000000
R19408 n1_M2_60_101580 n1_M5_60_101580 10.000000
R19409 n1_M2_60_102660 n1_M5_60_102660 10.000000
R19410 n1_M2_60_103740 n1_M5_60_103740 10.000000
R19411 n1_M2_60_104820 n1_M5_60_104820 10.000000
R19412 n1_M2_60_105900 n1_M5_60_105900 10.000000
R19413 n1_M2_60_106980 n1_M5_60_106980 10.000000
R19414 n1_M2_60_108060 n1_M5_60_108060 10.000000
R19415 n1_M2_60_109140 n1_M5_60_109140 10.000000
R19416 n1_M2_60_110220 n1_M5_60_110220 10.000000
R19417 n1_M2_60_111300 n1_M5_60_111300 10.000000
R19418 n1_M2_60_112380 n1_M5_60_112380 10.000000
R19419 n1_M2_60_113460 n1_M5_60_113460 10.000000
R19420 n1_M2_60_114540 n1_M5_60_114540 10.000000
R19421 n1_M2_60_115620 n1_M5_60_115620 10.000000
R19422 n1_M2_60_116700 n1_M5_60_116700 10.000000
R19423 n1_M2_60_117780 n1_M5_60_117780 10.000000
R19424 n1_M2_60_118860 n1_M5_60_118860 10.000000
R19425 n1_M2_60_119940 n1_M5_60_119940 10.000000
R19426 n1_M2_60_121020 n1_M5_60_121020 10.000000
R19427 n1_M2_60_122100 n1_M5_60_122100 10.000000
R19428 n1_M2_60_123180 n1_M5_60_123180 10.000000
R19429 n1_M2_60_124260 n1_M5_60_124260 10.000000
R19430 n1_M2_60_125340 n1_M5_60_125340 10.000000
R19431 n1_M2_60_126420 n1_M5_60_126420 10.000000
R19432 n1_M2_60_127500 n1_M5_60_127500 10.000000
R19433 n1_M2_60_128580 n1_M5_60_128580 10.000000
R19434 n1_M2_60_129660 n1_M5_60_129660 10.000000
R19435 n1_M2_6540_60 n1_M5_6060_60 10.000000
R19436 n1_M2_11940_60 n1_M5_12060_60 10.000000
R19437 n1_M2_18420_60 n1_M5_18060_60 10.000000
R19438 n1_M2_23820_60 n1_M5_24060_60 10.000000
R19439 n1_M2_23820_1140 n1_M5_24060_1140 10.000000
R19440 n1_M2_23820_2220 n1_M5_24060_2220 10.000000
R19441 n1_M2_23820_3300 n1_M5_24060_3300 10.000000
R19442 n1_M2_23820_4380 n1_M5_24060_4380 10.000000
R19443 n1_M2_23820_5460 n1_M5_24060_5460 10.000000
R19444 n1_M2_23820_6540 n1_M5_24060_6540 10.000000
R19445 n1_M2_23820_7620 n1_M5_24060_7620 10.000000
R19446 n1_M2_23820_8700 n1_M5_24060_8700 10.000000
R19447 n1_M2_23820_9780 n1_M5_24060_9780 10.000000
R19448 n1_M2_23820_10860 n1_M5_24060_10860 10.000000
R19449 n1_M2_23820_11940 n1_M5_24060_11940 10.000000
R19450 n1_M2_23820_13020 n1_M5_24060_13020 10.000000
R19451 n1_M2_23820_14100 n1_M5_24060_14100 10.000000
R19452 n1_M2_23820_15180 n1_M5_24060_15180 10.000000
R19453 n1_M2_23820_16260 n1_M5_24060_16260 10.000000
R19454 n1_M2_23820_17340 n1_M5_24060_17340 10.000000
R19455 n1_M2_23820_18420 n1_M5_24060_18420 10.000000
R19456 n1_M2_23820_19500 n1_M5_24060_19500 10.000000
R19457 n1_M2_23820_20580 n1_M5_24060_20580 10.000000
R19458 n1_M2_23820_21660 n1_M5_24060_21660 10.000000
R19459 n1_M2_23820_22740 n1_M5_24060_22740 10.000000
R19460 n1_M2_23820_23820 n1_M5_24060_23820 10.000000
R19461 n1_M2_23820_24900 n1_M5_24060_24900 10.000000
R19462 n1_M2_23820_25980 n1_M5_24060_25980 10.000000
R19463 n1_M2_23820_27060 n1_M5_24060_27060 10.000000
R19464 n1_M2_23820_28140 n1_M5_24060_28140 10.000000
R19465 n1_M2_23820_29220 n1_M5_24060_29220 10.000000
R19466 n1_M2_23820_30300 n1_M5_24060_30300 10.000000
R19467 n1_M2_23820_31380 n1_M5_24060_31380 10.000000
R19468 n1_M2_23820_32460 n1_M5_24060_32460 10.000000
R19469 n1_M2_23820_33540 n1_M5_24060_33540 10.000000
R19470 n1_M2_23820_34620 n1_M5_24060_34620 10.000000
R19471 n1_M2_23820_35700 n1_M5_24060_35700 10.000000
R19472 n1_M2_23820_36780 n1_M5_24060_36780 10.000000
R19473 n1_M2_23820_37860 n1_M5_24060_37860 10.000000
R19474 n1_M2_23820_38940 n1_M5_24060_38940 10.000000
R19475 n1_M2_23820_40020 n1_M5_24060_40020 10.000000
R19476 n1_M2_23820_41100 n1_M5_24060_41100 10.000000
R19477 n1_M2_23820_42180 n1_M5_24060_42180 10.000000
R19478 n1_M2_23820_43260 n1_M5_24060_43260 10.000000
R19479 n1_M2_23820_44340 n1_M5_24060_44340 10.000000
R19480 n1_M2_23820_45420 n1_M5_24060_45420 10.000000
R19481 n1_M2_23820_46500 n1_M5_24060_46500 10.000000
R19482 n1_M2_23820_47580 n1_M5_24060_47580 10.000000
R19483 n1_M2_23820_48660 n1_M5_24060_48660 10.000000
R19484 n1_M2_23820_49740 n1_M5_24060_49740 10.000000
R19485 n1_M2_23820_50820 n1_M5_24060_50820 10.000000
R19486 n1_M2_23820_51900 n1_M5_24060_51900 10.000000
R19487 n1_M2_23820_52980 n1_M5_24060_52980 10.000000
R19488 n1_M2_23820_54060 n1_M5_24060_54060 10.000000
R19489 n1_M2_23820_55140 n1_M5_24060_55140 10.000000
R19490 n1_M2_23820_56220 n1_M5_24060_56220 10.000000
R19491 n1_M2_23820_57300 n1_M5_24060_57300 10.000000
R19492 n1_M2_23820_58380 n1_M5_24060_58380 10.000000
R19493 n1_M2_23820_59460 n1_M5_24060_59460 10.000000
R19494 n1_M2_23820_60540 n1_M5_24060_60540 10.000000
R19495 n1_M2_23820_61620 n1_M5_24060_61620 10.000000
R19496 n1_M2_23820_62700 n1_M5_24060_62700 10.000000
R19497 n1_M2_23820_63780 n1_M5_24060_63780 10.000000
R19498 n1_M2_23820_64860 n1_M5_24060_64860 10.000000
R19499 n1_M2_23820_65940 n1_M5_24060_65940 10.000000
R19500 n1_M2_23820_67020 n1_M5_24060_67020 10.000000
R19501 n1_M2_23820_68100 n1_M5_24060_68100 10.000000
R19502 n1_M2_23820_69180 n1_M5_24060_69180 10.000000
R19503 n1_M2_23820_70260 n1_M5_24060_70260 10.000000
R19504 n1_M2_23820_71340 n1_M5_24060_71340 10.000000
R19505 n1_M2_23820_72420 n1_M5_24060_72420 10.000000
R19506 n1_M2_23820_73500 n1_M5_24060_73500 10.000000
R19507 n1_M2_23820_74580 n1_M5_24060_74580 10.000000
R19508 n1_M2_23820_75660 n1_M5_24060_75660 10.000000
R19509 n1_M2_23820_76740 n1_M5_24060_76740 10.000000
R19510 n1_M2_23820_77820 n1_M5_24060_77820 10.000000
R19511 n1_M2_23820_78900 n1_M5_24060_78900 10.000000
R19512 n1_M2_23820_79980 n1_M5_24060_79980 10.000000
R19513 n1_M2_23820_81060 n1_M5_24060_81060 10.000000
R19514 n1_M2_23820_82140 n1_M5_24060_82140 10.000000
R19515 n1_M2_23820_83220 n1_M5_24060_83220 10.000000
R19516 n1_M2_23820_84300 n1_M5_24060_84300 10.000000
R19517 n1_M2_23820_85380 n1_M5_24060_85380 10.000000
R19518 n1_M2_23820_86460 n1_M5_24060_86460 10.000000
R19519 n1_M2_23820_87540 n1_M5_24060_87540 10.000000
R19520 n1_M2_23820_88620 n1_M5_24060_88620 10.000000
R19521 n1_M2_23820_89700 n1_M5_24060_89700 10.000000
R19522 n1_M2_23820_90780 n1_M5_24060_90780 10.000000
R19523 n1_M2_23820_91860 n1_M5_24060_91860 10.000000
R19524 n1_M2_23820_92940 n1_M5_24060_92940 10.000000
R19525 n1_M2_23820_94020 n1_M5_24060_94020 10.000000
R19526 n1_M2_23820_95100 n1_M5_24060_95100 10.000000
R19527 n1_M2_23820_96180 n1_M5_24060_96180 10.000000
R19528 n1_M2_23820_97260 n1_M5_24060_97260 10.000000
R19529 n1_M2_23820_98340 n1_M5_24060_98340 10.000000
R19530 n1_M2_23820_99420 n1_M5_24060_99420 10.000000
R19531 n1_M2_23820_100500 n1_M5_24060_100500 10.000000
R19532 n1_M2_23820_101580 n1_M5_24060_101580 10.000000
R19533 n1_M2_23820_102660 n1_M5_24060_102660 10.000000
R19534 n1_M2_23820_103740 n1_M5_24060_103740 10.000000
R19535 n1_M2_23820_104820 n1_M5_24060_104820 10.000000
R19536 n1_M2_23820_105900 n1_M5_24060_105900 10.000000
R19537 n1_M2_23820_106980 n1_M5_24060_106980 10.000000
R19538 n1_M2_23820_108060 n1_M5_24060_108060 10.000000
R19539 n1_M2_23820_109140 n1_M5_24060_109140 10.000000
R19540 n1_M2_23820_110220 n1_M5_24060_110220 10.000000
R19541 n1_M2_23820_111300 n1_M5_24060_111300 10.000000
R19542 n1_M2_23820_112380 n1_M5_24060_112380 10.000000
R19543 n1_M2_23820_113460 n1_M5_24060_113460 10.000000
R19544 n1_M2_23820_114540 n1_M5_24060_114540 10.000000
R19545 n1_M2_23820_115620 n1_M5_24060_115620 10.000000
R19546 n1_M2_23820_116700 n1_M5_24060_116700 10.000000
R19547 n1_M2_23820_117780 n1_M5_24060_117780 10.000000
R19548 n1_M2_23820_118860 n1_M5_24060_118860 10.000000
R19549 n1_M2_23820_119940 n1_M5_24060_119940 10.000000
R19550 n1_M2_23820_121020 n1_M5_24060_121020 10.000000
R19551 n1_M2_23820_122100 n1_M5_24060_122100 10.000000
R19552 n1_M2_23820_123180 n1_M5_24060_123180 10.000000
R19553 n1_M2_23820_124260 n1_M5_24060_124260 10.000000
R19554 n1_M2_23820_125340 n1_M5_24060_125340 10.000000
R19555 n1_M2_23820_126420 n1_M5_24060_126420 10.000000
R19556 n1_M2_23820_127500 n1_M5_24060_127500 10.000000
R19557 n1_M2_23820_128580 n1_M5_24060_128580 10.000000
R19558 n1_M2_23820_129660 n1_M5_24060_129660 10.000000
R19559 n1_M2_30300_60 n1_M5_30060_60 10.000000
R19560 n1_M2_35700_60 n1_M5_36060_60 10.000000
R19561 n1_M2_42180_60 n1_M5_42060_60 10.000000
R19562 n1_M2_47580_60 n1_M5_48060_60 10.000000
R19563 n1_M2_47580_1140 n1_M5_48060_1140 10.000000
R19564 n1_M2_47580_2220 n1_M5_48060_2220 10.000000
R19565 n1_M2_47580_3300 n1_M5_48060_3300 10.000000
R19566 n1_M2_47580_4380 n1_M5_48060_4380 10.000000
R19567 n1_M2_47580_5460 n1_M5_48060_5460 10.000000
R19568 n1_M2_47580_6540 n1_M5_48060_6540 10.000000
R19569 n1_M2_47580_7620 n1_M5_48060_7620 10.000000
R19570 n1_M2_47580_8700 n1_M5_48060_8700 10.000000
R19571 n1_M2_47580_9780 n1_M5_48060_9780 10.000000
R19572 n1_M2_47580_10860 n1_M5_48060_10860 10.000000
R19573 n1_M2_47580_11940 n1_M5_48060_11940 10.000000
R19574 n1_M2_47580_13020 n1_M5_48060_13020 10.000000
R19575 n1_M2_47580_14100 n1_M5_48060_14100 10.000000
R19576 n1_M2_47580_15180 n1_M5_48060_15180 10.000000
R19577 n1_M2_47580_16260 n1_M5_48060_16260 10.000000
R19578 n1_M2_47580_17340 n1_M5_48060_17340 10.000000
R19579 n1_M2_47580_18420 n1_M5_48060_18420 10.000000
R19580 n1_M2_47580_19500 n1_M5_48060_19500 10.000000
R19581 n1_M2_47580_20580 n1_M5_48060_20580 10.000000
R19582 n1_M2_47580_21660 n1_M5_48060_21660 10.000000
R19583 n1_M2_47580_22740 n1_M5_48060_22740 10.000000
R19584 n1_M2_47580_23820 n1_M5_48060_23820 10.000000
R19585 n1_M2_47580_24900 n1_M5_48060_24900 10.000000
R19586 n1_M2_47580_25980 n1_M5_48060_25980 10.000000
R19587 n1_M2_47580_27060 n1_M5_48060_27060 10.000000
R19588 n1_M2_47580_28140 n1_M5_48060_28140 10.000000
R19589 n1_M2_47580_29220 n1_M5_48060_29220 10.000000
R19590 n1_M2_47580_30300 n1_M5_48060_30300 10.000000
R19591 n1_M2_47580_31380 n1_M5_48060_31380 10.000000
R19592 n1_M2_47580_32460 n1_M5_48060_32460 10.000000
R19593 n1_M2_47580_33540 n1_M5_48060_33540 10.000000
R19594 n1_M2_47580_34620 n1_M5_48060_34620 10.000000
R19595 n1_M2_47580_35700 n1_M5_48060_35700 10.000000
R19596 n1_M2_47580_36780 n1_M5_48060_36780 10.000000
R19597 n1_M2_47580_37860 n1_M5_48060_37860 10.000000
R19598 n1_M2_47580_38940 n1_M5_48060_38940 10.000000
R19599 n1_M2_47580_40020 n1_M5_48060_40020 10.000000
R19600 n1_M2_47580_41100 n1_M5_48060_41100 10.000000
R19601 n1_M2_47580_42180 n1_M5_48060_42180 10.000000
R19602 n1_M2_47580_43260 n1_M5_48060_43260 10.000000
R19603 n1_M2_47580_44340 n1_M5_48060_44340 10.000000
R19604 n1_M2_47580_45420 n1_M5_48060_45420 10.000000
R19605 n1_M2_47580_46500 n1_M5_48060_46500 10.000000
R19606 n1_M2_47580_47580 n1_M5_48060_47580 10.000000
R19607 n1_M2_47580_48660 n1_M5_48060_48660 10.000000
R19608 n1_M2_47580_49740 n1_M5_48060_49740 10.000000
R19609 n1_M2_47580_50820 n1_M5_48060_50820 10.000000
R19610 n1_M2_47580_51900 n1_M5_48060_51900 10.000000
R19611 n1_M2_47580_52980 n1_M5_48060_52980 10.000000
R19612 n1_M2_47580_54060 n1_M5_48060_54060 10.000000
R19613 n1_M2_47580_55140 n1_M5_48060_55140 10.000000
R19614 n1_M2_47580_56220 n1_M5_48060_56220 10.000000
R19615 n1_M2_47580_57300 n1_M5_48060_57300 10.000000
R19616 n1_M2_47580_58380 n1_M5_48060_58380 10.000000
R19617 n1_M2_47580_59460 n1_M5_48060_59460 10.000000
R19618 n1_M2_47580_60540 n1_M5_48060_60540 10.000000
R19619 n1_M2_47580_61620 n1_M5_48060_61620 10.000000
R19620 n1_M2_47580_62700 n1_M5_48060_62700 10.000000
R19621 n1_M2_47580_63780 n1_M5_48060_63780 10.000000
R19622 n1_M2_47580_64860 n1_M5_48060_64860 10.000000
R19623 n1_M2_47580_65940 n1_M5_48060_65940 10.000000
R19624 n1_M2_47580_67020 n1_M5_48060_67020 10.000000
R19625 n1_M2_47580_68100 n1_M5_48060_68100 10.000000
R19626 n1_M2_47580_69180 n1_M5_48060_69180 10.000000
R19627 n1_M2_47580_70260 n1_M5_48060_70260 10.000000
R19628 n1_M2_47580_71340 n1_M5_48060_71340 10.000000
R19629 n1_M2_47580_72420 n1_M5_48060_72420 10.000000
R19630 n1_M2_47580_73500 n1_M5_48060_73500 10.000000
R19631 n1_M2_47580_74580 n1_M5_48060_74580 10.000000
R19632 n1_M2_47580_75660 n1_M5_48060_75660 10.000000
R19633 n1_M2_47580_76740 n1_M5_48060_76740 10.000000
R19634 n1_M2_47580_77820 n1_M5_48060_77820 10.000000
R19635 n1_M2_47580_78900 n1_M5_48060_78900 10.000000
R19636 n1_M2_47580_79980 n1_M5_48060_79980 10.000000
R19637 n1_M2_47580_81060 n1_M5_48060_81060 10.000000
R19638 n1_M2_47580_82140 n1_M5_48060_82140 10.000000
R19639 n1_M2_47580_83220 n1_M5_48060_83220 10.000000
R19640 n1_M2_47580_84300 n1_M5_48060_84300 10.000000
R19641 n1_M2_47580_85380 n1_M5_48060_85380 10.000000
R19642 n1_M2_47580_86460 n1_M5_48060_86460 10.000000
R19643 n1_M2_47580_87540 n1_M5_48060_87540 10.000000
R19644 n1_M2_47580_88620 n1_M5_48060_88620 10.000000
R19645 n1_M2_47580_89700 n1_M5_48060_89700 10.000000
R19646 n1_M2_47580_90780 n1_M5_48060_90780 10.000000
R19647 n1_M2_47580_91860 n1_M5_48060_91860 10.000000
R19648 n1_M2_47580_92940 n1_M5_48060_92940 10.000000
R19649 n1_M2_47580_94020 n1_M5_48060_94020 10.000000
R19650 n1_M2_47580_95100 n1_M5_48060_95100 10.000000
R19651 n1_M2_47580_96180 n1_M5_48060_96180 10.000000
R19652 n1_M2_47580_97260 n1_M5_48060_97260 10.000000
R19653 n1_M2_47580_98340 n1_M5_48060_98340 10.000000
R19654 n1_M2_47580_99420 n1_M5_48060_99420 10.000000
R19655 n1_M2_47580_100500 n1_M5_48060_100500 10.000000
R19656 n1_M2_47580_101580 n1_M5_48060_101580 10.000000
R19657 n1_M2_47580_102660 n1_M5_48060_102660 10.000000
R19658 n1_M2_47580_103740 n1_M5_48060_103740 10.000000
R19659 n1_M2_47580_104820 n1_M5_48060_104820 10.000000
R19660 n1_M2_47580_105900 n1_M5_48060_105900 10.000000
R19661 n1_M2_47580_106980 n1_M5_48060_106980 10.000000
R19662 n1_M2_47580_108060 n1_M5_48060_108060 10.000000
R19663 n1_M2_47580_109140 n1_M5_48060_109140 10.000000
R19664 n1_M2_47580_110220 n1_M5_48060_110220 10.000000
R19665 n1_M2_47580_111300 n1_M5_48060_111300 10.000000
R19666 n1_M2_47580_112380 n1_M5_48060_112380 10.000000
R19667 n1_M2_47580_113460 n1_M5_48060_113460 10.000000
R19668 n1_M2_47580_114540 n1_M5_48060_114540 10.000000
R19669 n1_M2_47580_115620 n1_M5_48060_115620 10.000000
R19670 n1_M2_47580_116700 n1_M5_48060_116700 10.000000
R19671 n1_M2_47580_117780 n1_M5_48060_117780 10.000000
R19672 n1_M2_47580_118860 n1_M5_48060_118860 10.000000
R19673 n1_M2_47580_119940 n1_M5_48060_119940 10.000000
R19674 n1_M2_47580_121020 n1_M5_48060_121020 10.000000
R19675 n1_M2_47580_122100 n1_M5_48060_122100 10.000000
R19676 n1_M2_47580_123180 n1_M5_48060_123180 10.000000
R19677 n1_M2_47580_124260 n1_M5_48060_124260 10.000000
R19678 n1_M2_47580_125340 n1_M5_48060_125340 10.000000
R19679 n1_M2_47580_126420 n1_M5_48060_126420 10.000000
R19680 n1_M2_47580_127500 n1_M5_48060_127500 10.000000
R19681 n1_M2_47580_128580 n1_M5_48060_128580 10.000000
R19682 n1_M2_47580_129660 n1_M5_48060_129660 10.000000
R19683 n1_M2_54060_60 n1_M5_54060_60 10.000000
R19684 n1_M2_60540_60 n1_M5_60060_60 10.000000
R19685 n1_M2_65940_60 n1_M5_66060_60 10.000000
R19686 n1_M2_72420_60 n1_M5_72060_60 10.000000
R19687 n1_M2_72420_1140 n1_M5_72060_1140 10.000000
R19688 n1_M2_72420_2220 n1_M5_72060_2220 10.000000
R19689 n1_M2_72420_3300 n1_M5_72060_3300 10.000000
R19690 n1_M2_72420_4380 n1_M5_72060_4380 10.000000
R19691 n1_M2_72420_5460 n1_M5_72060_5460 10.000000
R19692 n1_M2_72420_6540 n1_M5_72060_6540 10.000000
R19693 n1_M2_72420_7620 n1_M5_72060_7620 10.000000
R19694 n1_M2_72420_8700 n1_M5_72060_8700 10.000000
R19695 n1_M2_72420_9780 n1_M5_72060_9780 10.000000
R19696 n1_M2_72420_10860 n1_M5_72060_10860 10.000000
R19697 n1_M2_72420_11940 n1_M5_72060_11940 10.000000
R19698 n1_M2_72420_13020 n1_M5_72060_13020 10.000000
R19699 n1_M2_72420_14100 n1_M5_72060_14100 10.000000
R19700 n1_M2_72420_15180 n1_M5_72060_15180 10.000000
R19701 n1_M2_72420_16260 n1_M5_72060_16260 10.000000
R19702 n1_M2_72420_17340 n1_M5_72060_17340 10.000000
R19703 n1_M2_72420_18420 n1_M5_72060_18420 10.000000
R19704 n1_M2_72420_19500 n1_M5_72060_19500 10.000000
R19705 n1_M2_72420_20580 n1_M5_72060_20580 10.000000
R19706 n1_M2_72420_21660 n1_M5_72060_21660 10.000000
R19707 n1_M2_72420_22740 n1_M5_72060_22740 10.000000
R19708 n1_M2_72420_23820 n1_M5_72060_23820 10.000000
R19709 n1_M2_72420_24900 n1_M5_72060_24900 10.000000
R19710 n1_M2_72420_25980 n1_M5_72060_25980 10.000000
R19711 n1_M2_72420_27060 n1_M5_72060_27060 10.000000
R19712 n1_M2_72420_28140 n1_M5_72060_28140 10.000000
R19713 n1_M2_72420_29220 n1_M5_72060_29220 10.000000
R19714 n1_M2_72420_30300 n1_M5_72060_30300 10.000000
R19715 n1_M2_72420_31380 n1_M5_72060_31380 10.000000
R19716 n1_M2_72420_32460 n1_M5_72060_32460 10.000000
R19717 n1_M2_72420_33540 n1_M5_72060_33540 10.000000
R19718 n1_M2_72420_34620 n1_M5_72060_34620 10.000000
R19719 n1_M2_72420_35700 n1_M5_72060_35700 10.000000
R19720 n1_M2_72420_36780 n1_M5_72060_36780 10.000000
R19721 n1_M2_72420_37860 n1_M5_72060_37860 10.000000
R19722 n1_M2_72420_38940 n1_M5_72060_38940 10.000000
R19723 n1_M2_72420_40020 n1_M5_72060_40020 10.000000
R19724 n1_M2_72420_41100 n1_M5_72060_41100 10.000000
R19725 n1_M2_72420_42180 n1_M5_72060_42180 10.000000
R19726 n1_M2_72420_43260 n1_M5_72060_43260 10.000000
R19727 n1_M2_72420_44340 n1_M5_72060_44340 10.000000
R19728 n1_M2_72420_45420 n1_M5_72060_45420 10.000000
R19729 n1_M2_72420_46500 n1_M5_72060_46500 10.000000
R19730 n1_M2_72420_47580 n1_M5_72060_47580 10.000000
R19731 n1_M2_72420_48660 n1_M5_72060_48660 10.000000
R19732 n1_M2_72420_49740 n1_M5_72060_49740 10.000000
R19733 n1_M2_72420_50820 n1_M5_72060_50820 10.000000
R19734 n1_M2_72420_51900 n1_M5_72060_51900 10.000000
R19735 n1_M2_72420_52980 n1_M5_72060_52980 10.000000
R19736 n1_M2_72420_54060 n1_M5_72060_54060 10.000000
R19737 n1_M2_72420_55140 n1_M5_72060_55140 10.000000
R19738 n1_M2_72420_56220 n1_M5_72060_56220 10.000000
R19739 n1_M2_72420_57300 n1_M5_72060_57300 10.000000
R19740 n1_M2_72420_58380 n1_M5_72060_58380 10.000000
R19741 n1_M2_72420_59460 n1_M5_72060_59460 10.000000
R19742 n1_M2_72420_60540 n1_M5_72060_60540 10.000000
R19743 n1_M2_72420_61620 n1_M5_72060_61620 10.000000
R19744 n1_M2_72420_62700 n1_M5_72060_62700 10.000000
R19745 n1_M2_72420_63780 n1_M5_72060_63780 10.000000
R19746 n1_M2_72420_64860 n1_M5_72060_64860 10.000000
R19747 n1_M2_72420_65940 n1_M5_72060_65940 10.000000
R19748 n1_M2_72420_67020 n1_M5_72060_67020 10.000000
R19749 n1_M2_72420_68100 n1_M5_72060_68100 10.000000
R19750 n1_M2_72420_69180 n1_M5_72060_69180 10.000000
R19751 n1_M2_72420_70260 n1_M5_72060_70260 10.000000
R19752 n1_M2_72420_71340 n1_M5_72060_71340 10.000000
R19753 n1_M2_72420_72420 n1_M5_72060_72420 10.000000
R19754 n1_M2_72420_73500 n1_M5_72060_73500 10.000000
R19755 n1_M2_72420_74580 n1_M5_72060_74580 10.000000
R19756 n1_M2_72420_75660 n1_M5_72060_75660 10.000000
R19757 n1_M2_72420_76740 n1_M5_72060_76740 10.000000
R19758 n1_M2_72420_77820 n1_M5_72060_77820 10.000000
R19759 n1_M2_72420_78900 n1_M5_72060_78900 10.000000
R19760 n1_M2_72420_79980 n1_M5_72060_79980 10.000000
R19761 n1_M2_72420_81060 n1_M5_72060_81060 10.000000
R19762 n1_M2_72420_82140 n1_M5_72060_82140 10.000000
R19763 n1_M2_72420_83220 n1_M5_72060_83220 10.000000
R19764 n1_M2_72420_84300 n1_M5_72060_84300 10.000000
R19765 n1_M2_72420_85380 n1_M5_72060_85380 10.000000
R19766 n1_M2_72420_86460 n1_M5_72060_86460 10.000000
R19767 n1_M2_72420_87540 n1_M5_72060_87540 10.000000
R19768 n1_M2_72420_88620 n1_M5_72060_88620 10.000000
R19769 n1_M2_72420_89700 n1_M5_72060_89700 10.000000
R19770 n1_M2_72420_90780 n1_M5_72060_90780 10.000000
R19771 n1_M2_72420_91860 n1_M5_72060_91860 10.000000
R19772 n1_M2_72420_92940 n1_M5_72060_92940 10.000000
R19773 n1_M2_72420_94020 n1_M5_72060_94020 10.000000
R19774 n1_M2_72420_95100 n1_M5_72060_95100 10.000000
R19775 n1_M2_72420_96180 n1_M5_72060_96180 10.000000
R19776 n1_M2_72420_97260 n1_M5_72060_97260 10.000000
R19777 n1_M2_72420_98340 n1_M5_72060_98340 10.000000
R19778 n1_M2_72420_99420 n1_M5_72060_99420 10.000000
R19779 n1_M2_72420_100500 n1_M5_72060_100500 10.000000
R19780 n1_M2_72420_101580 n1_M5_72060_101580 10.000000
R19781 n1_M2_72420_102660 n1_M5_72060_102660 10.000000
R19782 n1_M2_72420_103740 n1_M5_72060_103740 10.000000
R19783 n1_M2_72420_104820 n1_M5_72060_104820 10.000000
R19784 n1_M2_72420_105900 n1_M5_72060_105900 10.000000
R19785 n1_M2_72420_106980 n1_M5_72060_106980 10.000000
R19786 n1_M2_72420_108060 n1_M5_72060_108060 10.000000
R19787 n1_M2_72420_109140 n1_M5_72060_109140 10.000000
R19788 n1_M2_72420_110220 n1_M5_72060_110220 10.000000
R19789 n1_M2_72420_111300 n1_M5_72060_111300 10.000000
R19790 n1_M2_72420_112380 n1_M5_72060_112380 10.000000
R19791 n1_M2_72420_113460 n1_M5_72060_113460 10.000000
R19792 n1_M2_72420_114540 n1_M5_72060_114540 10.000000
R19793 n1_M2_72420_115620 n1_M5_72060_115620 10.000000
R19794 n1_M2_72420_116700 n1_M5_72060_116700 10.000000
R19795 n1_M2_72420_117780 n1_M5_72060_117780 10.000000
R19796 n1_M2_72420_118860 n1_M5_72060_118860 10.000000
R19797 n1_M2_72420_119940 n1_M5_72060_119940 10.000000
R19798 n1_M2_72420_121020 n1_M5_72060_121020 10.000000
R19799 n1_M2_72420_122100 n1_M5_72060_122100 10.000000
R19800 n1_M2_72420_123180 n1_M5_72060_123180 10.000000
R19801 n1_M2_72420_124260 n1_M5_72060_124260 10.000000
R19802 n1_M2_72420_125340 n1_M5_72060_125340 10.000000
R19803 n1_M2_72420_126420 n1_M5_72060_126420 10.000000
R19804 n1_M2_72420_127500 n1_M5_72060_127500 10.000000
R19805 n1_M2_72420_128580 n1_M5_72060_128580 10.000000
R19806 n1_M2_72420_129660 n1_M5_72060_129660 10.000000
R19807 n1_M2_77820_60 n1_M5_78060_60 10.000000
R19808 n1_M2_84300_60 n1_M5_84060_60 10.000000
R19809 n1_M2_89700_60 n1_M5_90060_60 10.000000
R19810 n1_M2_96180_60 n1_M5_96060_60 10.000000
R19811 n1_M2_96180_1140 n1_M5_96060_1140 10.000000
R19812 n1_M2_96180_2220 n1_M5_96060_2220 10.000000
R19813 n1_M2_96180_3300 n1_M5_96060_3300 10.000000
R19814 n1_M2_96180_4380 n1_M5_96060_4380 10.000000
R19815 n1_M2_96180_5460 n1_M5_96060_5460 10.000000
R19816 n1_M2_96180_6540 n1_M5_96060_6540 10.000000
R19817 n1_M2_96180_7620 n1_M5_96060_7620 10.000000
R19818 n1_M2_96180_8700 n1_M5_96060_8700 10.000000
R19819 n1_M2_96180_9780 n1_M5_96060_9780 10.000000
R19820 n1_M2_96180_10860 n1_M5_96060_10860 10.000000
R19821 n1_M2_96180_11940 n1_M5_96060_11940 10.000000
R19822 n1_M2_96180_13020 n1_M5_96060_13020 10.000000
R19823 n1_M2_96180_14100 n1_M5_96060_14100 10.000000
R19824 n1_M2_96180_15180 n1_M5_96060_15180 10.000000
R19825 n1_M2_96180_16260 n1_M5_96060_16260 10.000000
R19826 n1_M2_96180_17340 n1_M5_96060_17340 10.000000
R19827 n1_M2_96180_18420 n1_M5_96060_18420 10.000000
R19828 n1_M2_96180_19500 n1_M5_96060_19500 10.000000
R19829 n1_M2_96180_20580 n1_M5_96060_20580 10.000000
R19830 n1_M2_96180_21660 n1_M5_96060_21660 10.000000
R19831 n1_M2_96180_22740 n1_M5_96060_22740 10.000000
R19832 n1_M2_96180_23820 n1_M5_96060_23820 10.000000
R19833 n1_M2_96180_24900 n1_M5_96060_24900 10.000000
R19834 n1_M2_96180_25980 n1_M5_96060_25980 10.000000
R19835 n1_M2_96180_27060 n1_M5_96060_27060 10.000000
R19836 n1_M2_96180_28140 n1_M5_96060_28140 10.000000
R19837 n1_M2_96180_29220 n1_M5_96060_29220 10.000000
R19838 n1_M2_96180_30300 n1_M5_96060_30300 10.000000
R19839 n1_M2_96180_31380 n1_M5_96060_31380 10.000000
R19840 n1_M2_96180_32460 n1_M5_96060_32460 10.000000
R19841 n1_M2_96180_33540 n1_M5_96060_33540 10.000000
R19842 n1_M2_96180_34620 n1_M5_96060_34620 10.000000
R19843 n1_M2_96180_35700 n1_M5_96060_35700 10.000000
R19844 n1_M2_96180_36780 n1_M5_96060_36780 10.000000
R19845 n1_M2_96180_37860 n1_M5_96060_37860 10.000000
R19846 n1_M2_96180_38940 n1_M5_96060_38940 10.000000
R19847 n1_M2_96180_40020 n1_M5_96060_40020 10.000000
R19848 n1_M2_96180_41100 n1_M5_96060_41100 10.000000
R19849 n1_M2_96180_42180 n1_M5_96060_42180 10.000000
R19850 n1_M2_96180_43260 n1_M5_96060_43260 10.000000
R19851 n1_M2_96180_44340 n1_M5_96060_44340 10.000000
R19852 n1_M2_96180_45420 n1_M5_96060_45420 10.000000
R19853 n1_M2_96180_46500 n1_M5_96060_46500 10.000000
R19854 n1_M2_96180_47580 n1_M5_96060_47580 10.000000
R19855 n1_M2_96180_48660 n1_M5_96060_48660 10.000000
R19856 n1_M2_96180_49740 n1_M5_96060_49740 10.000000
R19857 n1_M2_96180_50820 n1_M5_96060_50820 10.000000
R19858 n1_M2_96180_51900 n1_M5_96060_51900 10.000000
R19859 n1_M2_96180_52980 n1_M5_96060_52980 10.000000
R19860 n1_M2_96180_54060 n1_M5_96060_54060 10.000000
R19861 n1_M2_96180_55140 n1_M5_96060_55140 10.000000
R19862 n1_M2_96180_56220 n1_M5_96060_56220 10.000000
R19863 n1_M2_96180_57300 n1_M5_96060_57300 10.000000
R19864 n1_M2_96180_58380 n1_M5_96060_58380 10.000000
R19865 n1_M2_96180_59460 n1_M5_96060_59460 10.000000
R19866 n1_M2_96180_60540 n1_M5_96060_60540 10.000000
R19867 n1_M2_96180_61620 n1_M5_96060_61620 10.000000
R19868 n1_M2_96180_62700 n1_M5_96060_62700 10.000000
R19869 n1_M2_96180_63780 n1_M5_96060_63780 10.000000
R19870 n1_M2_96180_64860 n1_M5_96060_64860 10.000000
R19871 n1_M2_96180_65940 n1_M5_96060_65940 10.000000
R19872 n1_M2_96180_67020 n1_M5_96060_67020 10.000000
R19873 n1_M2_96180_68100 n1_M5_96060_68100 10.000000
R19874 n1_M2_96180_69180 n1_M5_96060_69180 10.000000
R19875 n1_M2_96180_70260 n1_M5_96060_70260 10.000000
R19876 n1_M2_96180_71340 n1_M5_96060_71340 10.000000
R19877 n1_M2_96180_72420 n1_M5_96060_72420 10.000000
R19878 n1_M2_96180_73500 n1_M5_96060_73500 10.000000
R19879 n1_M2_96180_74580 n1_M5_96060_74580 10.000000
R19880 n1_M2_96180_75660 n1_M5_96060_75660 10.000000
R19881 n1_M2_96180_76740 n1_M5_96060_76740 10.000000
R19882 n1_M2_96180_77820 n1_M5_96060_77820 10.000000
R19883 n1_M2_96180_78900 n1_M5_96060_78900 10.000000
R19884 n1_M2_96180_79980 n1_M5_96060_79980 10.000000
R19885 n1_M2_96180_81060 n1_M5_96060_81060 10.000000
R19886 n1_M2_96180_82140 n1_M5_96060_82140 10.000000
R19887 n1_M2_96180_83220 n1_M5_96060_83220 10.000000
R19888 n1_M2_96180_84300 n1_M5_96060_84300 10.000000
R19889 n1_M2_96180_85380 n1_M5_96060_85380 10.000000
R19890 n1_M2_96180_86460 n1_M5_96060_86460 10.000000
R19891 n1_M2_96180_87540 n1_M5_96060_87540 10.000000
R19892 n1_M2_96180_88620 n1_M5_96060_88620 10.000000
R19893 n1_M2_96180_89700 n1_M5_96060_89700 10.000000
R19894 n1_M2_96180_90780 n1_M5_96060_90780 10.000000
R19895 n1_M2_96180_91860 n1_M5_96060_91860 10.000000
R19896 n1_M2_96180_92940 n1_M5_96060_92940 10.000000
R19897 n1_M2_96180_94020 n1_M5_96060_94020 10.000000
R19898 n1_M2_96180_95100 n1_M5_96060_95100 10.000000
R19899 n1_M2_96180_96180 n1_M5_96060_96180 10.000000
R19900 n1_M2_96180_97260 n1_M5_96060_97260 10.000000
R19901 n1_M2_96180_98340 n1_M5_96060_98340 10.000000
R19902 n1_M2_96180_99420 n1_M5_96060_99420 10.000000
R19903 n1_M2_96180_100500 n1_M5_96060_100500 10.000000
R19904 n1_M2_96180_101580 n1_M5_96060_101580 10.000000
R19905 n1_M2_96180_102660 n1_M5_96060_102660 10.000000
R19906 n1_M2_96180_103740 n1_M5_96060_103740 10.000000
R19907 n1_M2_96180_104820 n1_M5_96060_104820 10.000000
R19908 n1_M2_96180_105900 n1_M5_96060_105900 10.000000
R19909 n1_M2_96180_106980 n1_M5_96060_106980 10.000000
R19910 n1_M2_96180_108060 n1_M5_96060_108060 10.000000
R19911 n1_M2_96180_109140 n1_M5_96060_109140 10.000000
R19912 n1_M2_96180_110220 n1_M5_96060_110220 10.000000
R19913 n1_M2_96180_111300 n1_M5_96060_111300 10.000000
R19914 n1_M2_96180_112380 n1_M5_96060_112380 10.000000
R19915 n1_M2_96180_113460 n1_M5_96060_113460 10.000000
R19916 n1_M2_96180_114540 n1_M5_96060_114540 10.000000
R19917 n1_M2_96180_115620 n1_M5_96060_115620 10.000000
R19918 n1_M2_96180_116700 n1_M5_96060_116700 10.000000
R19919 n1_M2_96180_117780 n1_M5_96060_117780 10.000000
R19920 n1_M2_96180_118860 n1_M5_96060_118860 10.000000
R19921 n1_M2_96180_119940 n1_M5_96060_119940 10.000000
R19922 n1_M2_96180_121020 n1_M5_96060_121020 10.000000
R19923 n1_M2_96180_122100 n1_M5_96060_122100 10.000000
R19924 n1_M2_96180_123180 n1_M5_96060_123180 10.000000
R19925 n1_M2_96180_124260 n1_M5_96060_124260 10.000000
R19926 n1_M2_96180_125340 n1_M5_96060_125340 10.000000
R19927 n1_M2_96180_126420 n1_M5_96060_126420 10.000000
R19928 n1_M2_96180_127500 n1_M5_96060_127500 10.000000
R19929 n1_M2_96180_128580 n1_M5_96060_128580 10.000000
R19930 n1_M2_96180_129660 n1_M5_96060_129660 10.000000
R19931 n1_M2_101580_60 n1_M5_102060_60 10.000000
R19932 n1_M2_108060_60 n1_M5_108060_60 10.000000
R19933 n1_M2_114540_60 n1_M5_114060_60 10.000000
R19934 n1_M2_119940_60 n1_M5_120060_60 10.000000
R19935 n1_M2_119940_1140 n1_M5_120060_1140 10.000000
R19936 n1_M2_119940_2220 n1_M5_120060_2220 10.000000
R19937 n1_M2_119940_3300 n1_M5_120060_3300 10.000000
R19938 n1_M2_119940_4380 n1_M5_120060_4380 10.000000
R19939 n1_M2_119940_5460 n1_M5_120060_5460 10.000000
R19940 n1_M2_119940_6540 n1_M5_120060_6540 10.000000
R19941 n1_M2_119940_7620 n1_M5_120060_7620 10.000000
R19942 n1_M2_119940_8700 n1_M5_120060_8700 10.000000
R19943 n1_M2_119940_9780 n1_M5_120060_9780 10.000000
R19944 n1_M2_119940_10860 n1_M5_120060_10860 10.000000
R19945 n1_M2_119940_11940 n1_M5_120060_11940 10.000000
R19946 n1_M2_119940_13020 n1_M5_120060_13020 10.000000
R19947 n1_M2_119940_14100 n1_M5_120060_14100 10.000000
R19948 n1_M2_119940_15180 n1_M5_120060_15180 10.000000
R19949 n1_M2_119940_16260 n1_M5_120060_16260 10.000000
R19950 n1_M2_119940_17340 n1_M5_120060_17340 10.000000
R19951 n1_M2_119940_18420 n1_M5_120060_18420 10.000000
R19952 n1_M2_119940_19500 n1_M5_120060_19500 10.000000
R19953 n1_M2_119940_20580 n1_M5_120060_20580 10.000000
R19954 n1_M2_119940_21660 n1_M5_120060_21660 10.000000
R19955 n1_M2_119940_22740 n1_M5_120060_22740 10.000000
R19956 n1_M2_119940_23820 n1_M5_120060_23820 10.000000
R19957 n1_M2_119940_24900 n1_M5_120060_24900 10.000000
R19958 n1_M2_119940_25980 n1_M5_120060_25980 10.000000
R19959 n1_M2_119940_27060 n1_M5_120060_27060 10.000000
R19960 n1_M2_119940_28140 n1_M5_120060_28140 10.000000
R19961 n1_M2_119940_29220 n1_M5_120060_29220 10.000000
R19962 n1_M2_119940_30300 n1_M5_120060_30300 10.000000
R19963 n1_M2_119940_31380 n1_M5_120060_31380 10.000000
R19964 n1_M2_119940_32460 n1_M5_120060_32460 10.000000
R19965 n1_M2_119940_33540 n1_M5_120060_33540 10.000000
R19966 n1_M2_119940_34620 n1_M5_120060_34620 10.000000
R19967 n1_M2_119940_35700 n1_M5_120060_35700 10.000000
R19968 n1_M2_119940_36780 n1_M5_120060_36780 10.000000
R19969 n1_M2_119940_37860 n1_M5_120060_37860 10.000000
R19970 n1_M2_119940_38940 n1_M5_120060_38940 10.000000
R19971 n1_M2_119940_40020 n1_M5_120060_40020 10.000000
R19972 n1_M2_119940_41100 n1_M5_120060_41100 10.000000
R19973 n1_M2_119940_42180 n1_M5_120060_42180 10.000000
R19974 n1_M2_119940_43260 n1_M5_120060_43260 10.000000
R19975 n1_M2_119940_44340 n1_M5_120060_44340 10.000000
R19976 n1_M2_119940_45420 n1_M5_120060_45420 10.000000
R19977 n1_M2_119940_46500 n1_M5_120060_46500 10.000000
R19978 n1_M2_119940_47580 n1_M5_120060_47580 10.000000
R19979 n1_M2_119940_48660 n1_M5_120060_48660 10.000000
R19980 n1_M2_119940_49740 n1_M5_120060_49740 10.000000
R19981 n1_M2_119940_50820 n1_M5_120060_50820 10.000000
R19982 n1_M2_119940_51900 n1_M5_120060_51900 10.000000
R19983 n1_M2_119940_52980 n1_M5_120060_52980 10.000000
R19984 n1_M2_119940_54060 n1_M5_120060_54060 10.000000
R19985 n1_M2_119940_55140 n1_M5_120060_55140 10.000000
R19986 n1_M2_119940_56220 n1_M5_120060_56220 10.000000
R19987 n1_M2_119940_57300 n1_M5_120060_57300 10.000000
R19988 n1_M2_119940_58380 n1_M5_120060_58380 10.000000
R19989 n1_M2_119940_59460 n1_M5_120060_59460 10.000000
R19990 n1_M2_119940_60540 n1_M5_120060_60540 10.000000
R19991 n1_M2_119940_61620 n1_M5_120060_61620 10.000000
R19992 n1_M2_119940_62700 n1_M5_120060_62700 10.000000
R19993 n1_M2_119940_63780 n1_M5_120060_63780 10.000000
R19994 n1_M2_119940_64860 n1_M5_120060_64860 10.000000
R19995 n1_M2_119940_65940 n1_M5_120060_65940 10.000000
R19996 n1_M2_119940_67020 n1_M5_120060_67020 10.000000
R19997 n1_M2_119940_68100 n1_M5_120060_68100 10.000000
R19998 n1_M2_119940_69180 n1_M5_120060_69180 10.000000
R19999 n1_M2_119940_70260 n1_M5_120060_70260 10.000000
R20000 n1_M2_119940_71340 n1_M5_120060_71340 10.000000
R20001 n1_M2_119940_72420 n1_M5_120060_72420 10.000000
R20002 n1_M2_119940_73500 n1_M5_120060_73500 10.000000
R20003 n1_M2_119940_74580 n1_M5_120060_74580 10.000000
R20004 n1_M2_119940_75660 n1_M5_120060_75660 10.000000
R20005 n1_M2_119940_76740 n1_M5_120060_76740 10.000000
R20006 n1_M2_119940_77820 n1_M5_120060_77820 10.000000
R20007 n1_M2_119940_78900 n1_M5_120060_78900 10.000000
R20008 n1_M2_119940_79980 n1_M5_120060_79980 10.000000
R20009 n1_M2_119940_81060 n1_M5_120060_81060 10.000000
R20010 n1_M2_119940_82140 n1_M5_120060_82140 10.000000
R20011 n1_M2_119940_83220 n1_M5_120060_83220 10.000000
R20012 n1_M2_119940_84300 n1_M5_120060_84300 10.000000
R20013 n1_M2_119940_85380 n1_M5_120060_85380 10.000000
R20014 n1_M2_119940_86460 n1_M5_120060_86460 10.000000
R20015 n1_M2_119940_87540 n1_M5_120060_87540 10.000000
R20016 n1_M2_119940_88620 n1_M5_120060_88620 10.000000
R20017 n1_M2_119940_89700 n1_M5_120060_89700 10.000000
R20018 n1_M2_119940_90780 n1_M5_120060_90780 10.000000
R20019 n1_M2_119940_91860 n1_M5_120060_91860 10.000000
R20020 n1_M2_119940_92940 n1_M5_120060_92940 10.000000
R20021 n1_M2_119940_94020 n1_M5_120060_94020 10.000000
R20022 n1_M2_119940_95100 n1_M5_120060_95100 10.000000
R20023 n1_M2_119940_96180 n1_M5_120060_96180 10.000000
R20024 n1_M2_119940_97260 n1_M5_120060_97260 10.000000
R20025 n1_M2_119940_98340 n1_M5_120060_98340 10.000000
R20026 n1_M2_119940_99420 n1_M5_120060_99420 10.000000
R20027 n1_M2_119940_100500 n1_M5_120060_100500 10.000000
R20028 n1_M2_119940_101580 n1_M5_120060_101580 10.000000
R20029 n1_M2_119940_102660 n1_M5_120060_102660 10.000000
R20030 n1_M2_119940_103740 n1_M5_120060_103740 10.000000
R20031 n1_M2_119940_104820 n1_M5_120060_104820 10.000000
R20032 n1_M2_119940_105900 n1_M5_120060_105900 10.000000
R20033 n1_M2_119940_106980 n1_M5_120060_106980 10.000000
R20034 n1_M2_119940_108060 n1_M5_120060_108060 10.000000
R20035 n1_M2_119940_109140 n1_M5_120060_109140 10.000000
R20036 n1_M2_119940_110220 n1_M5_120060_110220 10.000000
R20037 n1_M2_119940_111300 n1_M5_120060_111300 10.000000
R20038 n1_M2_119940_112380 n1_M5_120060_112380 10.000000
R20039 n1_M2_119940_113460 n1_M5_120060_113460 10.000000
R20040 n1_M2_119940_114540 n1_M5_120060_114540 10.000000
R20041 n1_M2_119940_115620 n1_M5_120060_115620 10.000000
R20042 n1_M2_119940_116700 n1_M5_120060_116700 10.000000
R20043 n1_M2_119940_117780 n1_M5_120060_117780 10.000000
R20044 n1_M2_119940_118860 n1_M5_120060_118860 10.000000
R20045 n1_M2_119940_119940 n1_M5_120060_119940 10.000000
R20046 n1_M2_119940_121020 n1_M5_120060_121020 10.000000
R20047 n1_M2_119940_122100 n1_M5_120060_122100 10.000000
R20048 n1_M2_119940_123180 n1_M5_120060_123180 10.000000
R20049 n1_M2_119940_124260 n1_M5_120060_124260 10.000000
R20050 n1_M2_119940_125340 n1_M5_120060_125340 10.000000
R20051 n1_M2_119940_126420 n1_M5_120060_126420 10.000000
R20052 n1_M2_119940_127500 n1_M5_120060_127500 10.000000
R20053 n1_M2_119940_128580 n1_M5_120060_128580 10.000000
R20054 n1_M2_119940_129660 n1_M5_120060_129660 10.000000
R20055 n1_M2_126420_60 n1_M5_126060_60 10.000000
R20056 n1_M5_60_60 n1_M6_60_60 10.000000
R20057 n1_M5_60_12060 n1_M6_60_12060 10.000000
R20058 n1_M5_60_24060 n1_M6_60_24060 10.000000
R20059 n1_M5_60_36060 n1_M6_60_36060 10.000000
R20060 n1_M5_60_48060 n1_M6_60_48060 10.000000
R20061 n1_M5_60_60060 n1_M6_60_60060 10.000000
R20062 n1_M5_60_72060 n1_M6_60_72060 10.000000
R20063 n1_M5_60_84060 n1_M6_60_84060 10.000000
R20064 n1_M5_60_96060 n1_M6_60_96060 10.000000
R20065 n1_M5_60_108060 n1_M6_60_108060 10.000000
R20066 n1_M5_60_120060 n1_M6_60_120060 10.000000
R20067 n1_M5_6060_60 n1_M6_6060_60 10.000000
R20068 n1_M5_12060_60 n1_M6_12060_60 10.000000
R20069 n1_M5_18060_60 n1_M6_18060_60 10.000000
R20070 n1_M5_24060_60 n1_M6_24060_60 10.000000
R20071 n1_M5_24060_12060 n1_M6_24060_12060 10.000000
R20072 n1_M5_24060_24060 n1_M6_24060_24060 10.000000
R20073 n1_M5_24060_36060 n1_M6_24060_36060 10.000000
R20074 n1_M5_24060_48060 n1_M6_24060_48060 10.000000
R20075 n1_M5_24060_60060 n1_M6_24060_60060 10.000000
R20076 n1_M5_24060_72060 n1_M6_24060_72060 10.000000
R20077 n1_M5_24060_84060 n1_M6_24060_84060 10.000000
R20078 n1_M5_24060_96060 n1_M6_24060_96060 10.000000
R20079 n1_M5_24060_108060 n1_M6_24060_108060 10.000000
R20080 n1_M5_24060_120060 n1_M6_24060_120060 10.000000
R20081 n1_M5_30060_60 n1_M6_30060_60 10.000000
R20082 n1_M5_36060_60 n1_M6_36060_60 10.000000
R20083 n1_M5_42060_60 n1_M6_42060_60 10.000000
R20084 n1_M5_48060_60 n1_M6_48060_60 10.000000
R20085 n1_M5_48060_12060 n1_M6_48060_12060 10.000000
R20086 n1_M5_48060_24060 n1_M6_48060_24060 10.000000
R20087 n1_M5_48060_36060 n1_M6_48060_36060 10.000000
R20088 n1_M5_48060_48060 n1_M6_48060_48060 10.000000
R20089 n1_M5_48060_60060 n1_M6_48060_60060 10.000000
R20090 n1_M5_48060_72060 n1_M6_48060_72060 10.000000
R20091 n1_M5_48060_84060 n1_M6_48060_84060 10.000000
R20092 n1_M5_48060_96060 n1_M6_48060_96060 10.000000
R20093 n1_M5_48060_108060 n1_M6_48060_108060 10.000000
R20094 n1_M5_48060_120060 n1_M6_48060_120060 10.000000
R20095 n1_M5_54060_60 n1_M6_54060_60 10.000000
R20096 n1_M5_60060_60 n1_M6_60060_60 10.000000
R20097 n1_M5_66060_60 n1_M6_66060_60 10.000000
R20098 n1_M5_72060_60 n1_M6_72060_60 10.000000
R20099 n1_M5_72060_12060 n1_M6_72060_12060 10.000000
R20100 n1_M5_72060_24060 n1_M6_72060_24060 10.000000
R20101 n1_M5_72060_36060 n1_M6_72060_36060 10.000000
R20102 n1_M5_72060_48060 n1_M6_72060_48060 10.000000
R20103 n1_M5_72060_60060 n1_M6_72060_60060 10.000000
R20104 n1_M5_72060_72060 n1_M6_72060_72060 10.000000
R20105 n1_M5_72060_84060 n1_M6_72060_84060 10.000000
R20106 n1_M5_72060_96060 n1_M6_72060_96060 10.000000
R20107 n1_M5_72060_108060 n1_M6_72060_108060 10.000000
R20108 n1_M5_72060_120060 n1_M6_72060_120060 10.000000
R20109 n1_M5_78060_60 n1_M6_78060_60 10.000000
R20110 n1_M5_84060_60 n1_M6_84060_60 10.000000
R20111 n1_M5_90060_60 n1_M6_90060_60 10.000000
R20112 n1_M5_96060_60 n1_M6_96060_60 10.000000
R20113 n1_M5_96060_12060 n1_M6_96060_12060 10.000000
R20114 n1_M5_96060_24060 n1_M6_96060_24060 10.000000
R20115 n1_M5_96060_36060 n1_M6_96060_36060 10.000000
R20116 n1_M5_96060_48060 n1_M6_96060_48060 10.000000
R20117 n1_M5_96060_60060 n1_M6_96060_60060 10.000000
R20118 n1_M5_96060_72060 n1_M6_96060_72060 10.000000
R20119 n1_M5_96060_84060 n1_M6_96060_84060 10.000000
R20120 n1_M5_96060_96060 n1_M6_96060_96060 10.000000
R20121 n1_M5_96060_108060 n1_M6_96060_108060 10.000000
R20122 n1_M5_96060_120060 n1_M6_96060_120060 10.000000
R20123 n1_M5_102060_60 n1_M6_102060_60 10.000000
R20124 n1_M5_108060_60 n1_M6_108060_60 10.000000
R20125 n1_M5_114060_60 n1_M6_114060_60 10.000000
R20126 n1_M5_120060_60 n1_M6_120060_60 10.000000
R20127 n1_M5_120060_12060 n1_M6_120060_12060 10.000000
R20128 n1_M5_120060_24060 n1_M6_120060_24060 10.000000
R20129 n1_M5_120060_36060 n1_M6_120060_36060 10.000000
R20130 n1_M5_120060_48060 n1_M6_120060_48060 10.000000
R20131 n1_M5_120060_60060 n1_M6_120060_60060 10.000000
R20132 n1_M5_120060_72060 n1_M6_120060_72060 10.000000
R20133 n1_M5_120060_84060 n1_M6_120060_84060 10.000000
R20134 n1_M5_120060_96060 n1_M6_120060_96060 10.000000
R20135 n1_M5_120060_108060 n1_M6_120060_108060 10.000000
R20136 n1_M5_120060_120060 n1_M6_120060_120060 10.000000
R20137 n1_M5_126060_60 n1_M6_126060_60 10.000000
R20138 n1_M6_60_60 n1_M7_60_60 10.000000
R20139 n1_M6_60_12060 n1_M7_60_12060 10.000000
R20140 n1_M6_60_24060 n1_M7_60_24060 10.000000
R20141 n1_M6_60_36060 n1_M7_60_36060 10.000000
R20142 n1_M6_60_48060 n1_M7_60_48060 10.000000
R20143 n1_M6_60_60060 n1_M7_60_60060 10.000000
R20144 n1_M6_60_72060 n1_M7_60_72060 10.000000
R20145 n1_M6_60_84060 n1_M7_60_84060 10.000000
R20146 n1_M6_60_96060 n1_M7_60_96060 10.000000
R20147 n1_M6_60_108060 n1_M7_60_108060 10.000000
R20148 n1_M6_60_120060 n1_M7_60_120060 10.000000
R20149 n1_M6_4156_60 n1_M7_4156_60 10.000000
R20150 n1_M6_4156_12060 n1_M7_4156_12060 10.000000
R20151 n1_M6_4156_24060 n1_M7_4156_24060 10.000000
R20152 n1_M6_4156_36060 n1_M7_4156_36060 10.000000
R20153 n1_M6_4156_48060 n1_M7_4156_48060 10.000000
R20154 n1_M6_4156_60060 n1_M7_4156_60060 10.000000
R20155 n1_M6_4156_72060 n1_M7_4156_72060 10.000000
R20156 n1_M6_4156_84060 n1_M7_4156_84060 10.000000
R20157 n1_M6_4156_96060 n1_M7_4156_96060 10.000000
R20158 n1_M6_4156_108060 n1_M7_4156_108060 10.000000
R20159 n1_M6_4156_120060 n1_M7_4156_120060 10.000000
R20160 n1_M6_8252_60 n1_M7_8252_60 10.000000
R20161 n1_M6_8252_12060 n1_M7_8252_12060 10.000000
R20162 n1_M6_8252_24060 n1_M7_8252_24060 10.000000
R20163 n1_M6_8252_36060 n1_M7_8252_36060 10.000000
R20164 n1_M6_8252_48060 n1_M7_8252_48060 10.000000
R20165 n1_M6_8252_60060 n1_M7_8252_60060 10.000000
R20166 n1_M6_8252_72060 n1_M7_8252_72060 10.000000
R20167 n1_M6_8252_84060 n1_M7_8252_84060 10.000000
R20168 n1_M6_8252_96060 n1_M7_8252_96060 10.000000
R20169 n1_M6_8252_108060 n1_M7_8252_108060 10.000000
R20170 n1_M6_8252_120060 n1_M7_8252_120060 10.000000
R20171 n1_M6_12348_60 n1_M7_12348_60 10.000000
R20172 n1_M6_12348_12060 n1_M7_12348_12060 10.000000
R20173 n1_M6_12348_24060 n1_M7_12348_24060 10.000000
R20174 n1_M6_12348_36060 n1_M7_12348_36060 10.000000
R20175 n1_M6_12348_48060 n1_M7_12348_48060 10.000000
R20176 n1_M6_12348_60060 n1_M7_12348_60060 10.000000
R20177 n1_M6_12348_72060 n1_M7_12348_72060 10.000000
R20178 n1_M6_12348_84060 n1_M7_12348_84060 10.000000
R20179 n1_M6_12348_96060 n1_M7_12348_96060 10.000000
R20180 n1_M6_12348_108060 n1_M7_12348_108060 10.000000
R20181 n1_M6_12348_120060 n1_M7_12348_120060 10.000000
R20182 n1_M6_16444_60 n1_M7_16444_60 10.000000
R20183 n1_M6_16444_12060 n1_M7_16444_12060 10.000000
R20184 n1_M6_16444_24060 n1_M7_16444_24060 10.000000
R20185 n1_M6_16444_36060 n1_M7_16444_36060 10.000000
R20186 n1_M6_16444_48060 n1_M7_16444_48060 10.000000
R20187 n1_M6_16444_60060 n1_M7_16444_60060 10.000000
R20188 n1_M6_16444_72060 n1_M7_16444_72060 10.000000
R20189 n1_M6_16444_84060 n1_M7_16444_84060 10.000000
R20190 n1_M6_16444_96060 n1_M7_16444_96060 10.000000
R20191 n1_M6_16444_108060 n1_M7_16444_108060 10.000000
R20192 n1_M6_16444_120060 n1_M7_16444_120060 10.000000
R20193 n1_M6_20540_60 n1_M7_20540_60 10.000000
R20194 n1_M6_20540_12060 n1_M7_20540_12060 10.000000
R20195 n1_M6_20540_24060 n1_M7_20540_24060 10.000000
R20196 n1_M6_20540_36060 n1_M7_20540_36060 10.000000
R20197 n1_M6_20540_48060 n1_M7_20540_48060 10.000000
R20198 n1_M6_20540_60060 n1_M7_20540_60060 10.000000
R20199 n1_M6_20540_72060 n1_M7_20540_72060 10.000000
R20200 n1_M6_20540_84060 n1_M7_20540_84060 10.000000
R20201 n1_M6_20540_96060 n1_M7_20540_96060 10.000000
R20202 n1_M6_20540_108060 n1_M7_20540_108060 10.000000
R20203 n1_M6_20540_120060 n1_M7_20540_120060 10.000000
R20204 n1_M6_24636_60 n1_M7_24636_60 10.000000
R20205 n1_M6_24636_12060 n1_M7_24636_12060 10.000000
R20206 n1_M6_24636_24060 n1_M7_24636_24060 10.000000
R20207 n1_M6_24636_36060 n1_M7_24636_36060 10.000000
R20208 n1_M6_24636_48060 n1_M7_24636_48060 10.000000
R20209 n1_M6_24636_60060 n1_M7_24636_60060 10.000000
R20210 n1_M6_24636_72060 n1_M7_24636_72060 10.000000
R20211 n1_M6_24636_84060 n1_M7_24636_84060 10.000000
R20212 n1_M6_24636_96060 n1_M7_24636_96060 10.000000
R20213 n1_M6_24636_108060 n1_M7_24636_108060 10.000000
R20214 n1_M6_24636_120060 n1_M7_24636_120060 10.000000
R20215 n1_M6_28732_60 n1_M7_28732_60 10.000000
R20216 n1_M6_28732_12060 n1_M7_28732_12060 10.000000
R20217 n1_M6_28732_24060 n1_M7_28732_24060 10.000000
R20218 n1_M6_28732_36060 n1_M7_28732_36060 10.000000
R20219 n1_M6_28732_48060 n1_M7_28732_48060 10.000000
R20220 n1_M6_28732_60060 n1_M7_28732_60060 10.000000
R20221 n1_M6_28732_72060 n1_M7_28732_72060 10.000000
R20222 n1_M6_28732_84060 n1_M7_28732_84060 10.000000
R20223 n1_M6_28732_96060 n1_M7_28732_96060 10.000000
R20224 n1_M6_28732_108060 n1_M7_28732_108060 10.000000
R20225 n1_M6_28732_120060 n1_M7_28732_120060 10.000000
R20226 n1_M6_32828_60 n1_M7_32828_60 10.000000
R20227 n1_M6_32828_12060 n1_M7_32828_12060 10.000000
R20228 n1_M6_32828_24060 n1_M7_32828_24060 10.000000
R20229 n1_M6_32828_36060 n1_M7_32828_36060 10.000000
R20230 n1_M6_32828_48060 n1_M7_32828_48060 10.000000
R20231 n1_M6_32828_60060 n1_M7_32828_60060 10.000000
R20232 n1_M6_32828_72060 n1_M7_32828_72060 10.000000
R20233 n1_M6_32828_84060 n1_M7_32828_84060 10.000000
R20234 n1_M6_32828_96060 n1_M7_32828_96060 10.000000
R20235 n1_M6_32828_108060 n1_M7_32828_108060 10.000000
R20236 n1_M6_32828_120060 n1_M7_32828_120060 10.000000
R20237 n1_M6_36924_60 n1_M7_36924_60 10.000000
R20238 n1_M6_36924_12060 n1_M7_36924_12060 10.000000
R20239 n1_M6_36924_24060 n1_M7_36924_24060 10.000000
R20240 n1_M6_36924_36060 n1_M7_36924_36060 10.000000
R20241 n1_M6_36924_48060 n1_M7_36924_48060 10.000000
R20242 n1_M6_36924_60060 n1_M7_36924_60060 10.000000
R20243 n1_M6_36924_72060 n1_M7_36924_72060 10.000000
R20244 n1_M6_36924_84060 n1_M7_36924_84060 10.000000
R20245 n1_M6_36924_96060 n1_M7_36924_96060 10.000000
R20246 n1_M6_36924_108060 n1_M7_36924_108060 10.000000
R20247 n1_M6_36924_120060 n1_M7_36924_120060 10.000000
R20248 n1_M6_41020_60 n1_M7_41020_60 10.000000
R20249 n1_M6_41020_12060 n1_M7_41020_12060 10.000000
R20250 n1_M6_41020_24060 n1_M7_41020_24060 10.000000
R20251 n1_M6_41020_36060 n1_M7_41020_36060 10.000000
R20252 n1_M6_41020_48060 n1_M7_41020_48060 10.000000
R20253 n1_M6_41020_60060 n1_M7_41020_60060 10.000000
R20254 n1_M6_41020_72060 n1_M7_41020_72060 10.000000
R20255 n1_M6_41020_84060 n1_M7_41020_84060 10.000000
R20256 n1_M6_41020_96060 n1_M7_41020_96060 10.000000
R20257 n1_M6_41020_108060 n1_M7_41020_108060 10.000000
R20258 n1_M6_41020_120060 n1_M7_41020_120060 10.000000
R20259 n1_M6_45116_60 n1_M7_45116_60 10.000000
R20260 n1_M6_45116_12060 n1_M7_45116_12060 10.000000
R20261 n1_M6_45116_24060 n1_M7_45116_24060 10.000000
R20262 n1_M6_45116_36060 n1_M7_45116_36060 10.000000
R20263 n1_M6_45116_48060 n1_M7_45116_48060 10.000000
R20264 n1_M6_45116_60060 n1_M7_45116_60060 10.000000
R20265 n1_M6_45116_72060 n1_M7_45116_72060 10.000000
R20266 n1_M6_45116_84060 n1_M7_45116_84060 10.000000
R20267 n1_M6_45116_96060 n1_M7_45116_96060 10.000000
R20268 n1_M6_45116_108060 n1_M7_45116_108060 10.000000
R20269 n1_M6_45116_120060 n1_M7_45116_120060 10.000000
R20270 n1_M6_49212_60 n1_M7_49212_60 10.000000
R20271 n1_M6_49212_12060 n1_M7_49212_12060 10.000000
R20272 n1_M6_49212_24060 n1_M7_49212_24060 10.000000
R20273 n1_M6_49212_36060 n1_M7_49212_36060 10.000000
R20274 n1_M6_49212_48060 n1_M7_49212_48060 10.000000
R20275 n1_M6_49212_60060 n1_M7_49212_60060 10.000000
R20276 n1_M6_49212_72060 n1_M7_49212_72060 10.000000
R20277 n1_M6_49212_84060 n1_M7_49212_84060 10.000000
R20278 n1_M6_49212_96060 n1_M7_49212_96060 10.000000
R20279 n1_M6_49212_108060 n1_M7_49212_108060 10.000000
R20280 n1_M6_49212_120060 n1_M7_49212_120060 10.000000
R20281 n1_M6_53308_60 n1_M7_53308_60 10.000000
R20282 n1_M6_53308_12060 n1_M7_53308_12060 10.000000
R20283 n1_M6_53308_24060 n1_M7_53308_24060 10.000000
R20284 n1_M6_53308_36060 n1_M7_53308_36060 10.000000
R20285 n1_M6_53308_48060 n1_M7_53308_48060 10.000000
R20286 n1_M6_53308_60060 n1_M7_53308_60060 10.000000
R20287 n1_M6_53308_72060 n1_M7_53308_72060 10.000000
R20288 n1_M6_53308_84060 n1_M7_53308_84060 10.000000
R20289 n1_M6_53308_96060 n1_M7_53308_96060 10.000000
R20290 n1_M6_53308_108060 n1_M7_53308_108060 10.000000
R20291 n1_M6_53308_120060 n1_M7_53308_120060 10.000000
R20292 n1_M6_57404_60 n1_M7_57404_60 10.000000
R20293 n1_M6_57404_12060 n1_M7_57404_12060 10.000000
R20294 n1_M6_57404_24060 n1_M7_57404_24060 10.000000
R20295 n1_M6_57404_36060 n1_M7_57404_36060 10.000000
R20296 n1_M6_57404_48060 n1_M7_57404_48060 10.000000
R20297 n1_M6_57404_60060 n1_M7_57404_60060 10.000000
R20298 n1_M6_57404_72060 n1_M7_57404_72060 10.000000
R20299 n1_M6_57404_84060 n1_M7_57404_84060 10.000000
R20300 n1_M6_57404_96060 n1_M7_57404_96060 10.000000
R20301 n1_M6_57404_108060 n1_M7_57404_108060 10.000000
R20302 n1_M6_57404_120060 n1_M7_57404_120060 10.000000
R20303 n1_M6_61500_60 n1_M7_61500_60 10.000000
R20304 n1_M6_61500_12060 n1_M7_61500_12060 10.000000
R20305 n1_M6_61500_24060 n1_M7_61500_24060 10.000000
R20306 n1_M6_61500_36060 n1_M7_61500_36060 10.000000
R20307 n1_M6_61500_48060 n1_M7_61500_48060 10.000000
R20308 n1_M6_61500_60060 n1_M7_61500_60060 10.000000
R20309 n1_M6_61500_72060 n1_M7_61500_72060 10.000000
R20310 n1_M6_61500_84060 n1_M7_61500_84060 10.000000
R20311 n1_M6_61500_96060 n1_M7_61500_96060 10.000000
R20312 n1_M6_61500_108060 n1_M7_61500_108060 10.000000
R20313 n1_M6_61500_120060 n1_M7_61500_120060 10.000000
R20314 n1_M6_65596_60 n1_M7_65596_60 10.000000
R20315 n1_M6_65596_12060 n1_M7_65596_12060 10.000000
R20316 n1_M6_65596_24060 n1_M7_65596_24060 10.000000
R20317 n1_M6_65596_36060 n1_M7_65596_36060 10.000000
R20318 n1_M6_65596_48060 n1_M7_65596_48060 10.000000
R20319 n1_M6_65596_60060 n1_M7_65596_60060 10.000000
R20320 n1_M6_65596_72060 n1_M7_65596_72060 10.000000
R20321 n1_M6_65596_84060 n1_M7_65596_84060 10.000000
R20322 n1_M6_65596_96060 n1_M7_65596_96060 10.000000
R20323 n1_M6_65596_108060 n1_M7_65596_108060 10.000000
R20324 n1_M6_65596_120060 n1_M7_65596_120060 10.000000
R20325 n1_M6_69692_60 n1_M7_69692_60 10.000000
R20326 n1_M6_69692_12060 n1_M7_69692_12060 10.000000
R20327 n1_M6_69692_24060 n1_M7_69692_24060 10.000000
R20328 n1_M6_69692_36060 n1_M7_69692_36060 10.000000
R20329 n1_M6_69692_48060 n1_M7_69692_48060 10.000000
R20330 n1_M6_69692_60060 n1_M7_69692_60060 10.000000
R20331 n1_M6_69692_72060 n1_M7_69692_72060 10.000000
R20332 n1_M6_69692_84060 n1_M7_69692_84060 10.000000
R20333 n1_M6_69692_96060 n1_M7_69692_96060 10.000000
R20334 n1_M6_69692_108060 n1_M7_69692_108060 10.000000
R20335 n1_M6_69692_120060 n1_M7_69692_120060 10.000000
R20336 n1_M6_73788_60 n1_M7_73788_60 10.000000
R20337 n1_M6_73788_12060 n1_M7_73788_12060 10.000000
R20338 n1_M6_73788_24060 n1_M7_73788_24060 10.000000
R20339 n1_M6_73788_36060 n1_M7_73788_36060 10.000000
R20340 n1_M6_73788_48060 n1_M7_73788_48060 10.000000
R20341 n1_M6_73788_60060 n1_M7_73788_60060 10.000000
R20342 n1_M6_73788_72060 n1_M7_73788_72060 10.000000
R20343 n1_M6_73788_84060 n1_M7_73788_84060 10.000000
R20344 n1_M6_73788_96060 n1_M7_73788_96060 10.000000
R20345 n1_M6_73788_108060 n1_M7_73788_108060 10.000000
R20346 n1_M6_73788_120060 n1_M7_73788_120060 10.000000
R20347 n1_M6_77884_60 n1_M7_77884_60 10.000000
R20348 n1_M6_77884_12060 n1_M7_77884_12060 10.000000
R20349 n1_M6_77884_24060 n1_M7_77884_24060 10.000000
R20350 n1_M6_77884_36060 n1_M7_77884_36060 10.000000
R20351 n1_M6_77884_48060 n1_M7_77884_48060 10.000000
R20352 n1_M6_77884_60060 n1_M7_77884_60060 10.000000
R20353 n1_M6_77884_72060 n1_M7_77884_72060 10.000000
R20354 n1_M6_77884_84060 n1_M7_77884_84060 10.000000
R20355 n1_M6_77884_96060 n1_M7_77884_96060 10.000000
R20356 n1_M6_77884_108060 n1_M7_77884_108060 10.000000
R20357 n1_M6_77884_120060 n1_M7_77884_120060 10.000000
R20358 n1_M6_81980_60 n1_M7_81980_60 10.000000
R20359 n1_M6_81980_12060 n1_M7_81980_12060 10.000000
R20360 n1_M6_81980_24060 n1_M7_81980_24060 10.000000
R20361 n1_M6_81980_36060 n1_M7_81980_36060 10.000000
R20362 n1_M6_81980_48060 n1_M7_81980_48060 10.000000
R20363 n1_M6_81980_60060 n1_M7_81980_60060 10.000000
R20364 n1_M6_81980_72060 n1_M7_81980_72060 10.000000
R20365 n1_M6_81980_84060 n1_M7_81980_84060 10.000000
R20366 n1_M6_81980_96060 n1_M7_81980_96060 10.000000
R20367 n1_M6_81980_108060 n1_M7_81980_108060 10.000000
R20368 n1_M6_81980_120060 n1_M7_81980_120060 10.000000
R20369 n1_M6_86076_60 n1_M7_86076_60 10.000000
R20370 n1_M6_86076_12060 n1_M7_86076_12060 10.000000
R20371 n1_M6_86076_24060 n1_M7_86076_24060 10.000000
R20372 n1_M6_86076_36060 n1_M7_86076_36060 10.000000
R20373 n1_M6_86076_48060 n1_M7_86076_48060 10.000000
R20374 n1_M6_86076_60060 n1_M7_86076_60060 10.000000
R20375 n1_M6_86076_72060 n1_M7_86076_72060 10.000000
R20376 n1_M6_86076_84060 n1_M7_86076_84060 10.000000
R20377 n1_M6_86076_96060 n1_M7_86076_96060 10.000000
R20378 n1_M6_86076_108060 n1_M7_86076_108060 10.000000
R20379 n1_M6_86076_120060 n1_M7_86076_120060 10.000000
R20380 n1_M6_90172_60 n1_M7_90172_60 10.000000
R20381 n1_M6_90172_12060 n1_M7_90172_12060 10.000000
R20382 n1_M6_90172_24060 n1_M7_90172_24060 10.000000
R20383 n1_M6_90172_36060 n1_M7_90172_36060 10.000000
R20384 n1_M6_90172_48060 n1_M7_90172_48060 10.000000
R20385 n1_M6_90172_60060 n1_M7_90172_60060 10.000000
R20386 n1_M6_90172_72060 n1_M7_90172_72060 10.000000
R20387 n1_M6_90172_84060 n1_M7_90172_84060 10.000000
R20388 n1_M6_90172_96060 n1_M7_90172_96060 10.000000
R20389 n1_M6_90172_108060 n1_M7_90172_108060 10.000000
R20390 n1_M6_90172_120060 n1_M7_90172_120060 10.000000
R20391 n1_M6_94268_60 n1_M7_94268_60 10.000000
R20392 n1_M6_94268_12060 n1_M7_94268_12060 10.000000
R20393 n1_M6_94268_24060 n1_M7_94268_24060 10.000000
R20394 n1_M6_94268_36060 n1_M7_94268_36060 10.000000
R20395 n1_M6_94268_48060 n1_M7_94268_48060 10.000000
R20396 n1_M6_94268_60060 n1_M7_94268_60060 10.000000
R20397 n1_M6_94268_72060 n1_M7_94268_72060 10.000000
R20398 n1_M6_94268_84060 n1_M7_94268_84060 10.000000
R20399 n1_M6_94268_96060 n1_M7_94268_96060 10.000000
R20400 n1_M6_94268_108060 n1_M7_94268_108060 10.000000
R20401 n1_M6_94268_120060 n1_M7_94268_120060 10.000000
R20402 n1_M6_98364_60 n1_M7_98364_60 10.000000
R20403 n1_M6_98364_12060 n1_M7_98364_12060 10.000000
R20404 n1_M6_98364_24060 n1_M7_98364_24060 10.000000
R20405 n1_M6_98364_36060 n1_M7_98364_36060 10.000000
R20406 n1_M6_98364_48060 n1_M7_98364_48060 10.000000
R20407 n1_M6_98364_60060 n1_M7_98364_60060 10.000000
R20408 n1_M6_98364_72060 n1_M7_98364_72060 10.000000
R20409 n1_M6_98364_84060 n1_M7_98364_84060 10.000000
R20410 n1_M6_98364_96060 n1_M7_98364_96060 10.000000
R20411 n1_M6_98364_108060 n1_M7_98364_108060 10.000000
R20412 n1_M6_98364_120060 n1_M7_98364_120060 10.000000
R20413 n1_M6_102460_60 n1_M7_102460_60 10.000000
R20414 n1_M6_102460_12060 n1_M7_102460_12060 10.000000
R20415 n1_M6_102460_24060 n1_M7_102460_24060 10.000000
R20416 n1_M6_102460_36060 n1_M7_102460_36060 10.000000
R20417 n1_M6_102460_48060 n1_M7_102460_48060 10.000000
R20418 n1_M6_102460_60060 n1_M7_102460_60060 10.000000
R20419 n1_M6_102460_72060 n1_M7_102460_72060 10.000000
R20420 n1_M6_102460_84060 n1_M7_102460_84060 10.000000
R20421 n1_M6_102460_96060 n1_M7_102460_96060 10.000000
R20422 n1_M6_102460_108060 n1_M7_102460_108060 10.000000
R20423 n1_M6_102460_120060 n1_M7_102460_120060 10.000000
R20424 n1_M6_106556_60 n1_M7_106556_60 10.000000
R20425 n1_M6_106556_12060 n1_M7_106556_12060 10.000000
R20426 n1_M6_106556_24060 n1_M7_106556_24060 10.000000
R20427 n1_M6_106556_36060 n1_M7_106556_36060 10.000000
R20428 n1_M6_106556_48060 n1_M7_106556_48060 10.000000
R20429 n1_M6_106556_60060 n1_M7_106556_60060 10.000000
R20430 n1_M6_106556_72060 n1_M7_106556_72060 10.000000
R20431 n1_M6_106556_84060 n1_M7_106556_84060 10.000000
R20432 n1_M6_106556_96060 n1_M7_106556_96060 10.000000
R20433 n1_M6_106556_108060 n1_M7_106556_108060 10.000000
R20434 n1_M6_106556_120060 n1_M7_106556_120060 10.000000
R20435 n1_M6_110652_60 n1_M7_110652_60 10.000000
R20436 n1_M6_110652_12060 n1_M7_110652_12060 10.000000
R20437 n1_M6_110652_24060 n1_M7_110652_24060 10.000000
R20438 n1_M6_110652_36060 n1_M7_110652_36060 10.000000
R20439 n1_M6_110652_48060 n1_M7_110652_48060 10.000000
R20440 n1_M6_110652_60060 n1_M7_110652_60060 10.000000
R20441 n1_M6_110652_72060 n1_M7_110652_72060 10.000000
R20442 n1_M6_110652_84060 n1_M7_110652_84060 10.000000
R20443 n1_M6_110652_96060 n1_M7_110652_96060 10.000000
R20444 n1_M6_110652_108060 n1_M7_110652_108060 10.000000
R20445 n1_M6_110652_120060 n1_M7_110652_120060 10.000000
R20446 n1_M6_114748_60 n1_M7_114748_60 10.000000
R20447 n1_M6_114748_12060 n1_M7_114748_12060 10.000000
R20448 n1_M6_114748_24060 n1_M7_114748_24060 10.000000
R20449 n1_M6_114748_36060 n1_M7_114748_36060 10.000000
R20450 n1_M6_114748_48060 n1_M7_114748_48060 10.000000
R20451 n1_M6_114748_60060 n1_M7_114748_60060 10.000000
R20452 n1_M6_114748_72060 n1_M7_114748_72060 10.000000
R20453 n1_M6_114748_84060 n1_M7_114748_84060 10.000000
R20454 n1_M6_114748_96060 n1_M7_114748_96060 10.000000
R20455 n1_M6_114748_108060 n1_M7_114748_108060 10.000000
R20456 n1_M6_114748_120060 n1_M7_114748_120060 10.000000
R20457 n1_M6_118844_60 n1_M7_118844_60 10.000000
R20458 n1_M6_118844_12060 n1_M7_118844_12060 10.000000
R20459 n1_M6_118844_24060 n1_M7_118844_24060 10.000000
R20460 n1_M6_118844_36060 n1_M7_118844_36060 10.000000
R20461 n1_M6_118844_48060 n1_M7_118844_48060 10.000000
R20462 n1_M6_118844_60060 n1_M7_118844_60060 10.000000
R20463 n1_M6_118844_72060 n1_M7_118844_72060 10.000000
R20464 n1_M6_118844_84060 n1_M7_118844_84060 10.000000
R20465 n1_M6_118844_96060 n1_M7_118844_96060 10.000000
R20466 n1_M6_118844_108060 n1_M7_118844_108060 10.000000
R20467 n1_M6_118844_120060 n1_M7_118844_120060 10.000000
R20468 n1_M6_122940_60 n1_M7_122940_60 10.000000
R20469 n1_M6_122940_12060 n1_M7_122940_12060 10.000000
R20470 n1_M6_122940_24060 n1_M7_122940_24060 10.000000
R20471 n1_M6_122940_36060 n1_M7_122940_36060 10.000000
R20472 n1_M6_122940_48060 n1_M7_122940_48060 10.000000
R20473 n1_M6_122940_60060 n1_M7_122940_60060 10.000000
R20474 n1_M6_122940_72060 n1_M7_122940_72060 10.000000
R20475 n1_M6_122940_84060 n1_M7_122940_84060 10.000000
R20476 n1_M6_122940_96060 n1_M7_122940_96060 10.000000
R20477 n1_M6_122940_108060 n1_M7_122940_108060 10.000000
R20478 n1_M6_122940_120060 n1_M7_122940_120060 10.000000
R20479 n1_M6_127036_60 n1_M7_127036_60 10.000000
R20480 n1_M6_127036_12060 n1_M7_127036_12060 10.000000
R20481 n1_M6_127036_24060 n1_M7_127036_24060 10.000000
R20482 n1_M6_127036_36060 n1_M7_127036_36060 10.000000
R20483 n1_M6_127036_48060 n1_M7_127036_48060 10.000000
R20484 n1_M6_127036_60060 n1_M7_127036_60060 10.000000
R20485 n1_M6_127036_72060 n1_M7_127036_72060 10.000000
R20486 n1_M6_127036_84060 n1_M7_127036_84060 10.000000
R20487 n1_M6_127036_96060 n1_M7_127036_96060 10.000000
R20488 n1_M6_127036_108060 n1_M7_127036_108060 10.000000
R20489 n1_M6_127036_120060 n1_M7_127036_120060 10.000000
R20490 n1_M7_60_60 n1_M8_60_60 10.000000
R20491 n1_M7_60_6460 n1_M8_60_6460 10.000000
R20492 n1_M7_60_12860 n1_M8_60_12860 10.000000
R20493 n1_M7_60_19260 n1_M8_60_19260 10.000000
R20494 n1_M7_60_25660 n1_M8_60_25660 10.000000
R20495 n1_M7_60_32060 n1_M8_60_32060 10.000000
R20496 n1_M7_60_38460 n1_M8_60_38460 10.000000
R20497 n1_M7_60_44860 n1_M8_60_44860 10.000000
R20498 n1_M7_60_51260 n1_M8_60_51260 10.000000
R20499 n1_M7_60_57660 n1_M8_60_57660 10.000000
R20500 n1_M7_60_64060 n1_M8_60_64060 10.000000
R20501 n1_M7_60_70460 n1_M8_60_70460 10.000000
R20502 n1_M7_60_76860 n1_M8_60_76860 10.000000
R20503 n1_M7_60_83260 n1_M8_60_83260 10.000000
R20504 n1_M7_60_89660 n1_M8_60_89660 10.000000
R20505 n1_M7_60_96060 n1_M8_60_96060 10.000000
R20506 n1_M7_60_102460 n1_M8_60_102460 10.000000
R20507 n1_M7_60_108860 n1_M8_60_108860 10.000000
R20508 n1_M7_60_115260 n1_M8_60_115260 10.000000
R20509 n1_M7_60_121660 n1_M8_60_121660 10.000000
R20510 n1_M7_60_128060 n1_M8_60_128060 10.000000
R20511 n1_M7_4156_60 n1_M8_4380_60 10.000000
R20512 n1_M7_4156_6460 n1_M8_4380_6460 10.000000
R20513 n1_M7_4156_12860 n1_M8_4380_12860 10.000000
R20514 n1_M7_4156_19260 n1_M8_4380_19260 10.000000
R20515 n1_M7_4156_25660 n1_M8_4380_25660 10.000000
R20516 n1_M7_4156_32060 n1_M8_4380_32060 10.000000
R20517 n1_M7_4156_38460 n1_M8_4380_38460 10.000000
R20518 n1_M7_4156_44860 n1_M8_4380_44860 10.000000
R20519 n1_M7_4156_51260 n1_M8_4380_51260 10.000000
R20520 n1_M7_4156_57660 n1_M8_4380_57660 10.000000
R20521 n1_M7_4156_64060 n1_M8_4380_64060 10.000000
R20522 n1_M7_4156_70460 n1_M8_4380_70460 10.000000
R20523 n1_M7_4156_76860 n1_M8_4380_76860 10.000000
R20524 n1_M7_4156_83260 n1_M8_4380_83260 10.000000
R20525 n1_M7_4156_89660 n1_M8_4380_89660 10.000000
R20526 n1_M7_4156_96060 n1_M8_4380_96060 10.000000
R20527 n1_M7_4156_102460 n1_M8_4380_102460 10.000000
R20528 n1_M7_4156_108860 n1_M8_4380_108860 10.000000
R20529 n1_M7_4156_115260 n1_M8_4380_115260 10.000000
R20530 n1_M7_4156_121660 n1_M8_4380_121660 10.000000
R20531 n1_M7_4156_128060 n1_M8_4380_128060 10.000000
R20532 n1_M7_8252_60 n1_M8_8700_60 10.000000
R20533 n1_M7_8252_6460 n1_M8_8700_6460 10.000000
R20534 n1_M7_8252_12860 n1_M8_8700_12860 10.000000
R20535 n1_M7_8252_19260 n1_M8_8700_19260 10.000000
R20536 n1_M7_8252_25660 n1_M8_8700_25660 10.000000
R20537 n1_M7_8252_32060 n1_M8_8700_32060 10.000000
R20538 n1_M7_8252_38460 n1_M8_8700_38460 10.000000
R20539 n1_M7_8252_44860 n1_M8_8700_44860 10.000000
R20540 n1_M7_8252_51260 n1_M8_8700_51260 10.000000
R20541 n1_M7_8252_57660 n1_M8_8700_57660 10.000000
R20542 n1_M7_8252_64060 n1_M8_8700_64060 10.000000
R20543 n1_M7_8252_70460 n1_M8_8700_70460 10.000000
R20544 n1_M7_8252_76860 n1_M8_8700_76860 10.000000
R20545 n1_M7_8252_83260 n1_M8_8700_83260 10.000000
R20546 n1_M7_8252_89660 n1_M8_8700_89660 10.000000
R20547 n1_M7_8252_96060 n1_M8_8700_96060 10.000000
R20548 n1_M7_8252_102460 n1_M8_8700_102460 10.000000
R20549 n1_M7_8252_108860 n1_M8_8700_108860 10.000000
R20550 n1_M7_8252_115260 n1_M8_8700_115260 10.000000
R20551 n1_M7_8252_121660 n1_M8_8700_121660 10.000000
R20552 n1_M7_8252_128060 n1_M8_8700_128060 10.000000
R20553 n1_M7_12348_60 n1_M8_11940_60 10.000000
R20554 n1_M7_12348_6460 n1_M8_11940_6460 10.000000
R20555 n1_M7_12348_12860 n1_M8_11940_12860 10.000000
R20556 n1_M7_12348_19260 n1_M8_11940_19260 10.000000
R20557 n1_M7_12348_25660 n1_M8_11940_25660 10.000000
R20558 n1_M7_12348_32060 n1_M8_11940_32060 10.000000
R20559 n1_M7_12348_38460 n1_M8_11940_38460 10.000000
R20560 n1_M7_12348_44860 n1_M8_11940_44860 10.000000
R20561 n1_M7_12348_51260 n1_M8_11940_51260 10.000000
R20562 n1_M7_12348_57660 n1_M8_11940_57660 10.000000
R20563 n1_M7_12348_64060 n1_M8_11940_64060 10.000000
R20564 n1_M7_12348_70460 n1_M8_11940_70460 10.000000
R20565 n1_M7_12348_76860 n1_M8_11940_76860 10.000000
R20566 n1_M7_12348_83260 n1_M8_11940_83260 10.000000
R20567 n1_M7_12348_89660 n1_M8_11940_89660 10.000000
R20568 n1_M7_12348_96060 n1_M8_11940_96060 10.000000
R20569 n1_M7_12348_102460 n1_M8_11940_102460 10.000000
R20570 n1_M7_12348_108860 n1_M8_11940_108860 10.000000
R20571 n1_M7_12348_115260 n1_M8_11940_115260 10.000000
R20572 n1_M7_12348_121660 n1_M8_11940_121660 10.000000
R20573 n1_M7_12348_128060 n1_M8_11940_128060 10.000000
R20574 n1_M7_16444_60 n1_M8_16260_60 10.000000
R20575 n1_M7_16444_6460 n1_M8_16260_6460 10.000000
R20576 n1_M7_16444_12860 n1_M8_16260_12860 10.000000
R20577 n1_M7_16444_19260 n1_M8_16260_19260 10.000000
R20578 n1_M7_16444_25660 n1_M8_16260_25660 10.000000
R20579 n1_M7_16444_32060 n1_M8_16260_32060 10.000000
R20580 n1_M7_16444_38460 n1_M8_16260_38460 10.000000
R20581 n1_M7_16444_44860 n1_M8_16260_44860 10.000000
R20582 n1_M7_16444_51260 n1_M8_16260_51260 10.000000
R20583 n1_M7_16444_57660 n1_M8_16260_57660 10.000000
R20584 n1_M7_16444_64060 n1_M8_16260_64060 10.000000
R20585 n1_M7_16444_70460 n1_M8_16260_70460 10.000000
R20586 n1_M7_16444_76860 n1_M8_16260_76860 10.000000
R20587 n1_M7_16444_83260 n1_M8_16260_83260 10.000000
R20588 n1_M7_16444_89660 n1_M8_16260_89660 10.000000
R20589 n1_M7_16444_96060 n1_M8_16260_96060 10.000000
R20590 n1_M7_16444_102460 n1_M8_16260_102460 10.000000
R20591 n1_M7_16444_108860 n1_M8_16260_108860 10.000000
R20592 n1_M7_16444_115260 n1_M8_16260_115260 10.000000
R20593 n1_M7_16444_121660 n1_M8_16260_121660 10.000000
R20594 n1_M7_16444_128060 n1_M8_16260_128060 10.000000
R20595 n1_M7_20540_60 n1_M8_20580_60 10.000000
R20596 n1_M7_20540_6460 n1_M8_20580_6460 10.000000
R20597 n1_M7_20540_12860 n1_M8_20580_12860 10.000000
R20598 n1_M7_20540_19260 n1_M8_20580_19260 10.000000
R20599 n1_M7_20540_25660 n1_M8_20580_25660 10.000000
R20600 n1_M7_20540_32060 n1_M8_20580_32060 10.000000
R20601 n1_M7_20540_38460 n1_M8_20580_38460 10.000000
R20602 n1_M7_20540_44860 n1_M8_20580_44860 10.000000
R20603 n1_M7_20540_51260 n1_M8_20580_51260 10.000000
R20604 n1_M7_20540_57660 n1_M8_20580_57660 10.000000
R20605 n1_M7_20540_64060 n1_M8_20580_64060 10.000000
R20606 n1_M7_20540_70460 n1_M8_20580_70460 10.000000
R20607 n1_M7_20540_76860 n1_M8_20580_76860 10.000000
R20608 n1_M7_20540_83260 n1_M8_20580_83260 10.000000
R20609 n1_M7_20540_89660 n1_M8_20580_89660 10.000000
R20610 n1_M7_20540_96060 n1_M8_20580_96060 10.000000
R20611 n1_M7_20540_102460 n1_M8_20580_102460 10.000000
R20612 n1_M7_20540_108860 n1_M8_20580_108860 10.000000
R20613 n1_M7_20540_115260 n1_M8_20580_115260 10.000000
R20614 n1_M7_20540_121660 n1_M8_20580_121660 10.000000
R20615 n1_M7_20540_128060 n1_M8_20580_128060 10.000000
R20616 n1_M7_24636_60 n1_M8_24900_60 10.000000
R20617 n1_M7_24636_6460 n1_M8_24900_6460 10.000000
R20618 n1_M7_24636_12860 n1_M8_24900_12860 10.000000
R20619 n1_M7_24636_19260 n1_M8_24900_19260 10.000000
R20620 n1_M7_24636_25660 n1_M8_24900_25660 10.000000
R20621 n1_M7_24636_32060 n1_M8_24900_32060 10.000000
R20622 n1_M7_24636_38460 n1_M8_24900_38460 10.000000
R20623 n1_M7_24636_44860 n1_M8_24900_44860 10.000000
R20624 n1_M7_24636_51260 n1_M8_24900_51260 10.000000
R20625 n1_M7_24636_57660 n1_M8_24900_57660 10.000000
R20626 n1_M7_24636_64060 n1_M8_24900_64060 10.000000
R20627 n1_M7_24636_70460 n1_M8_24900_70460 10.000000
R20628 n1_M7_24636_76860 n1_M8_24900_76860 10.000000
R20629 n1_M7_24636_83260 n1_M8_24900_83260 10.000000
R20630 n1_M7_24636_89660 n1_M8_24900_89660 10.000000
R20631 n1_M7_24636_96060 n1_M8_24900_96060 10.000000
R20632 n1_M7_24636_102460 n1_M8_24900_102460 10.000000
R20633 n1_M7_24636_108860 n1_M8_24900_108860 10.000000
R20634 n1_M7_24636_115260 n1_M8_24900_115260 10.000000
R20635 n1_M7_24636_121660 n1_M8_24900_121660 10.000000
R20636 n1_M7_24636_128060 n1_M8_24900_128060 10.000000
R20637 n1_M7_28732_60 n1_M8_29220_60 10.000000
R20638 n1_M7_28732_6460 n1_M8_29220_6460 10.000000
R20639 n1_M7_28732_12860 n1_M8_29220_12860 10.000000
R20640 n1_M7_28732_19260 n1_M8_29220_19260 10.000000
R20641 n1_M7_28732_25660 n1_M8_29220_25660 10.000000
R20642 n1_M7_28732_32060 n1_M8_29220_32060 10.000000
R20643 n1_M7_28732_38460 n1_M8_29220_38460 10.000000
R20644 n1_M7_28732_44860 n1_M8_29220_44860 10.000000
R20645 n1_M7_28732_51260 n1_M8_29220_51260 10.000000
R20646 n1_M7_28732_57660 n1_M8_29220_57660 10.000000
R20647 n1_M7_28732_64060 n1_M8_29220_64060 10.000000
R20648 n1_M7_28732_70460 n1_M8_29220_70460 10.000000
R20649 n1_M7_28732_76860 n1_M8_29220_76860 10.000000
R20650 n1_M7_28732_83260 n1_M8_29220_83260 10.000000
R20651 n1_M7_28732_89660 n1_M8_29220_89660 10.000000
R20652 n1_M7_28732_96060 n1_M8_29220_96060 10.000000
R20653 n1_M7_28732_102460 n1_M8_29220_102460 10.000000
R20654 n1_M7_28732_108860 n1_M8_29220_108860 10.000000
R20655 n1_M7_28732_115260 n1_M8_29220_115260 10.000000
R20656 n1_M7_28732_121660 n1_M8_29220_121660 10.000000
R20657 n1_M7_28732_128060 n1_M8_29220_128060 10.000000
R20658 n1_M7_32828_60 n1_M8_32460_60 10.000000
R20659 n1_M7_32828_6460 n1_M8_32460_6460 10.000000
R20660 n1_M7_32828_12860 n1_M8_32460_12860 10.000000
R20661 n1_M7_32828_19260 n1_M8_32460_19260 10.000000
R20662 n1_M7_32828_25660 n1_M8_32460_25660 10.000000
R20663 n1_M7_32828_32060 n1_M8_32460_32060 10.000000
R20664 n1_M7_32828_38460 n1_M8_32460_38460 10.000000
R20665 n1_M7_32828_44860 n1_M8_32460_44860 10.000000
R20666 n1_M7_32828_51260 n1_M8_32460_51260 10.000000
R20667 n1_M7_32828_57660 n1_M8_32460_57660 10.000000
R20668 n1_M7_32828_64060 n1_M8_32460_64060 10.000000
R20669 n1_M7_32828_70460 n1_M8_32460_70460 10.000000
R20670 n1_M7_32828_76860 n1_M8_32460_76860 10.000000
R20671 n1_M7_32828_83260 n1_M8_32460_83260 10.000000
R20672 n1_M7_32828_89660 n1_M8_32460_89660 10.000000
R20673 n1_M7_32828_96060 n1_M8_32460_96060 10.000000
R20674 n1_M7_32828_102460 n1_M8_32460_102460 10.000000
R20675 n1_M7_32828_108860 n1_M8_32460_108860 10.000000
R20676 n1_M7_32828_115260 n1_M8_32460_115260 10.000000
R20677 n1_M7_32828_121660 n1_M8_32460_121660 10.000000
R20678 n1_M7_32828_128060 n1_M8_32460_128060 10.000000
R20679 n1_M7_36924_60 n1_M8_36780_60 10.000000
R20680 n1_M7_36924_6460 n1_M8_36780_6460 10.000000
R20681 n1_M7_36924_12860 n1_M8_36780_12860 10.000000
R20682 n1_M7_36924_19260 n1_M8_36780_19260 10.000000
R20683 n1_M7_36924_25660 n1_M8_36780_25660 10.000000
R20684 n1_M7_36924_32060 n1_M8_36780_32060 10.000000
R20685 n1_M7_36924_38460 n1_M8_36780_38460 10.000000
R20686 n1_M7_36924_44860 n1_M8_36780_44860 10.000000
R20687 n1_M7_36924_51260 n1_M8_36780_51260 10.000000
R20688 n1_M7_36924_57660 n1_M8_36780_57660 10.000000
R20689 n1_M7_36924_64060 n1_M8_36780_64060 10.000000
R20690 n1_M7_36924_70460 n1_M8_36780_70460 10.000000
R20691 n1_M7_36924_76860 n1_M8_36780_76860 10.000000
R20692 n1_M7_36924_83260 n1_M8_36780_83260 10.000000
R20693 n1_M7_36924_89660 n1_M8_36780_89660 10.000000
R20694 n1_M7_36924_96060 n1_M8_36780_96060 10.000000
R20695 n1_M7_36924_102460 n1_M8_36780_102460 10.000000
R20696 n1_M7_36924_108860 n1_M8_36780_108860 10.000000
R20697 n1_M7_36924_115260 n1_M8_36780_115260 10.000000
R20698 n1_M7_36924_121660 n1_M8_36780_121660 10.000000
R20699 n1_M7_36924_128060 n1_M8_36780_128060 10.000000
R20700 n1_M7_41020_60 n1_M8_41100_60 10.000000
R20701 n1_M7_41020_6460 n1_M8_41100_6460 10.000000
R20702 n1_M7_41020_12860 n1_M8_41100_12860 10.000000
R20703 n1_M7_41020_19260 n1_M8_41100_19260 10.000000
R20704 n1_M7_41020_25660 n1_M8_41100_25660 10.000000
R20705 n1_M7_41020_32060 n1_M8_41100_32060 10.000000
R20706 n1_M7_41020_38460 n1_M8_41100_38460 10.000000
R20707 n1_M7_41020_44860 n1_M8_41100_44860 10.000000
R20708 n1_M7_41020_51260 n1_M8_41100_51260 10.000000
R20709 n1_M7_41020_57660 n1_M8_41100_57660 10.000000
R20710 n1_M7_41020_64060 n1_M8_41100_64060 10.000000
R20711 n1_M7_41020_70460 n1_M8_41100_70460 10.000000
R20712 n1_M7_41020_76860 n1_M8_41100_76860 10.000000
R20713 n1_M7_41020_83260 n1_M8_41100_83260 10.000000
R20714 n1_M7_41020_89660 n1_M8_41100_89660 10.000000
R20715 n1_M7_41020_96060 n1_M8_41100_96060 10.000000
R20716 n1_M7_41020_102460 n1_M8_41100_102460 10.000000
R20717 n1_M7_41020_108860 n1_M8_41100_108860 10.000000
R20718 n1_M7_41020_115260 n1_M8_41100_115260 10.000000
R20719 n1_M7_41020_121660 n1_M8_41100_121660 10.000000
R20720 n1_M7_41020_128060 n1_M8_41100_128060 10.000000
R20721 n1_M7_45116_60 n1_M8_45420_60 10.000000
R20722 n1_M7_45116_6460 n1_M8_45420_6460 10.000000
R20723 n1_M7_45116_12860 n1_M8_45420_12860 10.000000
R20724 n1_M7_45116_19260 n1_M8_45420_19260 10.000000
R20725 n1_M7_45116_25660 n1_M8_45420_25660 10.000000
R20726 n1_M7_45116_32060 n1_M8_45420_32060 10.000000
R20727 n1_M7_45116_38460 n1_M8_45420_38460 10.000000
R20728 n1_M7_45116_44860 n1_M8_45420_44860 10.000000
R20729 n1_M7_45116_51260 n1_M8_45420_51260 10.000000
R20730 n1_M7_45116_57660 n1_M8_45420_57660 10.000000
R20731 n1_M7_45116_64060 n1_M8_45420_64060 10.000000
R20732 n1_M7_45116_70460 n1_M8_45420_70460 10.000000
R20733 n1_M7_45116_76860 n1_M8_45420_76860 10.000000
R20734 n1_M7_45116_83260 n1_M8_45420_83260 10.000000
R20735 n1_M7_45116_89660 n1_M8_45420_89660 10.000000
R20736 n1_M7_45116_96060 n1_M8_45420_96060 10.000000
R20737 n1_M7_45116_102460 n1_M8_45420_102460 10.000000
R20738 n1_M7_45116_108860 n1_M8_45420_108860 10.000000
R20739 n1_M7_45116_115260 n1_M8_45420_115260 10.000000
R20740 n1_M7_45116_121660 n1_M8_45420_121660 10.000000
R20741 n1_M7_45116_128060 n1_M8_45420_128060 10.000000
R20742 n1_M7_49212_60 n1_M8_49740_60 10.000000
R20743 n1_M7_49212_6460 n1_M8_49740_6460 10.000000
R20744 n1_M7_49212_12860 n1_M8_49740_12860 10.000000
R20745 n1_M7_49212_19260 n1_M8_49740_19260 10.000000
R20746 n1_M7_49212_25660 n1_M8_49740_25660 10.000000
R20747 n1_M7_49212_32060 n1_M8_49740_32060 10.000000
R20748 n1_M7_49212_38460 n1_M8_49740_38460 10.000000
R20749 n1_M7_49212_44860 n1_M8_49740_44860 10.000000
R20750 n1_M7_49212_51260 n1_M8_49740_51260 10.000000
R20751 n1_M7_49212_57660 n1_M8_49740_57660 10.000000
R20752 n1_M7_49212_64060 n1_M8_49740_64060 10.000000
R20753 n1_M7_49212_70460 n1_M8_49740_70460 10.000000
R20754 n1_M7_49212_76860 n1_M8_49740_76860 10.000000
R20755 n1_M7_49212_83260 n1_M8_49740_83260 10.000000
R20756 n1_M7_49212_89660 n1_M8_49740_89660 10.000000
R20757 n1_M7_49212_96060 n1_M8_49740_96060 10.000000
R20758 n1_M7_49212_102460 n1_M8_49740_102460 10.000000
R20759 n1_M7_49212_108860 n1_M8_49740_108860 10.000000
R20760 n1_M7_49212_115260 n1_M8_49740_115260 10.000000
R20761 n1_M7_49212_121660 n1_M8_49740_121660 10.000000
R20762 n1_M7_49212_128060 n1_M8_49740_128060 10.000000
R20763 n1_M7_53308_60 n1_M8_52980_60 10.000000
R20764 n1_M7_53308_6460 n1_M8_52980_6460 10.000000
R20765 n1_M7_53308_12860 n1_M8_52980_12860 10.000000
R20766 n1_M7_53308_19260 n1_M8_52980_19260 10.000000
R20767 n1_M7_53308_25660 n1_M8_52980_25660 10.000000
R20768 n1_M7_53308_32060 n1_M8_52980_32060 10.000000
R20769 n1_M7_53308_38460 n1_M8_52980_38460 10.000000
R20770 n1_M7_53308_44860 n1_M8_52980_44860 10.000000
R20771 n1_M7_53308_51260 n1_M8_52980_51260 10.000000
R20772 n1_M7_53308_57660 n1_M8_52980_57660 10.000000
R20773 n1_M7_53308_64060 n1_M8_52980_64060 10.000000
R20774 n1_M7_53308_70460 n1_M8_52980_70460 10.000000
R20775 n1_M7_53308_76860 n1_M8_52980_76860 10.000000
R20776 n1_M7_53308_83260 n1_M8_52980_83260 10.000000
R20777 n1_M7_53308_89660 n1_M8_52980_89660 10.000000
R20778 n1_M7_53308_96060 n1_M8_52980_96060 10.000000
R20779 n1_M7_53308_102460 n1_M8_52980_102460 10.000000
R20780 n1_M7_53308_108860 n1_M8_52980_108860 10.000000
R20781 n1_M7_53308_115260 n1_M8_52980_115260 10.000000
R20782 n1_M7_53308_121660 n1_M8_52980_121660 10.000000
R20783 n1_M7_53308_128060 n1_M8_52980_128060 10.000000
R20784 n1_M7_57404_60 n1_M8_57300_60 10.000000
R20785 n1_M7_57404_6460 n1_M8_57300_6460 10.000000
R20786 n1_M7_57404_12860 n1_M8_57300_12860 10.000000
R20787 n1_M7_57404_19260 n1_M8_57300_19260 10.000000
R20788 n1_M7_57404_25660 n1_M8_57300_25660 10.000000
R20789 n1_M7_57404_32060 n1_M8_57300_32060 10.000000
R20790 n1_M7_57404_38460 n1_M8_57300_38460 10.000000
R20791 n1_M7_57404_44860 n1_M8_57300_44860 10.000000
R20792 n1_M7_57404_51260 n1_M8_57300_51260 10.000000
R20793 n1_M7_57404_57660 n1_M8_57300_57660 10.000000
R20794 n1_M7_57404_64060 n1_M8_57300_64060 10.000000
R20795 n1_M7_57404_70460 n1_M8_57300_70460 10.000000
R20796 n1_M7_57404_76860 n1_M8_57300_76860 10.000000
R20797 n1_M7_57404_83260 n1_M8_57300_83260 10.000000
R20798 n1_M7_57404_89660 n1_M8_57300_89660 10.000000
R20799 n1_M7_57404_96060 n1_M8_57300_96060 10.000000
R20800 n1_M7_57404_102460 n1_M8_57300_102460 10.000000
R20801 n1_M7_57404_108860 n1_M8_57300_108860 10.000000
R20802 n1_M7_57404_115260 n1_M8_57300_115260 10.000000
R20803 n1_M7_57404_121660 n1_M8_57300_121660 10.000000
R20804 n1_M7_57404_128060 n1_M8_57300_128060 10.000000
R20805 n1_M7_61500_60 n1_M8_61620_60 10.000000
R20806 n1_M7_61500_6460 n1_M8_61620_6460 10.000000
R20807 n1_M7_61500_12860 n1_M8_61620_12860 10.000000
R20808 n1_M7_61500_19260 n1_M8_61620_19260 10.000000
R20809 n1_M7_61500_25660 n1_M8_61620_25660 10.000000
R20810 n1_M7_61500_32060 n1_M8_61620_32060 10.000000
R20811 n1_M7_61500_38460 n1_M8_61620_38460 10.000000
R20812 n1_M7_61500_44860 n1_M8_61620_44860 10.000000
R20813 n1_M7_61500_51260 n1_M8_61620_51260 10.000000
R20814 n1_M7_61500_57660 n1_M8_61620_57660 10.000000
R20815 n1_M7_61500_64060 n1_M8_61620_64060 10.000000
R20816 n1_M7_61500_70460 n1_M8_61620_70460 10.000000
R20817 n1_M7_61500_76860 n1_M8_61620_76860 10.000000
R20818 n1_M7_61500_83260 n1_M8_61620_83260 10.000000
R20819 n1_M7_61500_89660 n1_M8_61620_89660 10.000000
R20820 n1_M7_61500_96060 n1_M8_61620_96060 10.000000
R20821 n1_M7_61500_102460 n1_M8_61620_102460 10.000000
R20822 n1_M7_61500_108860 n1_M8_61620_108860 10.000000
R20823 n1_M7_61500_115260 n1_M8_61620_115260 10.000000
R20824 n1_M7_61500_121660 n1_M8_61620_121660 10.000000
R20825 n1_M7_61500_128060 n1_M8_61620_128060 10.000000
R20826 n1_M7_65596_60 n1_M8_65940_60 10.000000
R20827 n1_M7_65596_6460 n1_M8_65940_6460 10.000000
R20828 n1_M7_65596_12860 n1_M8_65940_12860 10.000000
R20829 n1_M7_65596_19260 n1_M8_65940_19260 10.000000
R20830 n1_M7_65596_25660 n1_M8_65940_25660 10.000000
R20831 n1_M7_65596_32060 n1_M8_65940_32060 10.000000
R20832 n1_M7_65596_38460 n1_M8_65940_38460 10.000000
R20833 n1_M7_65596_44860 n1_M8_65940_44860 10.000000
R20834 n1_M7_65596_51260 n1_M8_65940_51260 10.000000
R20835 n1_M7_65596_57660 n1_M8_65940_57660 10.000000
R20836 n1_M7_65596_64060 n1_M8_65940_64060 10.000000
R20837 n1_M7_65596_70460 n1_M8_65940_70460 10.000000
R20838 n1_M7_65596_76860 n1_M8_65940_76860 10.000000
R20839 n1_M7_65596_83260 n1_M8_65940_83260 10.000000
R20840 n1_M7_65596_89660 n1_M8_65940_89660 10.000000
R20841 n1_M7_65596_96060 n1_M8_65940_96060 10.000000
R20842 n1_M7_65596_102460 n1_M8_65940_102460 10.000000
R20843 n1_M7_65596_108860 n1_M8_65940_108860 10.000000
R20844 n1_M7_65596_115260 n1_M8_65940_115260 10.000000
R20845 n1_M7_65596_121660 n1_M8_65940_121660 10.000000
R20846 n1_M7_65596_128060 n1_M8_65940_128060 10.000000
R20847 n1_M7_69692_60 n1_M8_69180_60 10.000000
R20848 n1_M7_69692_6460 n1_M8_69180_6460 10.000000
R20849 n1_M7_69692_12860 n1_M8_69180_12860 10.000000
R20850 n1_M7_69692_19260 n1_M8_69180_19260 10.000000
R20851 n1_M7_69692_25660 n1_M8_69180_25660 10.000000
R20852 n1_M7_69692_32060 n1_M8_69180_32060 10.000000
R20853 n1_M7_69692_38460 n1_M8_69180_38460 10.000000
R20854 n1_M7_69692_44860 n1_M8_69180_44860 10.000000
R20855 n1_M7_69692_51260 n1_M8_69180_51260 10.000000
R20856 n1_M7_69692_57660 n1_M8_69180_57660 10.000000
R20857 n1_M7_69692_64060 n1_M8_69180_64060 10.000000
R20858 n1_M7_69692_70460 n1_M8_69180_70460 10.000000
R20859 n1_M7_69692_76860 n1_M8_69180_76860 10.000000
R20860 n1_M7_69692_83260 n1_M8_69180_83260 10.000000
R20861 n1_M7_69692_89660 n1_M8_69180_89660 10.000000
R20862 n1_M7_69692_96060 n1_M8_69180_96060 10.000000
R20863 n1_M7_69692_102460 n1_M8_69180_102460 10.000000
R20864 n1_M7_69692_108860 n1_M8_69180_108860 10.000000
R20865 n1_M7_69692_115260 n1_M8_69180_115260 10.000000
R20866 n1_M7_69692_121660 n1_M8_69180_121660 10.000000
R20867 n1_M7_69692_128060 n1_M8_69180_128060 10.000000
R20868 n1_M7_73788_60 n1_M8_73500_60 10.000000
R20869 n1_M7_73788_6460 n1_M8_73500_6460 10.000000
R20870 n1_M7_73788_12860 n1_M8_73500_12860 10.000000
R20871 n1_M7_73788_19260 n1_M8_73500_19260 10.000000
R20872 n1_M7_73788_25660 n1_M8_73500_25660 10.000000
R20873 n1_M7_73788_32060 n1_M8_73500_32060 10.000000
R20874 n1_M7_73788_38460 n1_M8_73500_38460 10.000000
R20875 n1_M7_73788_44860 n1_M8_73500_44860 10.000000
R20876 n1_M7_73788_51260 n1_M8_73500_51260 10.000000
R20877 n1_M7_73788_57660 n1_M8_73500_57660 10.000000
R20878 n1_M7_73788_64060 n1_M8_73500_64060 10.000000
R20879 n1_M7_73788_70460 n1_M8_73500_70460 10.000000
R20880 n1_M7_73788_76860 n1_M8_73500_76860 10.000000
R20881 n1_M7_73788_83260 n1_M8_73500_83260 10.000000
R20882 n1_M7_73788_89660 n1_M8_73500_89660 10.000000
R20883 n1_M7_73788_96060 n1_M8_73500_96060 10.000000
R20884 n1_M7_73788_102460 n1_M8_73500_102460 10.000000
R20885 n1_M7_73788_108860 n1_M8_73500_108860 10.000000
R20886 n1_M7_73788_115260 n1_M8_73500_115260 10.000000
R20887 n1_M7_73788_121660 n1_M8_73500_121660 10.000000
R20888 n1_M7_73788_128060 n1_M8_73500_128060 10.000000
R20889 n1_M7_77884_60 n1_M8_77820_60 10.000000
R20890 n1_M7_77884_6460 n1_M8_77820_6460 10.000000
R20891 n1_M7_77884_12860 n1_M8_77820_12860 10.000000
R20892 n1_M7_77884_19260 n1_M8_77820_19260 10.000000
R20893 n1_M7_77884_25660 n1_M8_77820_25660 10.000000
R20894 n1_M7_77884_32060 n1_M8_77820_32060 10.000000
R20895 n1_M7_77884_38460 n1_M8_77820_38460 10.000000
R20896 n1_M7_77884_44860 n1_M8_77820_44860 10.000000
R20897 n1_M7_77884_51260 n1_M8_77820_51260 10.000000
R20898 n1_M7_77884_57660 n1_M8_77820_57660 10.000000
R20899 n1_M7_77884_64060 n1_M8_77820_64060 10.000000
R20900 n1_M7_77884_70460 n1_M8_77820_70460 10.000000
R20901 n1_M7_77884_76860 n1_M8_77820_76860 10.000000
R20902 n1_M7_77884_83260 n1_M8_77820_83260 10.000000
R20903 n1_M7_77884_89660 n1_M8_77820_89660 10.000000
R20904 n1_M7_77884_96060 n1_M8_77820_96060 10.000000
R20905 n1_M7_77884_102460 n1_M8_77820_102460 10.000000
R20906 n1_M7_77884_108860 n1_M8_77820_108860 10.000000
R20907 n1_M7_77884_115260 n1_M8_77820_115260 10.000000
R20908 n1_M7_77884_121660 n1_M8_77820_121660 10.000000
R20909 n1_M7_77884_128060 n1_M8_77820_128060 10.000000
R20910 n1_M7_81980_60 n1_M8_82140_60 10.000000
R20911 n1_M7_81980_6460 n1_M8_82140_6460 10.000000
R20912 n1_M7_81980_12860 n1_M8_82140_12860 10.000000
R20913 n1_M7_81980_19260 n1_M8_82140_19260 10.000000
R20914 n1_M7_81980_25660 n1_M8_82140_25660 10.000000
R20915 n1_M7_81980_32060 n1_M8_82140_32060 10.000000
R20916 n1_M7_81980_38460 n1_M8_82140_38460 10.000000
R20917 n1_M7_81980_44860 n1_M8_82140_44860 10.000000
R20918 n1_M7_81980_51260 n1_M8_82140_51260 10.000000
R20919 n1_M7_81980_57660 n1_M8_82140_57660 10.000000
R20920 n1_M7_81980_64060 n1_M8_82140_64060 10.000000
R20921 n1_M7_81980_70460 n1_M8_82140_70460 10.000000
R20922 n1_M7_81980_76860 n1_M8_82140_76860 10.000000
R20923 n1_M7_81980_83260 n1_M8_82140_83260 10.000000
R20924 n1_M7_81980_89660 n1_M8_82140_89660 10.000000
R20925 n1_M7_81980_96060 n1_M8_82140_96060 10.000000
R20926 n1_M7_81980_102460 n1_M8_82140_102460 10.000000
R20927 n1_M7_81980_108860 n1_M8_82140_108860 10.000000
R20928 n1_M7_81980_115260 n1_M8_82140_115260 10.000000
R20929 n1_M7_81980_121660 n1_M8_82140_121660 10.000000
R20930 n1_M7_81980_128060 n1_M8_82140_128060 10.000000
R20931 n1_M7_86076_60 n1_M8_86460_60 10.000000
R20932 n1_M7_86076_6460 n1_M8_86460_6460 10.000000
R20933 n1_M7_86076_12860 n1_M8_86460_12860 10.000000
R20934 n1_M7_86076_19260 n1_M8_86460_19260 10.000000
R20935 n1_M7_86076_25660 n1_M8_86460_25660 10.000000
R20936 n1_M7_86076_32060 n1_M8_86460_32060 10.000000
R20937 n1_M7_86076_38460 n1_M8_86460_38460 10.000000
R20938 n1_M7_86076_44860 n1_M8_86460_44860 10.000000
R20939 n1_M7_86076_51260 n1_M8_86460_51260 10.000000
R20940 n1_M7_86076_57660 n1_M8_86460_57660 10.000000
R20941 n1_M7_86076_64060 n1_M8_86460_64060 10.000000
R20942 n1_M7_86076_70460 n1_M8_86460_70460 10.000000
R20943 n1_M7_86076_76860 n1_M8_86460_76860 10.000000
R20944 n1_M7_86076_83260 n1_M8_86460_83260 10.000000
R20945 n1_M7_86076_89660 n1_M8_86460_89660 10.000000
R20946 n1_M7_86076_96060 n1_M8_86460_96060 10.000000
R20947 n1_M7_86076_102460 n1_M8_86460_102460 10.000000
R20948 n1_M7_86076_108860 n1_M8_86460_108860 10.000000
R20949 n1_M7_86076_115260 n1_M8_86460_115260 10.000000
R20950 n1_M7_86076_121660 n1_M8_86460_121660 10.000000
R20951 n1_M7_86076_128060 n1_M8_86460_128060 10.000000
R20952 n1_M7_90172_60 n1_M8_89700_60 10.000000
R20953 n1_M7_90172_6460 n1_M8_89700_6460 10.000000
R20954 n1_M7_90172_12860 n1_M8_89700_12860 10.000000
R20955 n1_M7_90172_19260 n1_M8_89700_19260 10.000000
R20956 n1_M7_90172_25660 n1_M8_89700_25660 10.000000
R20957 n1_M7_90172_32060 n1_M8_89700_32060 10.000000
R20958 n1_M7_90172_38460 n1_M8_89700_38460 10.000000
R20959 n1_M7_90172_44860 n1_M8_89700_44860 10.000000
R20960 n1_M7_90172_51260 n1_M8_89700_51260 10.000000
R20961 n1_M7_90172_57660 n1_M8_89700_57660 10.000000
R20962 n1_M7_90172_64060 n1_M8_89700_64060 10.000000
R20963 n1_M7_90172_70460 n1_M8_89700_70460 10.000000
R20964 n1_M7_90172_76860 n1_M8_89700_76860 10.000000
R20965 n1_M7_90172_83260 n1_M8_89700_83260 10.000000
R20966 n1_M7_90172_89660 n1_M8_89700_89660 10.000000
R20967 n1_M7_90172_96060 n1_M8_89700_96060 10.000000
R20968 n1_M7_90172_102460 n1_M8_89700_102460 10.000000
R20969 n1_M7_90172_108860 n1_M8_89700_108860 10.000000
R20970 n1_M7_90172_115260 n1_M8_89700_115260 10.000000
R20971 n1_M7_90172_121660 n1_M8_89700_121660 10.000000
R20972 n1_M7_90172_128060 n1_M8_89700_128060 10.000000
R20973 n1_M7_94268_60 n1_M8_94020_60 10.000000
R20974 n1_M7_94268_6460 n1_M8_94020_6460 10.000000
R20975 n1_M7_94268_12860 n1_M8_94020_12860 10.000000
R20976 n1_M7_94268_19260 n1_M8_94020_19260 10.000000
R20977 n1_M7_94268_25660 n1_M8_94020_25660 10.000000
R20978 n1_M7_94268_32060 n1_M8_94020_32060 10.000000
R20979 n1_M7_94268_38460 n1_M8_94020_38460 10.000000
R20980 n1_M7_94268_44860 n1_M8_94020_44860 10.000000
R20981 n1_M7_94268_51260 n1_M8_94020_51260 10.000000
R20982 n1_M7_94268_57660 n1_M8_94020_57660 10.000000
R20983 n1_M7_94268_64060 n1_M8_94020_64060 10.000000
R20984 n1_M7_94268_70460 n1_M8_94020_70460 10.000000
R20985 n1_M7_94268_76860 n1_M8_94020_76860 10.000000
R20986 n1_M7_94268_83260 n1_M8_94020_83260 10.000000
R20987 n1_M7_94268_89660 n1_M8_94020_89660 10.000000
R20988 n1_M7_94268_96060 n1_M8_94020_96060 10.000000
R20989 n1_M7_94268_102460 n1_M8_94020_102460 10.000000
R20990 n1_M7_94268_108860 n1_M8_94020_108860 10.000000
R20991 n1_M7_94268_115260 n1_M8_94020_115260 10.000000
R20992 n1_M7_94268_121660 n1_M8_94020_121660 10.000000
R20993 n1_M7_94268_128060 n1_M8_94020_128060 10.000000
R20994 n1_M7_98364_60 n1_M8_98340_60 10.000000
R20995 n1_M7_98364_6460 n1_M8_98340_6460 10.000000
R20996 n1_M7_98364_12860 n1_M8_98340_12860 10.000000
R20997 n1_M7_98364_19260 n1_M8_98340_19260 10.000000
R20998 n1_M7_98364_25660 n1_M8_98340_25660 10.000000
R20999 n1_M7_98364_32060 n1_M8_98340_32060 10.000000
R21000 n1_M7_98364_38460 n1_M8_98340_38460 10.000000
R21001 n1_M7_98364_44860 n1_M8_98340_44860 10.000000
R21002 n1_M7_98364_51260 n1_M8_98340_51260 10.000000
R21003 n1_M7_98364_57660 n1_M8_98340_57660 10.000000
R21004 n1_M7_98364_64060 n1_M8_98340_64060 10.000000
R21005 n1_M7_98364_70460 n1_M8_98340_70460 10.000000
R21006 n1_M7_98364_76860 n1_M8_98340_76860 10.000000
R21007 n1_M7_98364_83260 n1_M8_98340_83260 10.000000
R21008 n1_M7_98364_89660 n1_M8_98340_89660 10.000000
R21009 n1_M7_98364_96060 n1_M8_98340_96060 10.000000
R21010 n1_M7_98364_102460 n1_M8_98340_102460 10.000000
R21011 n1_M7_98364_108860 n1_M8_98340_108860 10.000000
R21012 n1_M7_98364_115260 n1_M8_98340_115260 10.000000
R21013 n1_M7_98364_121660 n1_M8_98340_121660 10.000000
R21014 n1_M7_98364_128060 n1_M8_98340_128060 10.000000
R21015 n1_M7_102460_60 n1_M8_102660_60 10.000000
R21016 n1_M7_102460_6460 n1_M8_102660_6460 10.000000
R21017 n1_M7_102460_12860 n1_M8_102660_12860 10.000000
R21018 n1_M7_102460_19260 n1_M8_102660_19260 10.000000
R21019 n1_M7_102460_25660 n1_M8_102660_25660 10.000000
R21020 n1_M7_102460_32060 n1_M8_102660_32060 10.000000
R21021 n1_M7_102460_38460 n1_M8_102660_38460 10.000000
R21022 n1_M7_102460_44860 n1_M8_102660_44860 10.000000
R21023 n1_M7_102460_51260 n1_M8_102660_51260 10.000000
R21024 n1_M7_102460_57660 n1_M8_102660_57660 10.000000
R21025 n1_M7_102460_64060 n1_M8_102660_64060 10.000000
R21026 n1_M7_102460_70460 n1_M8_102660_70460 10.000000
R21027 n1_M7_102460_76860 n1_M8_102660_76860 10.000000
R21028 n1_M7_102460_83260 n1_M8_102660_83260 10.000000
R21029 n1_M7_102460_89660 n1_M8_102660_89660 10.000000
R21030 n1_M7_102460_96060 n1_M8_102660_96060 10.000000
R21031 n1_M7_102460_102460 n1_M8_102660_102460 10.000000
R21032 n1_M7_102460_108860 n1_M8_102660_108860 10.000000
R21033 n1_M7_102460_115260 n1_M8_102660_115260 10.000000
R21034 n1_M7_102460_121660 n1_M8_102660_121660 10.000000
R21035 n1_M7_102460_128060 n1_M8_102660_128060 10.000000
R21036 n1_M7_106556_60 n1_M8_106980_60 10.000000
R21037 n1_M7_106556_6460 n1_M8_106980_6460 10.000000
R21038 n1_M7_106556_12860 n1_M8_106980_12860 10.000000
R21039 n1_M7_106556_19260 n1_M8_106980_19260 10.000000
R21040 n1_M7_106556_25660 n1_M8_106980_25660 10.000000
R21041 n1_M7_106556_32060 n1_M8_106980_32060 10.000000
R21042 n1_M7_106556_38460 n1_M8_106980_38460 10.000000
R21043 n1_M7_106556_44860 n1_M8_106980_44860 10.000000
R21044 n1_M7_106556_51260 n1_M8_106980_51260 10.000000
R21045 n1_M7_106556_57660 n1_M8_106980_57660 10.000000
R21046 n1_M7_106556_64060 n1_M8_106980_64060 10.000000
R21047 n1_M7_106556_70460 n1_M8_106980_70460 10.000000
R21048 n1_M7_106556_76860 n1_M8_106980_76860 10.000000
R21049 n1_M7_106556_83260 n1_M8_106980_83260 10.000000
R21050 n1_M7_106556_89660 n1_M8_106980_89660 10.000000
R21051 n1_M7_106556_96060 n1_M8_106980_96060 10.000000
R21052 n1_M7_106556_102460 n1_M8_106980_102460 10.000000
R21053 n1_M7_106556_108860 n1_M8_106980_108860 10.000000
R21054 n1_M7_106556_115260 n1_M8_106980_115260 10.000000
R21055 n1_M7_106556_121660 n1_M8_106980_121660 10.000000
R21056 n1_M7_106556_128060 n1_M8_106980_128060 10.000000
R21057 n1_M7_110652_60 n1_M8_110220_60 10.000000
R21058 n1_M7_110652_6460 n1_M8_110220_6460 10.000000
R21059 n1_M7_110652_12860 n1_M8_110220_12860 10.000000
R21060 n1_M7_110652_19260 n1_M8_110220_19260 10.000000
R21061 n1_M7_110652_25660 n1_M8_110220_25660 10.000000
R21062 n1_M7_110652_32060 n1_M8_110220_32060 10.000000
R21063 n1_M7_110652_38460 n1_M8_110220_38460 10.000000
R21064 n1_M7_110652_44860 n1_M8_110220_44860 10.000000
R21065 n1_M7_110652_51260 n1_M8_110220_51260 10.000000
R21066 n1_M7_110652_57660 n1_M8_110220_57660 10.000000
R21067 n1_M7_110652_64060 n1_M8_110220_64060 10.000000
R21068 n1_M7_110652_70460 n1_M8_110220_70460 10.000000
R21069 n1_M7_110652_76860 n1_M8_110220_76860 10.000000
R21070 n1_M7_110652_83260 n1_M8_110220_83260 10.000000
R21071 n1_M7_110652_89660 n1_M8_110220_89660 10.000000
R21072 n1_M7_110652_96060 n1_M8_110220_96060 10.000000
R21073 n1_M7_110652_102460 n1_M8_110220_102460 10.000000
R21074 n1_M7_110652_108860 n1_M8_110220_108860 10.000000
R21075 n1_M7_110652_115260 n1_M8_110220_115260 10.000000
R21076 n1_M7_110652_121660 n1_M8_110220_121660 10.000000
R21077 n1_M7_110652_128060 n1_M8_110220_128060 10.000000
R21078 n1_M7_114748_60 n1_M8_114540_60 10.000000
R21079 n1_M7_114748_6460 n1_M8_114540_6460 10.000000
R21080 n1_M7_114748_12860 n1_M8_114540_12860 10.000000
R21081 n1_M7_114748_19260 n1_M8_114540_19260 10.000000
R21082 n1_M7_114748_25660 n1_M8_114540_25660 10.000000
R21083 n1_M7_114748_32060 n1_M8_114540_32060 10.000000
R21084 n1_M7_114748_38460 n1_M8_114540_38460 10.000000
R21085 n1_M7_114748_44860 n1_M8_114540_44860 10.000000
R21086 n1_M7_114748_51260 n1_M8_114540_51260 10.000000
R21087 n1_M7_114748_57660 n1_M8_114540_57660 10.000000
R21088 n1_M7_114748_64060 n1_M8_114540_64060 10.000000
R21089 n1_M7_114748_70460 n1_M8_114540_70460 10.000000
R21090 n1_M7_114748_76860 n1_M8_114540_76860 10.000000
R21091 n1_M7_114748_83260 n1_M8_114540_83260 10.000000
R21092 n1_M7_114748_89660 n1_M8_114540_89660 10.000000
R21093 n1_M7_114748_96060 n1_M8_114540_96060 10.000000
R21094 n1_M7_114748_102460 n1_M8_114540_102460 10.000000
R21095 n1_M7_114748_108860 n1_M8_114540_108860 10.000000
R21096 n1_M7_114748_115260 n1_M8_114540_115260 10.000000
R21097 n1_M7_114748_121660 n1_M8_114540_121660 10.000000
R21098 n1_M7_114748_128060 n1_M8_114540_128060 10.000000
R21099 n1_M7_118844_60 n1_M8_118860_60 10.000000
R21100 n1_M7_118844_6460 n1_M8_118860_6460 10.000000
R21101 n1_M7_118844_12860 n1_M8_118860_12860 10.000000
R21102 n1_M7_118844_19260 n1_M8_118860_19260 10.000000
R21103 n1_M7_118844_25660 n1_M8_118860_25660 10.000000
R21104 n1_M7_118844_32060 n1_M8_118860_32060 10.000000
R21105 n1_M7_118844_38460 n1_M8_118860_38460 10.000000
R21106 n1_M7_118844_44860 n1_M8_118860_44860 10.000000
R21107 n1_M7_118844_51260 n1_M8_118860_51260 10.000000
R21108 n1_M7_118844_57660 n1_M8_118860_57660 10.000000
R21109 n1_M7_118844_64060 n1_M8_118860_64060 10.000000
R21110 n1_M7_118844_70460 n1_M8_118860_70460 10.000000
R21111 n1_M7_118844_76860 n1_M8_118860_76860 10.000000
R21112 n1_M7_118844_83260 n1_M8_118860_83260 10.000000
R21113 n1_M7_118844_89660 n1_M8_118860_89660 10.000000
R21114 n1_M7_118844_96060 n1_M8_118860_96060 10.000000
R21115 n1_M7_118844_102460 n1_M8_118860_102460 10.000000
R21116 n1_M7_118844_108860 n1_M8_118860_108860 10.000000
R21117 n1_M7_118844_115260 n1_M8_118860_115260 10.000000
R21118 n1_M7_118844_121660 n1_M8_118860_121660 10.000000
R21119 n1_M7_118844_128060 n1_M8_118860_128060 10.000000
R21120 n1_M7_122940_60 n1_M8_123180_60 10.000000
R21121 n1_M7_122940_6460 n1_M8_123180_6460 10.000000
R21122 n1_M7_122940_12860 n1_M8_123180_12860 10.000000
R21123 n1_M7_122940_19260 n1_M8_123180_19260 10.000000
R21124 n1_M7_122940_25660 n1_M8_123180_25660 10.000000
R21125 n1_M7_122940_32060 n1_M8_123180_32060 10.000000
R21126 n1_M7_122940_38460 n1_M8_123180_38460 10.000000
R21127 n1_M7_122940_44860 n1_M8_123180_44860 10.000000
R21128 n1_M7_122940_51260 n1_M8_123180_51260 10.000000
R21129 n1_M7_122940_57660 n1_M8_123180_57660 10.000000
R21130 n1_M7_122940_64060 n1_M8_123180_64060 10.000000
R21131 n1_M7_122940_70460 n1_M8_123180_70460 10.000000
R21132 n1_M7_122940_76860 n1_M8_123180_76860 10.000000
R21133 n1_M7_122940_83260 n1_M8_123180_83260 10.000000
R21134 n1_M7_122940_89660 n1_M8_123180_89660 10.000000
R21135 n1_M7_122940_96060 n1_M8_123180_96060 10.000000
R21136 n1_M7_122940_102460 n1_M8_123180_102460 10.000000
R21137 n1_M7_122940_108860 n1_M8_123180_108860 10.000000
R21138 n1_M7_122940_115260 n1_M8_123180_115260 10.000000
R21139 n1_M7_122940_121660 n1_M8_123180_121660 10.000000
R21140 n1_M7_122940_128060 n1_M8_123180_128060 10.000000
R21141 n1_M7_127036_60 n1_M8_127500_60 10.000000
R21142 n1_M7_127036_6460 n1_M8_127500_6460 10.000000
R21143 n1_M7_127036_12860 n1_M8_127500_12860 10.000000
R21144 n1_M7_127036_19260 n1_M8_127500_19260 10.000000
R21145 n1_M7_127036_25660 n1_M8_127500_25660 10.000000
R21146 n1_M7_127036_32060 n1_M8_127500_32060 10.000000
R21147 n1_M7_127036_38460 n1_M8_127500_38460 10.000000
R21148 n1_M7_127036_44860 n1_M8_127500_44860 10.000000
R21149 n1_M7_127036_51260 n1_M8_127500_51260 10.000000
R21150 n1_M7_127036_57660 n1_M8_127500_57660 10.000000
R21151 n1_M7_127036_64060 n1_M8_127500_64060 10.000000
R21152 n1_M7_127036_70460 n1_M8_127500_70460 10.000000
R21153 n1_M7_127036_76860 n1_M8_127500_76860 10.000000
R21154 n1_M7_127036_83260 n1_M8_127500_83260 10.000000
R21155 n1_M7_127036_89660 n1_M8_127500_89660 10.000000
R21156 n1_M7_127036_96060 n1_M8_127500_96060 10.000000
R21157 n1_M7_127036_102460 n1_M8_127500_102460 10.000000
R21158 n1_M7_127036_108860 n1_M8_127500_108860 10.000000
R21159 n1_M7_127036_115260 n1_M8_127500_115260 10.000000
R21160 n1_M7_127036_121660 n1_M8_127500_121660 10.000000
R21161 n1_M7_127036_128060 n1_M8_127500_128060 10.000000
V0 n1_M8_89700_32060 0 0.700000
I0 n1_M2_60_60 0 2.830359e-06
I1 n1_M2_60_2220 0 2.590961e-06
I2 n1_M2_60_4380 0 2.627719e-06
I3 n1_M2_60_5460 0 2.592579e-06
I4 n1_M2_60_7620 0 2.655797e-06
I5 n1_M2_60_9780 0 2.662538e-06
I6 n1_M2_60_11940 0 2.662539e-06
I7 n1_M2_60_14100 0 2.662851e-06
I8 n1_M2_60_16260 0 2.617256e-06
I9 n1_M2_60_18420 0 2.611769e-06
I10 n1_M2_60_19500 0 2.593789e-06
I11 n1_M2_60_21660 0 2.551214e-06
I12 n1_M2_60_23820 0 2.655913e-06
I13 n1_M2_60_25980 0 2.656254e-06
I14 n1_M2_60_28140 0 2.607705e-06
I15 n1_M2_60_30300 0 2.607572e-06
I16 n1_M2_60_32460 0 2.565710e-06
I17 n1_M2_60_33540 0 2.615100e-06
I18 n1_M2_60_35700 0 2.618382e-06
I19 n1_M2_60_37860 0 2.599874e-06
I20 n1_M2_60_40020 0 2.605603e-06
I21 n1_M2_60_42180 0 2.662102e-06
I22 n1_M2_60_44340 0 2.562319e-06
I23 n1_M2_60_46500 0 2.545392e-06
I24 n1_M2_60_47580 0 2.602912e-06
I25 n1_M2_60_49740 0 2.592278e-06
I26 n1_M2_60_51900 0 2.609941e-06
I27 n1_M2_60_54060 0 2.646239e-06
I28 n1_M2_60_56220 0 2.664629e-06
I29 n1_M2_60_58380 0 2.601609e-06
I30 n1_M2_60_59460 0 2.670834e-06
I31 n1_M2_60_61620 0 2.729401e-06
I32 n1_M2_60_63780 0 2.739786e-06
I33 n1_M2_60_65940 0 2.662604e-06
I34 n1_M2_60_68100 0 2.704991e-06
I35 n1_M2_60_70260 0 2.764203e-06
I36 n1_M2_60_72420 0 2.712776e-06
I37 n1_M2_60_73500 0 2.569286e-06
I38 n1_M2_60_75660 0 2.569446e-06
I39 n1_M2_60_77820 0 2.704550e-06
I40 n1_M2_60_79980 0 2.822631e-06
I41 n1_M2_60_82140 0 2.792013e-06
I42 n1_M2_60_84300 0 2.785995e-06
I43 n1_M2_60_86460 0 2.725613e-06
I44 n1_M2_60_87540 0 2.781349e-06
I45 n1_M2_60_89700 0 2.622921e-06
I46 n1_M2_60_91860 0 2.663408e-06
I47 n1_M2_60_94020 0 2.719466e-06
I48 n1_M2_60_96180 0 2.717862e-06
I49 n1_M2_60_98340 0 2.652661e-06
I50 n1_M2_60_100500 0 2.544609e-06
I51 n1_M2_60_101580 0 2.548848e-06
I52 n1_M2_60_103740 0 2.631554e-06
I53 n1_M2_60_105900 0 2.539641e-06
I54 n1_M2_60_108060 0 2.539880e-06
I55 n1_M2_60_110220 0 2.534027e-06
I56 n1_M2_60_112380 0 2.474031e-06
I57 n1_M2_60_113460 0 2.375073e-06
I58 n1_M2_60_115620 0 2.370617e-06
I59 n1_M2_60_117780 0 2.374158e-06
I60 n1_M2_60_119940 0 2.466409e-06
I61 n1_M2_60_122100 0 2.597636e-06
I62 n1_M2_60_124260 0 2.572690e-06
I63 n1_M2_60_126420 0 2.635097e-06
I64 n1_M2_60_127500 0 2.717937e-06
I65 n1_M2_2220_60 0 2.830364e-06
I66 n1_M2_2220_2220 0 2.616115e-06
I67 n1_M2_2220_4380 0 2.634460e-06
I68 n1_M2_2220_5460 0 2.644454e-06
I69 n1_M2_2220_7620 0 2.664352e-06
I70 n1_M2_2220_9780 0 2.667715e-06
I71 n1_M2_2220_11940 0 2.667723e-06
I72 n1_M2_2220_14100 0 2.702943e-06
I73 n1_M2_2220_16260 0 2.779991e-06
I74 n1_M2_2220_18420 0 2.750263e-06
I75 n1_M2_2220_19500 0 2.662709e-06
I76 n1_M2_2220_21660 0 2.660965e-06
I77 n1_M2_2220_23820 0 2.628939e-06
I78 n1_M2_2220_25980 0 2.670276e-06
I79 n1_M2_2220_28140 0 2.718039e-06
I80 n1_M2_2220_30300 0 2.722445e-06
I81 n1_M2_2220_32460 0 2.679407e-06
I82 n1_M2_2220_33540 0 2.713788e-06
I83 n1_M2_2220_35700 0 2.676217e-06
I84 n1_M2_2220_37860 0 2.629970e-06
I85 n1_M2_2220_40020 0 2.732049e-06
I86 n1_M2_2220_42180 0 2.721596e-06
I87 n1_M2_2220_44340 0 2.572729e-06
I88 n1_M2_2220_46500 0 2.601727e-06
I89 n1_M2_2220_47580 0 2.582210e-06
I90 n1_M2_2220_49740 0 2.689365e-06
I91 n1_M2_2220_51900 0 2.697032e-06
I92 n1_M2_2220_54060 0 2.767296e-06
I93 n1_M2_2220_56220 0 2.838347e-06
I94 n1_M2_2220_58380 0 2.824364e-06
I95 n1_M2_2220_59460 0 2.849516e-06
I96 n1_M2_2220_61620 0 2.808346e-06
I97 n1_M2_2220_63780 0 2.955016e-06
I98 n1_M2_2220_65940 0 2.961060e-06
I99 n1_M2_2220_68100 0 2.925922e-06
I100 n1_M2_2220_70260 0 2.959965e-06
I101 n1_M2_2220_72420 0 2.845260e-06
I102 n1_M2_2220_73500 0 2.813100e-06
I103 n1_M2_2220_75660 0 2.834542e-06
I104 n1_M2_2220_77820 0 2.743720e-06
I105 n1_M2_2220_79980 0 2.760397e-06
I106 n1_M2_2220_82140 0 2.800403e-06
I107 n1_M2_2220_84300 0 2.750462e-06
I108 n1_M2_2220_86460 0 2.750848e-06
I109 n1_M2_2220_87540 0 2.743777e-06
I110 n1_M2_2220_89700 0 2.779509e-06
I111 n1_M2_2220_91860 0 2.719427e-06
I112 n1_M2_2220_94020 0 2.662030e-06
I113 n1_M2_2220_96180 0 2.561698e-06
I114 n1_M2_2220_98340 0 2.505949e-06
I115 n1_M2_2220_100500 0 2.542313e-06
I116 n1_M2_2220_101580 0 2.549668e-06
I117 n1_M2_2220_103740 0 2.562873e-06
I118 n1_M2_2220_105900 0 2.596150e-06
I119 n1_M2_2220_108060 0 2.463512e-06
I120 n1_M2_2220_110220 0 2.440257e-06
I121 n1_M2_2220_112380 0 2.439834e-06
I122 n1_M2_2220_113460 0 2.443459e-06
I123 n1_M2_2220_115620 0 2.377405e-06
I124 n1_M2_2220_117780 0 2.375808e-06
I125 n1_M2_2220_119940 0 2.386594e-06
I126 n1_M2_2220_122100 0 2.491095e-06
I127 n1_M2_2220_124260 0 2.492237e-06
I128 n1_M2_2220_126420 0 2.529201e-06
I129 n1_M2_2220_127500 0 2.611054e-06
I130 n1_M2_4380_60 0 2.832567e-06
I131 n1_M2_4380_2220 0 2.683905e-06
I132 n1_M2_4380_4380 0 2.714549e-06
I133 n1_M2_4380_5460 0 2.777899e-06
I134 n1_M2_4380_7620 0 2.815959e-06
I135 n1_M2_4380_9780 0 2.795616e-06
I136 n1_M2_4380_11940 0 2.810222e-06
I137 n1_M2_4380_14100 0 2.875454e-06
I138 n1_M2_4380_16260 0 2.973649e-06
I139 n1_M2_4380_18420 0 2.933888e-06
I140 n1_M2_4380_19500 0 2.807824e-06
I141 n1_M2_4380_21660 0 2.895447e-06
I142 n1_M2_4380_23820 0 2.913575e-06
I143 n1_M2_4380_25980 0 2.958278e-06
I144 n1_M2_4380_28140 0 2.971552e-06
I145 n1_M2_4380_30300 0 2.971290e-06
I146 n1_M2_4380_32460 0 3.035088e-06
I147 n1_M2_4380_33540 0 2.960710e-06
I148 n1_M2_4380_35700 0 2.913188e-06
I149 n1_M2_4380_37860 0 3.054312e-06
I150 n1_M2_4380_40020 0 3.130769e-06
I151 n1_M2_4380_42180 0 3.158819e-06
I152 n1_M2_4380_44340 0 3.065839e-06
I153 n1_M2_4380_46500 0 3.001530e-06
I154 n1_M2_4380_47580 0 2.936062e-06
I155 n1_M2_4380_49740 0 3.346552e-06
I156 n1_M2_4380_51900 0 3.364666e-06
I157 n1_M2_4380_54060 0 3.171838e-06
I158 n1_M2_4380_56220 0 3.203659e-06
I159 n1_M2_4380_58380 0 3.342022e-06
I160 n1_M2_4380_59460 0 4.408865e-06
I161 n1_M2_4380_61620 0 4.581835e-06
I162 n1_M2_4380_63780 0 3.940849e-06
I163 n1_M2_4380_65940 0 4.267248e-06
I164 n1_M2_4380_68100 0 5.336777e-06
I165 n1_M2_4380_70260 0 5.851999e-06
I166 n1_M2_4380_72420 0 5.486811e-06
I167 n1_M2_4380_73500 0 4.612508e-06
I168 n1_M2_4380_75660 0 3.516175e-06
I169 n1_M2_4380_77820 0 3.446735e-06
I170 n1_M2_4380_79980 0 3.853353e-06
I171 n1_M2_4380_82140 0 4.294793e-06
I172 n1_M2_4380_84300 0 4.379652e-06
I173 n1_M2_4380_86460 0 5.334072e-06
I174 n1_M2_4380_87540 0 3.721548e-06
I175 n1_M2_4380_89700 0 3.564727e-06
I176 n1_M2_4380_91860 0 3.471999e-06
I177 n1_M2_4380_94020 0 3.430552e-06
I178 n1_M2_4380_96180 0 3.485380e-06
I179 n1_M2_4380_98340 0 3.158120e-06
I180 n1_M2_4380_100500 0 2.935604e-06
I181 n1_M2_4380_101580 0 2.850986e-06
I182 n1_M2_4380_103740 0 2.930509e-06
I183 n1_M2_4380_105900 0 2.747321e-06
I184 n1_M2_4380_108060 0 2.741926e-06
I185 n1_M2_4380_110220 0 2.766086e-06
I186 n1_M2_4380_112380 0 2.763078e-06
I187 n1_M2_4380_113460 0 2.652404e-06
I188 n1_M2_4380_115620 0 2.542405e-06
I189 n1_M2_4380_117780 0 2.504659e-06
I190 n1_M2_4380_119940 0 2.487809e-06
I191 n1_M2_4380_122100 0 2.493735e-06
I192 n1_M2_4380_124260 0 2.491543e-06
I193 n1_M2_4380_126420 0 2.522827e-06
I194 n1_M2_4380_127500 0 2.609167e-06
I195 n1_M2_5460_60 0 2.812519e-06
I196 n1_M2_5460_2220 0 2.650456e-06
I197 n1_M2_5460_4380 0 2.821034e-06
I198 n1_M2_5460_5460 0 2.899407e-06
I199 n1_M2_5460_7620 0 2.937259e-06
I200 n1_M2_5460_9780 0 3.000940e-06
I201 n1_M2_5460_11940 0 2.979947e-06
I202 n1_M2_5460_14100 0 2.971454e-06
I203 n1_M2_5460_16260 0 3.118736e-06
I204 n1_M2_5460_18420 0 3.233874e-06
I205 n1_M2_5460_19500 0 3.454035e-06
I206 n1_M2_5460_21660 0 4.038396e-06
I207 n1_M2_5460_23820 0 4.277731e-06
I208 n1_M2_5460_25980 0 4.834258e-06
I209 n1_M2_5460_28140 0 5.473765e-06
I210 n1_M2_5460_30300 0 6.035353e-06
I211 n1_M2_5460_32460 0 6.343709e-06
I212 n1_M2_5460_33540 0 5.876595e-06
I213 n1_M2_5460_35700 0 6.535893e-06
I214 n1_M2_5460_37860 0 9.074332e-06
I215 n1_M2_5460_40020 0 1.120600e-05
I216 n1_M2_5460_42180 0 1.112758e-05
I217 n1_M2_5460_44340 0 9.220672e-06
I218 n1_M2_5460_46500 0 6.177393e-06
I219 n1_M2_5460_47580 0 6.219436e-06
I220 n1_M2_5460_49740 0 1.036363e-05
I221 n1_M2_5460_51900 0 1.082369e-05
I222 n1_M2_5460_54060 0 7.146031e-06
I223 n1_M2_5460_56220 0 5.802900e-06
I224 n1_M2_5460_58380 0 7.331811e-06
I225 n1_M2_5460_59460 0 1.337251e-05
I226 n1_M2_5460_61620 0 1.578229e-05
I227 n1_M2_5460_63780 0 1.382209e-05
I228 n1_M2_5460_65940 0 1.411628e-05
I229 n1_M2_5460_68100 0 1.612941e-05
I230 n1_M2_5460_70260 0 1.645253e-05
I231 n1_M2_5460_72420 0 1.599493e-05
I232 n1_M2_5460_73500 0 1.332979e-05
I233 n1_M2_5460_75660 0 8.356073e-06
I234 n1_M2_5460_77820 0 7.692516e-06
I235 n1_M2_5460_79980 0 9.162892e-06
I236 n1_M2_5460_82140 0 1.028795e-05
I237 n1_M2_5460_84300 0 1.091788e-05
I238 n1_M2_5460_86460 0 1.367550e-05
I239 n1_M2_5460_87540 0 1.043636e-05
I240 n1_M2_5460_89700 0 1.012137e-05
I241 n1_M2_5460_91860 0 1.016501e-05
I242 n1_M2_5460_94020 0 1.056648e-05
I243 n1_M2_5460_96180 0 1.082204e-05
I244 n1_M2_5460_98340 0 9.770033e-06
I245 n1_M2_5460_100500 0 6.065511e-06
I246 n1_M2_5460_101580 0 4.252039e-06
I247 n1_M2_5460_103740 0 4.270174e-06
I248 n1_M2_5460_105900 0 5.111112e-06
I249 n1_M2_5460_108060 0 5.214660e-06
I250 n1_M2_5460_110220 0 4.081530e-06
I251 n1_M2_5460_112380 0 3.096982e-06
I252 n1_M2_5460_113460 0 2.886115e-06
I253 n1_M2_5460_115620 0 2.743157e-06
I254 n1_M2_5460_117780 0 2.655082e-06
I255 n1_M2_5460_119940 0 2.633700e-06
I256 n1_M2_5460_122100 0 2.604102e-06
I257 n1_M2_5460_124260 0 2.566493e-06
I258 n1_M2_5460_126420 0 2.605526e-06
I259 n1_M2_5460_127500 0 2.714047e-06
I260 n1_M2_7620_60 0 2.863247e-06
I261 n1_M2_7620_2220 0 2.731505e-06
I262 n1_M2_7620_4380 0 2.892700e-06
I263 n1_M2_7620_5460 0 3.039889e-06
I264 n1_M2_7620_7620 0 3.028547e-06
I265 n1_M2_7620_9780 0 3.221695e-06
I266 n1_M2_7620_11940 0 3.159477e-06
I267 n1_M2_7620_14100 0 4.170576e-06
I268 n1_M2_7620_16260 0 6.801450e-06
I269 n1_M2_7620_18420 0 9.881396e-06
I270 n1_M2_7620_19500 0 1.227274e-05
I271 n1_M2_7620_21660 0 1.475129e-05
I272 n1_M2_7620_23820 0 1.495016e-05
I273 n1_M2_7620_25980 0 1.715838e-05
I274 n1_M2_7620_28140 0 1.794279e-05
I275 n1_M2_7620_30300 0 1.767574e-05
I276 n1_M2_7620_32460 0 1.735505e-05
I277 n1_M2_7620_33540 0 1.668467e-05
I278 n1_M2_7620_35700 0 1.542522e-05
I279 n1_M2_7620_37860 0 2.017874e-05
I280 n1_M2_7620_40020 0 2.100388e-05
I281 n1_M2_7620_42180 0 2.113843e-05
I282 n1_M2_7620_44340 0 1.689324e-05
I283 n1_M2_7620_46500 0 1.290090e-05
I284 n1_M2_7620_47580 0 1.162487e-05
I285 n1_M2_7620_49740 0 1.978610e-05
I286 n1_M2_7620_51900 0 2.034991e-05
I287 n1_M2_7620_54060 0 1.562453e-05
I288 n1_M2_7620_56220 0 1.098056e-05
I289 n1_M2_7620_58380 0 1.597668e-05
I290 n1_M2_7620_59460 0 2.016550e-05
I291 n1_M2_7620_61620 0 2.279511e-05
I292 n1_M2_7620_63780 0 2.190654e-05
I293 n1_M2_7620_65940 0 2.023449e-05
I294 n1_M2_7620_68100 0 2.202659e-05
I295 n1_M2_7620_70260 0 2.327733e-05
I296 n1_M2_7620_72420 0 2.257403e-05
I297 n1_M2_7620_73500 0 2.048449e-05
I298 n1_M2_7620_75660 0 1.461576e-05
I299 n1_M2_7620_77820 0 1.271016e-05
I300 n1_M2_7620_79980 0 1.259677e-05
I301 n1_M2_7620_82140 0 1.428246e-05
I302 n1_M2_7620_84300 0 1.430731e-05
I303 n1_M2_7620_86460 0 2.026753e-05
I304 n1_M2_7620_87540 0 1.760932e-05
I305 n1_M2_7620_89700 0 1.357927e-05
I306 n1_M2_7620_91860 0 1.427731e-05
I307 n1_M2_7620_94020 0 1.534295e-05
I308 n1_M2_7620_96180 0 1.957128e-05
I309 n1_M2_7620_98340 0 2.025458e-05
I310 n1_M2_7620_100500 0 1.239684e-05
I311 n1_M2_7620_101580 0 6.234390e-06
I312 n1_M2_7620_103740 0 6.399845e-06
I313 n1_M2_7620_105900 0 1.280236e-05
I314 n1_M2_7620_108060 0 1.434554e-05
I315 n1_M2_7620_110220 0 1.025749e-05
I316 n1_M2_7620_112380 0 4.536571e-06
I317 n1_M2_7620_113460 0 3.192523e-06
I318 n1_M2_7620_115620 0 3.003006e-06
I319 n1_M2_7620_117780 0 2.865340e-06
I320 n1_M2_7620_119940 0 2.829188e-06
I321 n1_M2_7620_122100 0 2.675922e-06
I322 n1_M2_7620_124260 0 2.551684e-06
I323 n1_M2_7620_126420 0 2.581911e-06
I324 n1_M2_7620_127500 0 2.720658e-06
I325 n1_M2_9780_60 0 2.779638e-06
I326 n1_M2_9780_2220 0 2.676358e-06
I327 n1_M2_9780_4380 0 2.854555e-06
I328 n1_M2_9780_5460 0 2.998012e-06
I329 n1_M2_9780_7620 0 3.143376e-06
I330 n1_M2_9780_9780 0 3.492866e-06
I331 n1_M2_9780_11940 0 5.303614e-06
I332 n1_M2_9780_14100 0 1.280908e-05
I333 n1_M2_9780_16260 0 2.166064e-05
I334 n1_M2_9780_18420 0 2.350626e-05
I335 n1_M2_9780_19500 0 2.333991e-05
I336 n1_M2_9780_21660 0 2.256265e-05
I337 n1_M2_9780_23820 0 2.229775e-05
I338 n1_M2_9780_25980 0 2.341274e-05
I339 n1_M2_9780_28140 0 2.389873e-05
I340 n1_M2_9780_30300 0 2.349143e-05
I341 n1_M2_9780_32460 0 2.245214e-05
I342 n1_M2_9780_33540 0 2.159329e-05
I343 n1_M2_9780_35700 0 2.022140e-05
I344 n1_M2_9780_37860 0 2.238968e-05
I345 n1_M2_9780_40020 0 2.297815e-05
I346 n1_M2_9780_42180 0 2.258055e-05
I347 n1_M2_9780_44340 0 2.037805e-05
I348 n1_M2_9780_46500 0 1.652700e-05
I349 n1_M2_9780_47580 0 1.402389e-05
I350 n1_M2_9780_49740 0 2.141063e-05
I351 n1_M2_9780_51900 0 2.332568e-05
I352 n1_M2_9780_54060 0 2.178683e-05
I353 n1_M2_9780_56220 0 1.798959e-05
I354 n1_M2_9780_58380 0 2.083082e-05
I355 n1_M2_9780_59460 0 2.200522e-05
I356 n1_M2_9780_61620 0 2.340017e-05
I357 n1_M2_9780_63780 0 2.349775e-05
I358 n1_M2_9780_65940 0 2.273060e-05
I359 n1_M2_9780_68100 0 2.366531e-05
I360 n1_M2_9780_70260 0 2.471926e-05
I361 n1_M2_9780_72420 0 2.369803e-05
I362 n1_M2_9780_73500 0 2.173687e-05
I363 n1_M2_9780_75660 0 1.839974e-05
I364 n1_M2_9780_77820 0 1.513065e-05
I365 n1_M2_9780_79980 0 1.573763e-05
I366 n1_M2_9780_82140 0 1.854565e-05
I367 n1_M2_9780_84300 0 1.558056e-05
I368 n1_M2_9780_86460 0 2.077246e-05
I369 n1_M2_9780_87540 0 1.997817e-05
I370 n1_M2_9780_89700 0 1.588571e-05
I371 n1_M2_9780_91860 0 1.519340e-05
I372 n1_M2_9780_94020 0 1.491975e-05
I373 n1_M2_9780_96180 0 1.741868e-05
I374 n1_M2_9780_98340 0 1.998358e-05
I375 n1_M2_9780_100500 0 1.233619e-05
I376 n1_M2_9780_101580 0 7.466704e-06
I377 n1_M2_9780_103740 0 8.278771e-06
I378 n1_M2_9780_105900 0 1.654004e-05
I379 n1_M2_9780_108060 0 2.151483e-05
I380 n1_M2_9780_110220 0 1.977291e-05
I381 n1_M2_9780_112380 0 1.087489e-05
I382 n1_M2_9780_113460 0 4.186167e-06
I383 n1_M2_9780_115620 0 3.082145e-06
I384 n1_M2_9780_117780 0 3.003262e-06
I385 n1_M2_9780_119940 0 2.955358e-06
I386 n1_M2_9780_122100 0 2.744302e-06
I387 n1_M2_9780_124260 0 2.627827e-06
I388 n1_M2_9780_126420 0 2.634621e-06
I389 n1_M2_9780_127500 0 2.722674e-06
I390 n1_M2_11940_60 0 2.815807e-06
I391 n1_M2_11940_2220 0 2.698281e-06
I392 n1_M2_11940_4380 0 2.883038e-06
I393 n1_M2_11940_5460 0 3.011910e-06
I394 n1_M2_11940_7620 0 3.256248e-06
I395 n1_M2_11940_9780 0 4.742489e-06
I396 n1_M2_11940_11940 0 1.002521e-05
I397 n1_M2_11940_14100 0 2.153026e-05
I398 n1_M2_11940_16260 0 2.488076e-05
I399 n1_M2_11940_18420 0 2.563161e-05
I400 n1_M2_11940_19500 0 2.483327e-05
I401 n1_M2_11940_21660 0 2.369031e-05
I402 n1_M2_11940_23820 0 2.314851e-05
I403 n1_M2_11940_25980 0 2.421354e-05
I404 n1_M2_11940_28140 0 2.538005e-05
I405 n1_M2_11940_30300 0 2.517187e-05
I406 n1_M2_11940_32460 0 2.422904e-05
I407 n1_M2_11940_33540 0 2.443135e-05
I408 n1_M2_11940_35700 0 2.233767e-05
I409 n1_M2_11940_37860 0 2.335748e-05
I410 n1_M2_11940_40020 0 2.518893e-05
I411 n1_M2_11940_42180 0 2.452027e-05
I412 n1_M2_11940_44340 0 2.281887e-05
I413 n1_M2_11940_46500 0 2.064769e-05
I414 n1_M2_11940_47580 0 1.716209e-05
I415 n1_M2_11940_49740 0 2.269415e-05
I416 n1_M2_11940_51900 0 2.546876e-05
I417 n1_M2_11940_54060 0 2.476334e-05
I418 n1_M2_11940_56220 0 2.312515e-05
I419 n1_M2_11940_58380 0 2.415260e-05
I420 n1_M2_11940_59460 0 2.429553e-05
I421 n1_M2_11940_61620 0 2.452223e-05
I422 n1_M2_11940_63780 0 2.529109e-05
I423 n1_M2_11940_65940 0 2.494798e-05
I424 n1_M2_11940_68100 0 2.519598e-05
I425 n1_M2_11940_70260 0 2.601134e-05
I426 n1_M2_11940_72420 0 2.546806e-05
I427 n1_M2_11940_73500 0 2.433674e-05
I428 n1_M2_11940_75660 0 2.283262e-05
I429 n1_M2_11940_77820 0 2.150234e-05
I430 n1_M2_11940_79980 0 2.216983e-05
I431 n1_M2_11940_82140 0 2.376531e-05
I432 n1_M2_11940_84300 0 2.205733e-05
I433 n1_M2_11940_86460 0 2.471293e-05
I434 n1_M2_11940_87540 0 2.550395e-05
I435 n1_M2_11940_89700 0 2.263244e-05
I436 n1_M2_11940_91860 0 1.993827e-05
I437 n1_M2_11940_94020 0 2.033764e-05
I438 n1_M2_11940_96180 0 2.007586e-05
I439 n1_M2_11940_98340 0 2.028137e-05
I440 n1_M2_11940_100500 0 1.321040e-05
I441 n1_M2_11940_101580 0 8.054740e-06
I442 n1_M2_11940_103740 0 7.690655e-06
I443 n1_M2_11940_105900 0 1.925258e-05
I444 n1_M2_11940_108060 0 2.396031e-05
I445 n1_M2_11940_110220 0 2.456594e-05
I446 n1_M2_11940_112380 0 1.956851e-05
I447 n1_M2_11940_113460 0 6.771960e-06
I448 n1_M2_11940_115620 0 3.452182e-06
I449 n1_M2_11940_117780 0 3.228867e-06
I450 n1_M2_11940_119940 0 3.101176e-06
I451 n1_M2_11940_122100 0 2.859926e-06
I452 n1_M2_11940_124260 0 2.738397e-06
I453 n1_M2_11940_126420 0 2.693006e-06
I454 n1_M2_11940_127500 0 2.726203e-06
I455 n1_M2_14100_60 0 2.931538e-06
I456 n1_M2_14100_2220 0 2.837515e-06
I457 n1_M2_14100_4380 0 2.896356e-06
I458 n1_M2_14100_5460 0 3.031119e-06
I459 n1_M2_14100_7620 0 3.769215e-06
I460 n1_M2_14100_9780 0 6.302272e-06
I461 n1_M2_14100_11940 0 1.205294e-05
I462 n1_M2_14100_14100 0 2.241105e-05
I463 n1_M2_14100_16260 0 2.438668e-05
I464 n1_M2_14100_18420 0 2.484794e-05
I465 n1_M2_14100_19500 0 2.382526e-05
I466 n1_M2_14100_21660 0 2.257163e-05
I467 n1_M2_14100_23820 0 2.198197e-05
I468 n1_M2_14100_25980 0 2.295547e-05
I469 n1_M2_14100_28140 0 2.472458e-05
I470 n1_M2_14100_30300 0 2.520909e-05
I471 n1_M2_14100_32460 0 2.470340e-05
I472 n1_M2_14100_33540 0 2.444291e-05
I473 n1_M2_14100_35700 0 2.266361e-05
I474 n1_M2_14100_37860 0 2.297952e-05
I475 n1_M2_14100_40020 0 2.470424e-05
I476 n1_M2_14100_42180 0 2.453622e-05
I477 n1_M2_14100_44340 0 2.241579e-05
I478 n1_M2_14100_46500 0 1.927958e-05
I479 n1_M2_14100_47580 0 1.695305e-05
I480 n1_M2_14100_49740 0 2.198039e-05
I481 n1_M2_14100_51900 0 2.485548e-05
I482 n1_M2_14100_54060 0 2.487691e-05
I483 n1_M2_14100_56220 0 2.394710e-05
I484 n1_M2_14100_58380 0 2.409706e-05
I485 n1_M2_14100_59460 0 2.366184e-05
I486 n1_M2_14100_61620 0 2.353583e-05
I487 n1_M2_14100_63780 0 2.422659e-05
I488 n1_M2_14100_65940 0 2.497503e-05
I489 n1_M2_14100_68100 0 2.558144e-05
I490 n1_M2_14100_70260 0 2.594628e-05
I491 n1_M2_14100_72420 0 2.575785e-05
I492 n1_M2_14100_73500 0 2.549760e-05
I493 n1_M2_14100_75660 0 2.377059e-05
I494 n1_M2_14100_77820 0 2.320265e-05
I495 n1_M2_14100_79980 0 2.366501e-05
I496 n1_M2_14100_82140 0 2.439754e-05
I497 n1_M2_14100_84300 0 2.380269e-05
I498 n1_M2_14100_86460 0 2.589220e-05
I499 n1_M2_14100_87540 0 2.624851e-05
I500 n1_M2_14100_89700 0 2.481489e-05
I501 n1_M2_14100_91860 0 2.241445e-05
I502 n1_M2_14100_94020 0 2.194587e-05
I503 n1_M2_14100_96180 0 2.204318e-05
I504 n1_M2_14100_98340 0 2.006315e-05
I505 n1_M2_14100_100500 0 1.224871e-05
I506 n1_M2_14100_101580 0 8.067034e-06
I507 n1_M2_14100_103740 0 8.422908e-06
I508 n1_M2_14100_105900 0 1.959513e-05
I509 n1_M2_14100_108060 0 2.462872e-05
I510 n1_M2_14100_110220 0 2.563951e-05
I511 n1_M2_14100_112380 0 2.287432e-05
I512 n1_M2_14100_113460 0 1.082590e-05
I513 n1_M2_14100_115620 0 4.767243e-06
I514 n1_M2_14100_117780 0 3.987692e-06
I515 n1_M2_14100_119940 0 3.442727e-06
I516 n1_M2_14100_122100 0 3.006634e-06
I517 n1_M2_14100_124260 0 2.819290e-06
I518 n1_M2_14100_126420 0 2.730762e-06
I519 n1_M2_14100_127500 0 2.726359e-06
I520 n1_M2_16260_60 0 2.902729e-06
I521 n1_M2_16260_2220 0 2.793353e-06
I522 n1_M2_16260_4380 0 2.884336e-06
I523 n1_M2_16260_5460 0 3.186187e-06
I524 n1_M2_16260_7620 0 6.153220e-06
I525 n1_M2_16260_9780 0 1.018704e-05
I526 n1_M2_16260_11940 0 1.654890e-05
I527 n1_M2_16260_14100 0 2.416744e-05
I528 n1_M2_16260_16260 0 2.460383e-05
I529 n1_M2_16260_18420 0 2.436477e-05
I530 n1_M2_16260_19500 0 2.374358e-05
I531 n1_M2_16260_21660 0 2.261299e-05
I532 n1_M2_16260_23820 0 2.204999e-05
I533 n1_M2_16260_25980 0 2.305370e-05
I534 n1_M2_16260_28140 0 2.420486e-05
I535 n1_M2_16260_30300 0 2.479401e-05
I536 n1_M2_16260_32460 0 2.512906e-05
I537 n1_M2_16260_33540 0 2.451548e-05
I538 n1_M2_16260_35700 0 2.402664e-05
I539 n1_M2_16260_37860 0 2.365259e-05
I540 n1_M2_16260_40020 0 2.498001e-05
I541 n1_M2_16260_42180 0 2.396142e-05
I542 n1_M2_16260_44340 0 2.308201e-05
I543 n1_M2_16260_46500 0 2.122906e-05
I544 n1_M2_16260_47580 0 2.048308e-05
I545 n1_M2_16260_49740 0 2.265317e-05
I546 n1_M2_16260_51900 0 2.452877e-05
I547 n1_M2_16260_54060 0 2.382401e-05
I548 n1_M2_16260_56220 0 2.391184e-05
I549 n1_M2_16260_58380 0 2.376802e-05
I550 n1_M2_16260_59460 0 2.328212e-05
I551 n1_M2_16260_61620 0 2.301907e-05
I552 n1_M2_16260_63780 0 2.451424e-05
I553 n1_M2_16260_65940 0 2.482694e-05
I554 n1_M2_16260_68100 0 2.566857e-05
I555 n1_M2_16260_70260 0 2.601556e-05
I556 n1_M2_16260_72420 0 2.591591e-05
I557 n1_M2_16260_73500 0 2.600896e-05
I558 n1_M2_16260_75660 0 2.484787e-05
I559 n1_M2_16260_77820 0 2.399541e-05
I560 n1_M2_16260_79980 0 2.464253e-05
I561 n1_M2_16260_82140 0 2.487623e-05
I562 n1_M2_16260_84300 0 2.352866e-05
I563 n1_M2_16260_86460 0 2.609923e-05
I564 n1_M2_16260_87540 0 2.605927e-05
I565 n1_M2_16260_89700 0 2.554610e-05
I566 n1_M2_16260_91860 0 2.512093e-05
I567 n1_M2_16260_94020 0 2.437166e-05
I568 n1_M2_16260_96180 0 2.496784e-05
I569 n1_M2_16260_98340 0 2.369725e-05
I570 n1_M2_16260_100500 0 1.580342e-05
I571 n1_M2_16260_101580 0 9.264134e-06
I572 n1_M2_16260_103740 0 6.716715e-06
I573 n1_M2_16260_105900 0 1.585052e-05
I574 n1_M2_16260_108060 0 2.410063e-05
I575 n1_M2_16260_110220 0 2.553133e-05
I576 n1_M2_16260_112380 0 2.435293e-05
I577 n1_M2_16260_113460 0 1.515391e-05
I578 n1_M2_16260_115620 0 7.340048e-06
I579 n1_M2_16260_117780 0 4.995808e-06
I580 n1_M2_16260_119940 0 4.109416e-06
I581 n1_M2_16260_122100 0 3.118505e-06
I582 n1_M2_16260_124260 0 3.017489e-06
I583 n1_M2_16260_126420 0 2.839907e-06
I584 n1_M2_16260_127500 0 2.763979e-06
I585 n1_M2_18420_60 0 2.894055e-06
I586 n1_M2_18420_2220 0 2.787813e-06
I587 n1_M2_18420_4380 0 2.909614e-06
I588 n1_M2_18420_5460 0 3.606261e-06
I589 n1_M2_18420_7620 0 1.022720e-05
I590 n1_M2_18420_9780 0 1.535971e-05
I591 n1_M2_18420_11940 0 1.902428e-05
I592 n1_M2_18420_14100 0 2.375194e-05
I593 n1_M2_18420_16260 0 2.351677e-05
I594 n1_M2_18420_18420 0 2.269663e-05
I595 n1_M2_18420_19500 0 2.251909e-05
I596 n1_M2_18420_21660 0 2.142989e-05
I597 n1_M2_18420_23820 0 1.971150e-05
I598 n1_M2_18420_25980 0 2.224498e-05
I599 n1_M2_18420_28140 0 2.353097e-05
I600 n1_M2_18420_30300 0 2.377113e-05
I601 n1_M2_18420_32460 0 2.535044e-05
I602 n1_M2_18420_33540 0 2.543321e-05
I603 n1_M2_18420_35700 0 2.495803e-05
I604 n1_M2_18420_37860 0 2.417449e-05
I605 n1_M2_18420_40020 0 2.417633e-05
I606 n1_M2_18420_42180 0 2.322459e-05
I607 n1_M2_18420_44340 0 2.423856e-05
I608 n1_M2_18420_46500 0 2.339555e-05
I609 n1_M2_18420_47580 0 2.220741e-05
I610 n1_M2_18420_49740 0 2.323885e-05
I611 n1_M2_18420_51900 0 2.386567e-05
I612 n1_M2_18420_54060 0 2.320264e-05
I613 n1_M2_18420_56220 0 2.398059e-05
I614 n1_M2_18420_58380 0 2.446851e-05
I615 n1_M2_18420_59460 0 2.262561e-05
I616 n1_M2_18420_61620 0 2.100759e-05
I617 n1_M2_18420_63780 0 2.324228e-05
I618 n1_M2_18420_65940 0 2.456882e-05
I619 n1_M2_18420_68100 0 2.537972e-05
I620 n1_M2_18420_70260 0 2.592941e-05
I621 n1_M2_18420_72420 0 2.614421e-05
I622 n1_M2_18420_73500 0 2.601093e-05
I623 n1_M2_18420_75660 0 2.527995e-05
I624 n1_M2_18420_77820 0 2.370767e-05
I625 n1_M2_18420_79980 0 2.370160e-05
I626 n1_M2_18420_82140 0 2.408904e-05
I627 n1_M2_18420_84300 0 2.244608e-05
I628 n1_M2_18420_86460 0 2.488712e-05
I629 n1_M2_18420_87540 0 2.630395e-05
I630 n1_M2_18420_89700 0 2.511082e-05
I631 n1_M2_18420_91860 0 2.422943e-05
I632 n1_M2_18420_94020 0 2.451635e-05
I633 n1_M2_18420_96180 0 2.527216e-05
I634 n1_M2_18420_98340 0 2.397343e-05
I635 n1_M2_18420_100500 0 1.568781e-05
I636 n1_M2_18420_101580 0 9.329739e-06
I637 n1_M2_18420_103740 0 7.260195e-06
I638 n1_M2_18420_105900 0 1.364071e-05
I639 n1_M2_18420_108060 0 2.197016e-05
I640 n1_M2_18420_110220 0 2.434814e-05
I641 n1_M2_18420_112380 0 2.279428e-05
I642 n1_M2_18420_113460 0 1.469573e-05
I643 n1_M2_18420_115620 0 8.198598e-06
I644 n1_M2_18420_117780 0 6.595167e-06
I645 n1_M2_18420_119940 0 4.469029e-06
I646 n1_M2_18420_122100 0 3.340547e-06
I647 n1_M2_18420_124260 0 3.095782e-06
I648 n1_M2_18420_126420 0 2.900988e-06
I649 n1_M2_18420_127500 0 2.845838e-06
I650 n1_M2_19500_60 0 2.907168e-06
I651 n1_M2_19500_2220 0 2.793032e-06
I652 n1_M2_19500_4380 0 3.015520e-06
I653 n1_M2_19500_5460 0 4.448521e-06
I654 n1_M2_19500_7620 0 1.271451e-05
I655 n1_M2_19500_9780 0 1.941701e-05
I656 n1_M2_19500_11940 0 2.166555e-05
I657 n1_M2_19500_14100 0 2.390416e-05
I658 n1_M2_19500_16260 0 2.319576e-05
I659 n1_M2_19500_18420 0 2.062579e-05
I660 n1_M2_19500_19500 0 1.939273e-05
I661 n1_M2_19500_21660 0 1.906992e-05
I662 n1_M2_19500_23820 0 1.690019e-05
I663 n1_M2_19500_25980 0 1.890830e-05
I664 n1_M2_19500_28140 0 2.327147e-05
I665 n1_M2_19500_30300 0 2.342649e-05
I666 n1_M2_19500_32460 0 2.496697e-05
I667 n1_M2_19500_33540 0 2.559560e-05
I668 n1_M2_19500_35700 0 2.528532e-05
I669 n1_M2_19500_37860 0 2.462302e-05
I670 n1_M2_19500_40020 0 2.479184e-05
I671 n1_M2_19500_42180 0 2.396218e-05
I672 n1_M2_19500_44340 0 2.440426e-05
I673 n1_M2_19500_46500 0 2.499389e-05
I674 n1_M2_19500_47580 0 2.402812e-05
I675 n1_M2_19500_49740 0 2.479143e-05
I676 n1_M2_19500_51900 0 2.445491e-05
I677 n1_M2_19500_54060 0 2.372634e-05
I678 n1_M2_19500_56220 0 2.411501e-05
I679 n1_M2_19500_58380 0 2.453960e-05
I680 n1_M2_19500_59460 0 2.174567e-05
I681 n1_M2_19500_61620 0 1.796339e-05
I682 n1_M2_19500_63780 0 2.040673e-05
I683 n1_M2_19500_65940 0 2.278453e-05
I684 n1_M2_19500_68100 0 2.451222e-05
I685 n1_M2_19500_70260 0 2.560629e-05
I686 n1_M2_19500_72420 0 2.584103e-05
I687 n1_M2_19500_73500 0 2.588196e-05
I688 n1_M2_19500_75660 0 2.482067e-05
I689 n1_M2_19500_77820 0 2.349497e-05
I690 n1_M2_19500_79980 0 2.321619e-05
I691 n1_M2_19500_82140 0 2.312785e-05
I692 n1_M2_19500_84300 0 2.155134e-05
I693 n1_M2_19500_86460 0 2.319067e-05
I694 n1_M2_19500_87540 0 2.562280e-05
I695 n1_M2_19500_89700 0 2.376847e-05
I696 n1_M2_19500_91860 0 2.285469e-05
I697 n1_M2_19500_94020 0 2.421879e-05
I698 n1_M2_19500_96180 0 2.527714e-05
I699 n1_M2_19500_98340 0 2.340879e-05
I700 n1_M2_19500_100500 0 1.553585e-05
I701 n1_M2_19500_101580 0 1.065835e-05
I702 n1_M2_19500_103740 0 8.610043e-06
I703 n1_M2_19500_105900 0 1.266067e-05
I704 n1_M2_19500_108060 0 1.930331e-05
I705 n1_M2_19500_110220 0 2.212946e-05
I706 n1_M2_19500_112380 0 2.200261e-05
I707 n1_M2_19500_113460 0 1.817867e-05
I708 n1_M2_19500_115620 0 1.120172e-05
I709 n1_M2_19500_117780 0 8.733788e-06
I710 n1_M2_19500_119940 0 6.175392e-06
I711 n1_M2_19500_122100 0 4.531099e-06
I712 n1_M2_19500_124260 0 3.266096e-06
I713 n1_M2_19500_126420 0 2.906153e-06
I714 n1_M2_19500_127500 0 2.896252e-06
I715 n1_M2_21660_60 0 2.948123e-06
I716 n1_M2_21660_2220 0 2.832212e-06
I717 n1_M2_21660_4380 0 3.169336e-06
I718 n1_M2_21660_5460 0 5.537144e-06
I719 n1_M2_21660_7620 0 1.250429e-05
I720 n1_M2_21660_9780 0 1.887055e-05
I721 n1_M2_21660_11940 0 2.215287e-05
I722 n1_M2_21660_14100 0 2.359831e-05
I723 n1_M2_21660_16260 0 2.208228e-05
I724 n1_M2_21660_18420 0 1.883800e-05
I725 n1_M2_21660_19500 0 1.645085e-05
I726 n1_M2_21660_21660 0 1.749119e-05
I727 n1_M2_21660_23820 0 1.498560e-05
I728 n1_M2_21660_25980 0 1.686148e-05
I729 n1_M2_21660_28140 0 2.260644e-05
I730 n1_M2_21660_30300 0 2.360210e-05
I731 n1_M2_21660_32460 0 2.501221e-05
I732 n1_M2_21660_33540 0 2.557762e-05
I733 n1_M2_21660_35700 0 2.487121e-05
I734 n1_M2_21660_37860 0 2.473430e-05
I735 n1_M2_21660_40020 0 2.493982e-05
I736 n1_M2_21660_42180 0 2.464027e-05
I737 n1_M2_21660_44340 0 2.476415e-05
I738 n1_M2_21660_46500 0 2.504754e-05
I739 n1_M2_21660_47580 0 2.389346e-05
I740 n1_M2_21660_49740 0 2.520653e-05
I741 n1_M2_21660_51900 0 2.514000e-05
I742 n1_M2_21660_54060 0 2.443171e-05
I743 n1_M2_21660_56220 0 2.455554e-05
I744 n1_M2_21660_58380 0 2.448881e-05
I745 n1_M2_21660_59460 0 2.122566e-05
I746 n1_M2_21660_61620 0 1.679326e-05
I747 n1_M2_21660_63780 0 1.648217e-05
I748 n1_M2_21660_65940 0 1.905947e-05
I749 n1_M2_21660_68100 0 2.253464e-05
I750 n1_M2_21660_70260 0 2.509740e-05
I751 n1_M2_21660_72420 0 2.566947e-05
I752 n1_M2_21660_73500 0 2.589081e-05
I753 n1_M2_21660_75660 0 2.498605e-05
I754 n1_M2_21660_77820 0 2.368207e-05
I755 n1_M2_21660_79980 0 2.314697e-05
I756 n1_M2_21660_82140 0 2.244489e-05
I757 n1_M2_21660_84300 0 1.922944e-05
I758 n1_M2_21660_86460 0 2.193313e-05
I759 n1_M2_21660_87540 0 2.440415e-05
I760 n1_M2_21660_89700 0 2.209802e-05
I761 n1_M2_21660_91860 0 2.109096e-05
I762 n1_M2_21660_94020 0 2.219877e-05
I763 n1_M2_21660_96180 0 2.354378e-05
I764 n1_M2_21660_98340 0 2.277061e-05
I765 n1_M2_21660_100500 0 1.554388e-05
I766 n1_M2_21660_101580 0 1.363832e-05
I767 n1_M2_21660_103740 0 1.200103e-05
I768 n1_M2_21660_105900 0 1.227769e-05
I769 n1_M2_21660_108060 0 1.726400e-05
I770 n1_M2_21660_110220 0 2.136431e-05
I771 n1_M2_21660_112380 0 2.252418e-05
I772 n1_M2_21660_113460 0 2.168862e-05
I773 n1_M2_21660_115620 0 1.665108e-05
I774 n1_M2_21660_117780 0 1.263415e-05
I775 n1_M2_21660_119940 0 9.928228e-06
I776 n1_M2_21660_122100 0 5.963812e-06
I777 n1_M2_21660_124260 0 3.552272e-06
I778 n1_M2_21660_126420 0 2.914661e-06
I779 n1_M2_21660_127500 0 2.949629e-06
I780 n1_M2_23820_60 0 2.898070e-06
I781 n1_M2_23820_2220 0 2.807033e-06
I782 n1_M2_23820_4380 0 3.217988e-06
I783 n1_M2_23820_5460 0 6.578932e-06
I784 n1_M2_23820_7620 0 1.246626e-05
I785 n1_M2_23820_9780 0 1.911957e-05
I786 n1_M2_23820_11940 0 2.209929e-05
I787 n1_M2_23820_14100 0 2.282629e-05
I788 n1_M2_23820_16260 0 2.221024e-05
I789 n1_M2_23820_18420 0 1.933923e-05
I790 n1_M2_23820_19500 0 1.753364e-05
I791 n1_M2_23820_21660 0 1.559140e-05
I792 n1_M2_23820_23820 0 1.268897e-05
I793 n1_M2_23820_25980 0 1.685290e-05
I794 n1_M2_23820_28140 0 2.175490e-05
I795 n1_M2_23820_30300 0 2.244344e-05
I796 n1_M2_23820_32460 0 2.423476e-05
I797 n1_M2_23820_33540 0 2.495218e-05
I798 n1_M2_23820_35700 0 2.388551e-05
I799 n1_M2_23820_37860 0 2.340200e-05
I800 n1_M2_23820_40020 0 2.439906e-05
I801 n1_M2_23820_42180 0 2.367771e-05
I802 n1_M2_23820_44340 0 2.271234e-05
I803 n1_M2_23820_46500 0 2.357126e-05
I804 n1_M2_23820_47580 0 2.248849e-05
I805 n1_M2_23820_49740 0 2.363433e-05
I806 n1_M2_23820_51900 0 2.519708e-05
I807 n1_M2_23820_54060 0 2.539239e-05
I808 n1_M2_23820_56220 0 2.506159e-05
I809 n1_M2_23820_58380 0 2.526615e-05
I810 n1_M2_23820_59460 0 2.200303e-05
I811 n1_M2_23820_61620 0 1.575254e-05
I812 n1_M2_23820_63780 0 1.462800e-05
I813 n1_M2_23820_65940 0 1.378301e-05
I814 n1_M2_23820_68100 0 1.866958e-05
I815 n1_M2_23820_70260 0 2.279271e-05
I816 n1_M2_23820_72420 0 2.433896e-05
I817 n1_M2_23820_73500 0 2.490761e-05
I818 n1_M2_23820_75660 0 2.439619e-05
I819 n1_M2_23820_77820 0 2.334476e-05
I820 n1_M2_23820_79980 0 2.237847e-05
I821 n1_M2_23820_82140 0 2.117971e-05
I822 n1_M2_23820_84300 0 1.528810e-05
I823 n1_M2_23820_86460 0 1.732638e-05
I824 n1_M2_23820_87540 0 2.259110e-05
I825 n1_M2_23820_89700 0 1.950528e-05
I826 n1_M2_23820_91860 0 1.842789e-05
I827 n1_M2_23820_94020 0 1.905495e-05
I828 n1_M2_23820_96180 0 2.068107e-05
I829 n1_M2_23820_98340 0 2.055418e-05
I830 n1_M2_23820_100500 0 1.286054e-05
I831 n1_M2_23820_101580 0 1.113840e-05
I832 n1_M2_23820_103740 0 1.152097e-05
I833 n1_M2_23820_105900 0 1.313229e-05
I834 n1_M2_23820_108060 0 1.608613e-05
I835 n1_M2_23820_110220 0 2.002018e-05
I836 n1_M2_23820_112380 0 2.184644e-05
I837 n1_M2_23820_113460 0 2.154882e-05
I838 n1_M2_23820_115620 0 2.051566e-05
I839 n1_M2_23820_117780 0 1.746900e-05
I840 n1_M2_23820_119940 0 1.412139e-05
I841 n1_M2_23820_122100 0 7.412876e-06
I842 n1_M2_23820_124260 0 3.733526e-06
I843 n1_M2_23820_126420 0 2.884351e-06
I844 n1_M2_23820_127500 0 2.807897e-06
I845 n1_M2_25980_60 0 2.832024e-06
I846 n1_M2_25980_2220 0 2.841671e-06
I847 n1_M2_25980_4380 0 3.304883e-06
I848 n1_M2_25980_5460 0 7.492614e-06
I849 n1_M2_25980_7620 0 1.291341e-05
I850 n1_M2_25980_9780 0 1.914901e-05
I851 n1_M2_25980_11940 0 2.154070e-05
I852 n1_M2_25980_14100 0 2.200927e-05
I853 n1_M2_25980_16260 0 2.216904e-05
I854 n1_M2_25980_18420 0 2.124988e-05
I855 n1_M2_25980_19500 0 1.942034e-05
I856 n1_M2_25980_21660 0 1.608373e-05
I857 n1_M2_25980_23820 0 1.392445e-05
I858 n1_M2_25980_25980 0 1.451993e-05
I859 n1_M2_25980_28140 0 2.033344e-05
I860 n1_M2_25980_30300 0 2.142949e-05
I861 n1_M2_25980_32460 0 2.272187e-05
I862 n1_M2_25980_33540 0 2.362080e-05
I863 n1_M2_25980_35700 0 2.236026e-05
I864 n1_M2_25980_37860 0 2.184267e-05
I865 n1_M2_25980_40020 0 2.248170e-05
I866 n1_M2_25980_42180 0 2.190383e-05
I867 n1_M2_25980_44340 0 1.791048e-05
I868 n1_M2_25980_46500 0 1.837459e-05
I869 n1_M2_25980_47580 0 1.843194e-05
I870 n1_M2_25980_49740 0 2.049431e-05
I871 n1_M2_25980_51900 0 2.408459e-05
I872 n1_M2_25980_54060 0 2.523889e-05
I873 n1_M2_25980_56220 0 2.466734e-05
I874 n1_M2_25980_58380 0 2.558161e-05
I875 n1_M2_25980_59460 0 2.319942e-05
I876 n1_M2_25980_61620 0 1.517836e-05
I877 n1_M2_25980_63780 0 1.370438e-05
I878 n1_M2_25980_65940 0 1.442497e-05
I879 n1_M2_25980_68100 0 1.449904e-05
I880 n1_M2_25980_70260 0 2.171612e-05
I881 n1_M2_25980_72420 0 2.341674e-05
I882 n1_M2_25980_73500 0 2.428851e-05
I883 n1_M2_25980_75660 0 2.414357e-05
I884 n1_M2_25980_77820 0 2.327749e-05
I885 n1_M2_25980_79980 0 2.123654e-05
I886 n1_M2_25980_82140 0 1.910017e-05
I887 n1_M2_25980_84300 0 1.435267e-05
I888 n1_M2_25980_86460 0 1.328315e-05
I889 n1_M2_25980_87540 0 2.061953e-05
I890 n1_M2_25980_89700 0 1.846481e-05
I891 n1_M2_25980_91860 0 1.533461e-05
I892 n1_M2_25980_94020 0 1.572392e-05
I893 n1_M2_25980_96180 0 1.783043e-05
I894 n1_M2_25980_98340 0 1.682451e-05
I895 n1_M2_25980_100500 0 1.099751e-05
I896 n1_M2_25980_101580 0 1.028661e-05
I897 n1_M2_25980_103740 0 1.232291e-05
I898 n1_M2_25980_105900 0 1.482015e-05
I899 n1_M2_25980_108060 0 1.607541e-05
I900 n1_M2_25980_110220 0 1.839873e-05
I901 n1_M2_25980_112380 0 1.940185e-05
I902 n1_M2_25980_113460 0 1.913560e-05
I903 n1_M2_25980_115620 0 1.958321e-05
I904 n1_M2_25980_117780 0 2.090393e-05
I905 n1_M2_25980_119940 0 1.820286e-05
I906 n1_M2_25980_122100 0 8.287406e-06
I907 n1_M2_25980_124260 0 3.878116e-06
I908 n1_M2_25980_126420 0 2.934857e-06
I909 n1_M2_25980_127500 0 2.936843e-06
I910 n1_M2_28140_60 0 2.781087e-06
I911 n1_M2_28140_2220 0 2.840863e-06
I912 n1_M2_28140_4380 0 3.364135e-06
I913 n1_M2_28140_5460 0 7.999694e-06
I914 n1_M2_28140_7620 0 1.124065e-05
I915 n1_M2_28140_9780 0 1.357778e-05
I916 n1_M2_28140_11940 0 1.585898e-05
I917 n1_M2_28140_14100 0 1.944637e-05
I918 n1_M2_28140_16260 0 2.017896e-05
I919 n1_M2_28140_18420 0 1.868548e-05
I920 n1_M2_28140_19500 0 1.727218e-05
I921 n1_M2_28140_21660 0 1.516543e-05
I922 n1_M2_28140_23820 0 1.240991e-05
I923 n1_M2_28140_25980 0 1.264902e-05
I924 n1_M2_28140_28140 0 1.423862e-05
I925 n1_M2_28140_30300 0 1.739445e-05
I926 n1_M2_28140_32460 0 2.211865e-05
I927 n1_M2_28140_33540 0 2.147854e-05
I928 n1_M2_28140_35700 0 2.112156e-05
I929 n1_M2_28140_37860 0 2.119035e-05
I930 n1_M2_28140_40020 0 2.122801e-05
I931 n1_M2_28140_42180 0 2.026094e-05
I932 n1_M2_28140_44340 0 1.394498e-05
I933 n1_M2_28140_46500 0 1.117162e-05
I934 n1_M2_28140_47580 0 1.302256e-05
I935 n1_M2_28140_49740 0 1.590740e-05
I936 n1_M2_28140_51900 0 2.149203e-05
I937 n1_M2_28140_54060 0 2.142023e-05
I938 n1_M2_28140_56220 0 2.178955e-05
I939 n1_M2_28140_58380 0 2.240450e-05
I940 n1_M2_28140_59460 0 2.118384e-05
I941 n1_M2_28140_61620 0 1.459608e-05
I942 n1_M2_28140_63780 0 1.290699e-05
I943 n1_M2_28140_65940 0 1.081164e-05
I944 n1_M2_28140_68100 0 1.124186e-05
I945 n1_M2_28140_70260 0 1.612793e-05
I946 n1_M2_28140_72420 0 2.038987e-05
I947 n1_M2_28140_73500 0 2.333874e-05
I948 n1_M2_28140_75660 0 2.372591e-05
I949 n1_M2_28140_77820 0 2.212647e-05
I950 n1_M2_28140_79980 0 2.045772e-05
I951 n1_M2_28140_82140 0 1.749336e-05
I952 n1_M2_28140_84300 0 1.422316e-05
I953 n1_M2_28140_86460 0 1.324098e-05
I954 n1_M2_28140_87540 0 1.641960e-05
I955 n1_M2_28140_89700 0 1.415040e-05
I956 n1_M2_28140_91860 0 1.173152e-05
I957 n1_M2_28140_94020 0 1.311484e-05
I958 n1_M2_28140_96180 0 1.614756e-05
I959 n1_M2_28140_98340 0 1.782395e-05
I960 n1_M2_28140_100500 0 1.149094e-05
I961 n1_M2_28140_101580 0 1.023015e-05
I962 n1_M2_28140_103740 0 1.425988e-05
I963 n1_M2_28140_105900 0 1.703715e-05
I964 n1_M2_28140_108060 0 1.722257e-05
I965 n1_M2_28140_110220 0 1.961114e-05
I966 n1_M2_28140_112380 0 1.996700e-05
I967 n1_M2_28140_113460 0 1.870316e-05
I968 n1_M2_28140_115620 0 2.084803e-05
I969 n1_M2_28140_117780 0 2.027822e-05
I970 n1_M2_28140_119940 0 1.638667e-05
I971 n1_M2_28140_122100 0 7.372782e-06
I972 n1_M2_28140_124260 0 3.547890e-06
I973 n1_M2_28140_126420 0 2.841499e-06
I974 n1_M2_28140_127500 0 2.932552e-06
I975 n1_M2_30300_60 0 2.781070e-06
I976 n1_M2_30300_2220 0 2.795532e-06
I977 n1_M2_30300_4380 0 3.271730e-06
I978 n1_M2_30300_5460 0 7.282085e-06
I979 n1_M2_30300_7620 0 1.068221e-05
I980 n1_M2_30300_9780 0 1.043075e-05
I981 n1_M2_30300_11940 0 1.111048e-05
I982 n1_M2_30300_14100 0 1.442045e-05
I983 n1_M2_30300_16260 0 1.689402e-05
I984 n1_M2_30300_18420 0 1.667870e-05
I985 n1_M2_30300_19500 0 1.857687e-05
I986 n1_M2_30300_21660 0 1.699602e-05
I987 n1_M2_30300_23820 0 1.213572e-05
I988 n1_M2_30300_25980 0 1.035617e-05
I989 n1_M2_30300_28140 0 9.237639e-06
I990 n1_M2_30300_30300 0 1.112302e-05
I991 n1_M2_30300_32460 0 2.129790e-05
I992 n1_M2_30300_33540 0 2.181102e-05
I993 n1_M2_30300_35700 0 2.114303e-05
I994 n1_M2_30300_37860 0 2.034149e-05
I995 n1_M2_30300_40020 0 1.944896e-05
I996 n1_M2_30300_42180 0 1.330389e-05
I997 n1_M2_30300_44340 0 1.017322e-05
I998 n1_M2_30300_46500 0 8.316102e-06
I999 n1_M2_30300_47580 0 9.723949e-06
I1000 n1_M2_30300_49740 0 1.247172e-05
I1001 n1_M2_30300_51900 0 1.738766e-05
I1002 n1_M2_30300_54060 0 1.377838e-05
I1003 n1_M2_30300_56220 0 1.594697e-05
I1004 n1_M2_30300_58380 0 2.196241e-05
I1005 n1_M2_30300_59460 0 1.963014e-05
I1006 n1_M2_30300_61620 0 1.417878e-05
I1007 n1_M2_30300_63780 0 1.040114e-05
I1008 n1_M2_30300_65940 0 9.099913e-06
I1009 n1_M2_30300_68100 0 1.173200e-05
I1010 n1_M2_30300_70260 0 1.534518e-05
I1011 n1_M2_30300_72420 0 1.645085e-05
I1012 n1_M2_30300_73500 0 2.200959e-05
I1013 n1_M2_30300_75660 0 2.284515e-05
I1014 n1_M2_30300_77820 0 2.106359e-05
I1015 n1_M2_30300_79980 0 1.928060e-05
I1016 n1_M2_30300_82140 0 2.048768e-05
I1017 n1_M2_30300_84300 0 1.418612e-05
I1018 n1_M2_30300_86460 0 1.284641e-05
I1019 n1_M2_30300_87540 0 1.528605e-05
I1020 n1_M2_30300_89700 0 1.168521e-05
I1021 n1_M2_30300_91860 0 1.145713e-05
I1022 n1_M2_30300_94020 0 1.546071e-05
I1023 n1_M2_30300_96180 0 1.918568e-05
I1024 n1_M2_30300_98340 0 1.962775e-05
I1025 n1_M2_30300_100500 0 1.319238e-05
I1026 n1_M2_30300_101580 0 1.275545e-05
I1027 n1_M2_30300_103740 0 2.053978e-05
I1028 n1_M2_30300_105900 0 2.158237e-05
I1029 n1_M2_30300_108060 0 1.844496e-05
I1030 n1_M2_30300_110220 0 1.915938e-05
I1031 n1_M2_30300_112380 0 1.695684e-05
I1032 n1_M2_30300_113460 0 1.405607e-05
I1033 n1_M2_30300_115620 0 1.659264e-05
I1034 n1_M2_30300_117780 0 1.778914e-05
I1035 n1_M2_30300_119940 0 1.512936e-05
I1036 n1_M2_30300_122100 0 6.712156e-06
I1037 n1_M2_30300_124260 0 3.290329e-06
I1038 n1_M2_30300_126420 0 2.804097e-06
I1039 n1_M2_30300_127500 0 2.859520e-06
I1040 n1_M2_32460_60 0 2.781069e-06
I1041 n1_M2_32460_2220 0 2.786276e-06
I1042 n1_M2_32460_4380 0 3.070526e-06
I1043 n1_M2_32460_5460 0 3.662318e-06
I1044 n1_M2_32460_7620 0 4.983411e-06
I1045 n1_M2_32460_9780 0 5.124592e-06
I1046 n1_M2_32460_11940 0 6.532996e-06
I1047 n1_M2_32460_14100 0 1.085186e-05
I1048 n1_M2_32460_16260 0 1.512194e-05
I1049 n1_M2_32460_18420 0 1.595270e-05
I1050 n1_M2_32460_19500 0 1.992262e-05
I1051 n1_M2_32460_21660 0 1.806565e-05
I1052 n1_M2_32460_23820 0 1.259864e-05
I1053 n1_M2_32460_25980 0 9.839629e-06
I1054 n1_M2_32460_28140 0 1.138465e-05
I1055 n1_M2_32460_30300 0 1.128804e-05
I1056 n1_M2_32460_32460 0 2.201459e-05
I1057 n1_M2_32460_33540 0 2.309092e-05
I1058 n1_M2_32460_35700 0 2.330677e-05
I1059 n1_M2_32460_37860 0 2.233865e-05
I1060 n1_M2_32460_40020 0 1.974295e-05
I1061 n1_M2_32460_42180 0 1.551103e-05
I1062 n1_M2_32460_44340 0 1.328513e-05
I1063 n1_M2_32460_46500 0 1.386296e-05
I1064 n1_M2_32460_47580 0 1.350717e-05
I1065 n1_M2_32460_49740 0 1.117058e-05
I1066 n1_M2_32460_51900 0 1.129602e-05
I1067 n1_M2_32460_54060 0 9.500032e-06
I1068 n1_M2_32460_56220 0 1.369196e-05
I1069 n1_M2_32460_58380 0 2.403990e-05
I1070 n1_M2_32460_59460 0 2.472462e-05
I1071 n1_M2_32460_61620 0 1.862313e-05
I1072 n1_M2_32460_63780 0 1.262834e-05
I1073 n1_M2_32460_65940 0 1.297739e-05
I1074 n1_M2_32460_68100 0 1.488087e-05
I1075 n1_M2_32460_70260 0 2.096692e-05
I1076 n1_M2_32460_72420 0 1.831816e-05
I1077 n1_M2_32460_73500 0 2.085586e-05
I1078 n1_M2_32460_75660 0 2.357199e-05
I1079 n1_M2_32460_77820 0 2.286922e-05
I1080 n1_M2_32460_79980 0 2.281191e-05
I1081 n1_M2_32460_82140 0 2.437914e-05
I1082 n1_M2_32460_84300 0 2.038743e-05
I1083 n1_M2_32460_86460 0 1.450425e-05
I1084 n1_M2_32460_87540 0 2.049928e-05
I1085 n1_M2_32460_89700 0 1.579273e-05
I1086 n1_M2_32460_91860 0 1.285447e-05
I1087 n1_M2_32460_94020 0 1.984393e-05
I1088 n1_M2_32460_96180 0 2.371070e-05
I1089 n1_M2_32460_98340 0 2.352603e-05
I1090 n1_M2_32460_100500 0 1.762326e-05
I1091 n1_M2_32460_101580 0 1.716902e-05
I1092 n1_M2_32460_103740 0 2.222855e-05
I1093 n1_M2_32460_105900 0 2.356346e-05
I1094 n1_M2_32460_108060 0 2.197998e-05
I1095 n1_M2_32460_110220 0 1.829463e-05
I1096 n1_M2_32460_112380 0 1.510142e-05
I1097 n1_M2_32460_113460 0 1.302349e-05
I1098 n1_M2_32460_115620 0 1.463743e-05
I1099 n1_M2_32460_117780 0 1.478554e-05
I1100 n1_M2_32460_119940 0 1.284297e-05
I1101 n1_M2_32460_122100 0 5.768241e-06
I1102 n1_M2_32460_124260 0 3.320666e-06
I1103 n1_M2_32460_126420 0 2.803282e-06
I1104 n1_M2_32460_127500 0 2.948794e-06
I1105 n1_M2_33540_60 0 2.781069e-06
I1106 n1_M2_33540_2220 0 2.786273e-06
I1107 n1_M2_33540_4380 0 3.060495e-06
I1108 n1_M2_33540_5460 0 3.253979e-06
I1109 n1_M2_33540_7620 0 3.523621e-06
I1110 n1_M2_33540_9780 0 3.686078e-06
I1111 n1_M2_33540_11940 0 4.113054e-06
I1112 n1_M2_33540_14100 0 6.226232e-06
I1113 n1_M2_33540_16260 0 1.012599e-05
I1114 n1_M2_33540_18420 0 1.044247e-05
I1115 n1_M2_33540_19500 0 1.312594e-05
I1116 n1_M2_33540_21660 0 1.294557e-05
I1117 n1_M2_33540_23820 0 9.951850e-06
I1118 n1_M2_33540_25980 0 7.326745e-06
I1119 n1_M2_33540_28140 0 8.364686e-06
I1120 n1_M2_33540_30300 0 9.918349e-06
I1121 n1_M2_33540_32460 0 2.150456e-05
I1122 n1_M2_33540_33540 0 2.291031e-05
I1123 n1_M2_33540_35700 0 2.215367e-05
I1124 n1_M2_33540_37860 0 2.221304e-05
I1125 n1_M2_33540_40020 0 2.202030e-05
I1126 n1_M2_33540_42180 0 2.114297e-05
I1127 n1_M2_33540_44340 0 1.809206e-05
I1128 n1_M2_33540_46500 0 1.468496e-05
I1129 n1_M2_33540_47580 0 1.105129e-05
I1130 n1_M2_33540_49740 0 8.135253e-06
I1131 n1_M2_33540_51900 0 7.200707e-06
I1132 n1_M2_33540_54060 0 5.541336e-06
I1133 n1_M2_33540_56220 0 1.055435e-05
I1134 n1_M2_33540_58380 0 2.302860e-05
I1135 n1_M2_33540_59460 0 2.535749e-05
I1136 n1_M2_33540_61620 0 1.936867e-05
I1137 n1_M2_33540_63780 0 1.187465e-05
I1138 n1_M2_33540_65940 0 1.258478e-05
I1139 n1_M2_33540_68100 0 1.160836e-05
I1140 n1_M2_33540_70260 0 1.290009e-05
I1141 n1_M2_33540_72420 0 1.161469e-05
I1142 n1_M2_33540_73500 0 1.685048e-05
I1143 n1_M2_33540_75660 0 2.325401e-05
I1144 n1_M2_33540_77820 0 2.435794e-05
I1145 n1_M2_33540_79980 0 2.427176e-05
I1146 n1_M2_33540_82140 0 2.396573e-05
I1147 n1_M2_33540_84300 0 1.949724e-05
I1148 n1_M2_33540_86460 0 1.680183e-05
I1149 n1_M2_33540_87540 0 2.180649e-05
I1150 n1_M2_33540_89700 0 1.811720e-05
I1151 n1_M2_33540_91860 0 1.220649e-05
I1152 n1_M2_33540_94020 0 1.904515e-05
I1153 n1_M2_33540_96180 0 2.322174e-05
I1154 n1_M2_33540_98340 0 2.364634e-05
I1155 n1_M2_33540_100500 0 1.962393e-05
I1156 n1_M2_33540_101580 0 1.970012e-05
I1157 n1_M2_33540_103740 0 2.386983e-05
I1158 n1_M2_33540_105900 0 2.417937e-05
I1159 n1_M2_33540_108060 0 2.319729e-05
I1160 n1_M2_33540_110220 0 2.120242e-05
I1161 n1_M2_33540_112380 0 1.571901e-05
I1162 n1_M2_33540_113460 0 1.416601e-05
I1163 n1_M2_33540_115620 0 1.535216e-05
I1164 n1_M2_33540_117780 0 1.393372e-05
I1165 n1_M2_33540_119940 0 1.157839e-05
I1166 n1_M2_33540_122100 0 6.216387e-06
I1167 n1_M2_33540_124260 0 3.610752e-06
I1168 n1_M2_33540_126420 0 2.797761e-06
I1169 n1_M2_33540_127500 0 2.906110e-06
I1170 n1_M2_35700_60 0 2.781069e-06
I1171 n1_M2_35700_2220 0 2.790661e-06
I1172 n1_M2_35700_4380 0 3.111382e-06
I1173 n1_M2_35700_5460 0 3.250371e-06
I1174 n1_M2_35700_7620 0 3.382260e-06
I1175 n1_M2_35700_9780 0 3.546180e-06
I1176 n1_M2_35700_11940 0 4.900126e-06
I1177 n1_M2_35700_14100 0 7.988682e-06
I1178 n1_M2_35700_16260 0 9.169132e-06
I1179 n1_M2_35700_18420 0 7.579827e-06
I1180 n1_M2_35700_19500 0 8.329777e-06
I1181 n1_M2_35700_21660 0 8.573765e-06
I1182 n1_M2_35700_23820 0 6.945784e-06
I1183 n1_M2_35700_25980 0 7.340961e-06
I1184 n1_M2_35700_28140 0 9.981541e-06
I1185 n1_M2_35700_30300 0 1.135696e-05
I1186 n1_M2_35700_32460 0 2.112446e-05
I1187 n1_M2_35700_33540 0 2.341352e-05
I1188 n1_M2_35700_35700 0 2.158937e-05
I1189 n1_M2_35700_37860 0 2.221680e-05
I1190 n1_M2_35700_40020 0 2.348285e-05
I1191 n1_M2_35700_42180 0 2.260758e-05
I1192 n1_M2_35700_44340 0 2.180516e-05
I1193 n1_M2_35700_46500 0 1.883720e-05
I1194 n1_M2_35700_47580 0 1.305272e-05
I1195 n1_M2_35700_49740 0 1.071788e-05
I1196 n1_M2_35700_51900 0 1.029347e-05
I1197 n1_M2_35700_54060 0 6.328101e-06
I1198 n1_M2_35700_56220 0 1.014558e-05
I1199 n1_M2_35700_58380 0 2.262353e-05
I1200 n1_M2_35700_59460 0 2.489924e-05
I1201 n1_M2_35700_61620 0 1.966566e-05
I1202 n1_M2_35700_63780 0 1.497977e-05
I1203 n1_M2_35700_65940 0 1.302670e-05
I1204 n1_M2_35700_68100 0 8.834442e-06
I1205 n1_M2_35700_70260 0 7.252074e-06
I1206 n1_M2_35700_72420 0 7.018182e-06
I1207 n1_M2_35700_73500 0 1.194183e-05
I1208 n1_M2_35700_75660 0 2.188434e-05
I1209 n1_M2_35700_77820 0 2.351149e-05
I1210 n1_M2_35700_79980 0 2.311108e-05
I1211 n1_M2_35700_82140 0 2.243221e-05
I1212 n1_M2_35700_84300 0 1.729142e-05
I1213 n1_M2_35700_86460 0 1.861857e-05
I1214 n1_M2_35700_87540 0 2.484788e-05
I1215 n1_M2_35700_89700 0 2.226500e-05
I1216 n1_M2_35700_91860 0 1.621001e-05
I1217 n1_M2_35700_94020 0 1.748448e-05
I1218 n1_M2_35700_96180 0 1.858393e-05
I1219 n1_M2_35700_98340 0 1.963262e-05
I1220 n1_M2_35700_100500 0 1.710694e-05
I1221 n1_M2_35700_101580 0 1.571565e-05
I1222 n1_M2_35700_103740 0 2.036049e-05
I1223 n1_M2_35700_105900 0 2.188164e-05
I1224 n1_M2_35700_108060 0 2.205136e-05
I1225 n1_M2_35700_110220 0 1.835841e-05
I1226 n1_M2_35700_112380 0 1.390702e-05
I1227 n1_M2_35700_113460 0 1.242515e-05
I1228 n1_M2_35700_115620 0 1.330153e-05
I1229 n1_M2_35700_117780 0 1.187509e-05
I1230 n1_M2_35700_119940 0 9.736804e-06
I1231 n1_M2_35700_122100 0 5.444754e-06
I1232 n1_M2_35700_124260 0 3.272358e-06
I1233 n1_M2_35700_126420 0 2.798287e-06
I1234 n1_M2_35700_127500 0 2.953721e-06
I1235 n1_M2_37860_60 0 2.781076e-06
I1236 n1_M2_37860_2220 0 2.787188e-06
I1237 n1_M2_37860_4380 0 3.071119e-06
I1238 n1_M2_37860_5460 0 3.279630e-06
I1239 n1_M2_37860_7620 0 4.388051e-06
I1240 n1_M2_37860_9780 0 5.974189e-06
I1241 n1_M2_37860_11940 0 7.582211e-06
I1242 n1_M2_37860_14100 0 9.488660e-06
I1243 n1_M2_37860_16260 0 9.217175e-06
I1244 n1_M2_37860_18420 0 7.218175e-06
I1245 n1_M2_37860_19500 0 7.628019e-06
I1246 n1_M2_37860_21660 0 8.853658e-06
I1247 n1_M2_37860_23820 0 7.132746e-06
I1248 n1_M2_37860_25980 0 8.839179e-06
I1249 n1_M2_37860_28140 0 1.126718e-05
I1250 n1_M2_37860_30300 0 1.261946e-05
I1251 n1_M2_37860_32460 0 1.919264e-05
I1252 n1_M2_37860_33540 0 2.128060e-05
I1253 n1_M2_37860_35700 0 2.036703e-05
I1254 n1_M2_37860_37860 0 2.040473e-05
I1255 n1_M2_37860_40020 0 2.333390e-05
I1256 n1_M2_37860_42180 0 2.236076e-05
I1257 n1_M2_37860_44340 0 1.563729e-05
I1258 n1_M2_37860_46500 0 1.299207e-05
I1259 n1_M2_37860_47580 0 1.056923e-05
I1260 n1_M2_37860_49740 0 9.626654e-06
I1261 n1_M2_37860_51900 0 1.067060e-05
I1262 n1_M2_37860_54060 0 6.557185e-06
I1263 n1_M2_37860_56220 0 7.264618e-06
I1264 n1_M2_37860_58380 0 1.729149e-05
I1265 n1_M2_37860_59460 0 2.040757e-05
I1266 n1_M2_37860_61620 0 1.429238e-05
I1267 n1_M2_37860_63780 0 1.325071e-05
I1268 n1_M2_37860_65940 0 1.075664e-05
I1269 n1_M2_37860_68100 0 6.801635e-06
I1270 n1_M2_37860_70260 0 5.317562e-06
I1271 n1_M2_37860_72420 0 4.594457e-06
I1272 n1_M2_37860_73500 0 7.090744e-06
I1273 n1_M2_37860_75660 0 1.621838e-05
I1274 n1_M2_37860_77820 0 2.011890e-05
I1275 n1_M2_37860_79980 0 2.074766e-05
I1276 n1_M2_37860_82140 0 1.875314e-05
I1277 n1_M2_37860_84300 0 1.376221e-05
I1278 n1_M2_37860_86460 0 1.435629e-05
I1279 n1_M2_37860_87540 0 2.332727e-05
I1280 n1_M2_37860_89700 0 2.117701e-05
I1281 n1_M2_37860_91860 0 1.262835e-05
I1282 n1_M2_37860_94020 0 1.265632e-05
I1283 n1_M2_37860_96180 0 1.148974e-05
I1284 n1_M2_37860_98340 0 1.223752e-05
I1285 n1_M2_37860_100500 0 9.250180e-06
I1286 n1_M2_37860_101580 0 6.811446e-06
I1287 n1_M2_37860_103740 0 8.428632e-06
I1288 n1_M2_37860_105900 0 1.162559e-05
I1289 n1_M2_37860_108060 0 1.374646e-05
I1290 n1_M2_37860_110220 0 1.173831e-05
I1291 n1_M2_37860_112380 0 1.034315e-05
I1292 n1_M2_37860_113460 0 9.458291e-06
I1293 n1_M2_37860_115620 0 1.136137e-05
I1294 n1_M2_37860_117780 0 1.148327e-05
I1295 n1_M2_37860_119940 0 1.029123e-05
I1296 n1_M2_37860_122100 0 6.807797e-06
I1297 n1_M2_37860_124260 0 3.802390e-06
I1298 n1_M2_37860_126420 0 2.891709e-06
I1299 n1_M2_37860_127500 0 2.918089e-06
I1300 n1_M2_40020_60 0 2.820420e-06
I1301 n1_M2_40020_2220 0 2.780043e-06
I1302 n1_M2_40020_4380 0 3.109179e-06
I1303 n1_M2_40020_5460 0 3.424927e-06
I1304 n1_M2_40020_7620 0 5.641322e-06
I1305 n1_M2_40020_9780 0 8.030746e-06
I1306 n1_M2_40020_11940 0 8.946949e-06
I1307 n1_M2_40020_14100 0 9.324603e-06
I1308 n1_M2_40020_16260 0 7.074703e-06
I1309 n1_M2_40020_18420 0 5.056476e-06
I1310 n1_M2_40020_19500 0 5.672711e-06
I1311 n1_M2_40020_21660 0 6.061448e-06
I1312 n1_M2_40020_23820 0 5.198792e-06
I1313 n1_M2_40020_25980 0 6.697630e-06
I1314 n1_M2_40020_28140 0 8.070794e-06
I1315 n1_M2_40020_30300 0 9.804672e-06
I1316 n1_M2_40020_32460 0 1.476467e-05
I1317 n1_M2_40020_33540 0 1.562869e-05
I1318 n1_M2_40020_35700 0 1.322261e-05
I1319 n1_M2_40020_37860 0 1.424945e-05
I1320 n1_M2_40020_40020 0 1.786851e-05
I1321 n1_M2_40020_42180 0 1.420808e-05
I1322 n1_M2_40020_44340 0 8.395581e-06
I1323 n1_M2_40020_46500 0 7.268232e-06
I1324 n1_M2_40020_47580 0 5.931483e-06
I1325 n1_M2_40020_49740 0 5.524319e-06
I1326 n1_M2_40020_51900 0 5.635510e-06
I1327 n1_M2_40020_54060 0 4.431039e-06
I1328 n1_M2_40020_56220 0 4.764508e-06
I1329 n1_M2_40020_58380 0 7.128791e-06
I1330 n1_M2_40020_59460 0 8.340791e-06
I1331 n1_M2_40020_61620 0 7.362320e-06
I1332 n1_M2_40020_63780 0 6.422091e-06
I1333 n1_M2_40020_65940 0 4.035887e-06
I1334 n1_M2_40020_68100 0 3.472616e-06
I1335 n1_M2_40020_70260 0 3.338863e-06
I1336 n1_M2_40020_72420 0 3.576843e-06
I1337 n1_M2_40020_73500 0 3.998876e-06
I1338 n1_M2_40020_75660 0 6.924226e-06
I1339 n1_M2_40020_77820 0 1.117549e-05
I1340 n1_M2_40020_79980 0 1.569552e-05
I1341 n1_M2_40020_82140 0 1.440523e-05
I1342 n1_M2_40020_84300 0 1.277252e-05
I1343 n1_M2_40020_86460 0 1.560442e-05
I1344 n1_M2_40020_87540 0 2.206138e-05
I1345 n1_M2_40020_89700 0 1.816854e-05
I1346 n1_M2_40020_91860 0 1.221641e-05
I1347 n1_M2_40020_94020 0 9.733096e-06
I1348 n1_M2_40020_96180 0 9.402996e-06
I1349 n1_M2_40020_98340 0 9.803133e-06
I1350 n1_M2_40020_100500 0 7.750354e-06
I1351 n1_M2_40020_101580 0 4.618119e-06
I1352 n1_M2_40020_103740 0 6.121557e-06
I1353 n1_M2_40020_105900 0 6.480603e-06
I1354 n1_M2_40020_108060 0 7.129575e-06
I1355 n1_M2_40020_110220 0 8.385568e-06
I1356 n1_M2_40020_112380 0 6.815838e-06
I1357 n1_M2_40020_113460 0 8.100299e-06
I1358 n1_M2_40020_115620 0 1.041591e-05
I1359 n1_M2_40020_117780 0 1.389170e-05
I1360 n1_M2_40020_119940 0 1.267709e-05
I1361 n1_M2_40020_122100 0 1.082751e-05
I1362 n1_M2_40020_124260 0 5.331895e-06
I1363 n1_M2_40020_126420 0 3.042608e-06
I1364 n1_M2_40020_127500 0 3.124377e-06
I1365 n1_M2_42180_60 0 2.743007e-06
I1366 n1_M2_42180_2220 0 2.725535e-06
I1367 n1_M2_42180_4380 0 3.061379e-06
I1368 n1_M2_42180_5460 0 3.256869e-06
I1369 n1_M2_42180_7620 0 5.037365e-06
I1370 n1_M2_42180_9780 0 6.597455e-06
I1371 n1_M2_42180_11940 0 6.720484e-06
I1372 n1_M2_42180_14100 0 6.643313e-06
I1373 n1_M2_42180_16260 0 5.056751e-06
I1374 n1_M2_42180_18420 0 4.867931e-06
I1375 n1_M2_42180_19500 0 6.303316e-06
I1376 n1_M2_42180_21660 0 7.919620e-06
I1377 n1_M2_42180_23820 0 7.331304e-06
I1378 n1_M2_42180_25980 0 8.243474e-06
I1379 n1_M2_42180_28140 0 8.601808e-06
I1380 n1_M2_42180_30300 0 1.007833e-05
I1381 n1_M2_42180_32460 0 1.863821e-05
I1382 n1_M2_42180_33540 0 1.819076e-05
I1383 n1_M2_42180_35700 0 1.402411e-05
I1384 n1_M2_42180_37860 0 1.435966e-05
I1385 n1_M2_42180_40020 0 1.455585e-05
I1386 n1_M2_42180_42180 0 1.330322e-05
I1387 n1_M2_42180_44340 0 9.936981e-06
I1388 n1_M2_42180_46500 0 6.437391e-06
I1389 n1_M2_42180_47580 0 5.880954e-06
I1390 n1_M2_42180_49740 0 6.630118e-06
I1391 n1_M2_42180_51900 0 6.733064e-06
I1392 n1_M2_42180_54060 0 5.688190e-06
I1393 n1_M2_42180_56220 0 4.513806e-06
I1394 n1_M2_42180_58380 0 5.297012e-06
I1395 n1_M2_42180_59460 0 8.178433e-06
I1396 n1_M2_42180_61620 0 8.764308e-06
I1397 n1_M2_42180_63780 0 6.773576e-06
I1398 n1_M2_42180_65940 0 5.304691e-06
I1399 n1_M2_42180_68100 0 4.484632e-06
I1400 n1_M2_42180_70260 0 3.793704e-06
I1401 n1_M2_42180_72420 0 3.408391e-06
I1402 n1_M2_42180_73500 0 3.454340e-06
I1403 n1_M2_42180_75660 0 4.260179e-06
I1404 n1_M2_42180_77820 0 7.122569e-06
I1405 n1_M2_42180_79980 0 1.382813e-05
I1406 n1_M2_42180_82140 0 2.002062e-05
I1407 n1_M2_42180_84300 0 1.900691e-05
I1408 n1_M2_42180_86460 0 2.094545e-05
I1409 n1_M2_42180_87540 0 2.396256e-05
I1410 n1_M2_42180_89700 0 2.173748e-05
I1411 n1_M2_42180_91860 0 1.954178e-05
I1412 n1_M2_42180_94020 0 1.981722e-05
I1413 n1_M2_42180_96180 0 1.503244e-05
I1414 n1_M2_42180_98340 0 1.338501e-05
I1415 n1_M2_42180_100500 0 1.089328e-05
I1416 n1_M2_42180_101580 0 7.923288e-06
I1417 n1_M2_42180_103740 0 8.435637e-06
I1418 n1_M2_42180_105900 0 9.757873e-06
I1419 n1_M2_42180_108060 0 8.115636e-06
I1420 n1_M2_42180_110220 0 5.845367e-06
I1421 n1_M2_42180_112380 0 4.899074e-06
I1422 n1_M2_42180_113460 0 4.031619e-06
I1423 n1_M2_42180_115620 0 7.336656e-06
I1424 n1_M2_42180_117780 0 1.384471e-05
I1425 n1_M2_42180_119940 0 1.475975e-05
I1426 n1_M2_42180_122100 0 1.357942e-05
I1427 n1_M2_42180_124260 0 6.773706e-06
I1428 n1_M2_42180_126420 0 2.986672e-06
I1429 n1_M2_42180_127500 0 3.127443e-06
I1430 n1_M2_44340_60 0 2.721665e-06
I1431 n1_M2_44340_2220 0 2.673951e-06
I1432 n1_M2_44340_4380 0 2.953803e-06
I1433 n1_M2_44340_5460 0 3.064550e-06
I1434 n1_M2_44340_7620 0 3.701813e-06
I1435 n1_M2_44340_9780 0 4.422094e-06
I1436 n1_M2_44340_11940 0 4.079631e-06
I1437 n1_M2_44340_14100 0 4.135650e-06
I1438 n1_M2_44340_16260 0 3.813368e-06
I1439 n1_M2_44340_18420 0 5.953506e-06
I1440 n1_M2_44340_19500 0 9.028630e-06
I1441 n1_M2_44340_21660 0 1.276815e-05
I1442 n1_M2_44340_23820 0 1.078353e-05
I1443 n1_M2_44340_25980 0 1.051788e-05
I1444 n1_M2_44340_28140 0 9.928342e-06
I1445 n1_M2_44340_30300 0 1.145145e-05
I1446 n1_M2_44340_32460 0 2.218892e-05
I1447 n1_M2_44340_33540 0 2.298896e-05
I1448 n1_M2_44340_35700 0 2.096269e-05
I1449 n1_M2_44340_37860 0 1.865046e-05
I1450 n1_M2_44340_40020 0 1.742653e-05
I1451 n1_M2_44340_42180 0 1.748566e-05
I1452 n1_M2_44340_44340 0 1.538993e-05
I1453 n1_M2_44340_46500 0 1.216829e-05
I1454 n1_M2_44340_47580 0 9.089415e-06
I1455 n1_M2_44340_49740 0 8.531670e-06
I1456 n1_M2_44340_51900 0 9.527777e-06
I1457 n1_M2_44340_54060 0 9.254984e-06
I1458 n1_M2_44340_56220 0 8.433562e-06
I1459 n1_M2_44340_58380 0 1.099657e-05
I1460 n1_M2_44340_59460 0 1.552903e-05
I1461 n1_M2_44340_61620 0 1.421586e-05
I1462 n1_M2_44340_63780 0 1.116542e-05
I1463 n1_M2_44340_65940 0 1.243944e-05
I1464 n1_M2_44340_68100 0 1.056589e-05
I1465 n1_M2_44340_70260 0 8.808191e-06
I1466 n1_M2_44340_72420 0 5.184405e-06
I1467 n1_M2_44340_73500 0 3.808533e-06
I1468 n1_M2_44340_75660 0 4.633928e-06
I1469 n1_M2_44340_77820 0 7.199377e-06
I1470 n1_M2_44340_79980 0 1.464457e-05
I1471 n1_M2_44340_82140 0 2.418683e-05
I1472 n1_M2_44340_84300 0 2.508551e-05
I1473 n1_M2_44340_86460 0 2.487325e-05
I1474 n1_M2_44340_87540 0 2.535817e-05
I1475 n1_M2_44340_89700 0 2.466445e-05
I1476 n1_M2_44340_91860 0 2.390840e-05
I1477 n1_M2_44340_94020 0 2.492298e-05
I1478 n1_M2_44340_96180 0 2.293838e-05
I1479 n1_M2_44340_98340 0 2.044093e-05
I1480 n1_M2_44340_100500 0 1.723045e-05
I1481 n1_M2_44340_101580 0 1.554705e-05
I1482 n1_M2_44340_103740 0 1.643069e-05
I1483 n1_M2_44340_105900 0 1.731293e-05
I1484 n1_M2_44340_108060 0 1.688912e-05
I1485 n1_M2_44340_110220 0 8.746129e-06
I1486 n1_M2_44340_112380 0 4.246606e-06
I1487 n1_M2_44340_113460 0 3.901875e-06
I1488 n1_M2_44340_115620 0 6.776070e-06
I1489 n1_M2_44340_117780 0 1.294433e-05
I1490 n1_M2_44340_119940 0 1.494985e-05
I1491 n1_M2_44340_122100 0 1.596922e-05
I1492 n1_M2_44340_124260 0 8.247533e-06
I1493 n1_M2_44340_126420 0 3.005181e-06
I1494 n1_M2_44340_127500 0 3.202011e-06
I1495 n1_M2_46500_60 0 2.817638e-06
I1496 n1_M2_46500_2220 0 2.717678e-06
I1497 n1_M2_46500_4380 0 2.959585e-06
I1498 n1_M2_46500_5460 0 3.078466e-06
I1499 n1_M2_46500_7620 0 3.141669e-06
I1500 n1_M2_46500_9780 0 3.231322e-06
I1501 n1_M2_46500_11940 0 3.182005e-06
I1502 n1_M2_46500_14100 0 3.357457e-06
I1503 n1_M2_46500_16260 0 4.017432e-06
I1504 n1_M2_46500_18420 0 6.412146e-06
I1505 n1_M2_46500_19500 0 1.194398e-05
I1506 n1_M2_46500_21660 0 1.641606e-05
I1507 n1_M2_46500_23820 0 1.323518e-05
I1508 n1_M2_46500_25980 0 1.150468e-05
I1509 n1_M2_46500_28140 0 9.110292e-06
I1510 n1_M2_46500_30300 0 9.914965e-06
I1511 n1_M2_46500_32460 0 2.197360e-05
I1512 n1_M2_46500_33540 0 2.437371e-05
I1513 n1_M2_46500_35700 0 2.121427e-05
I1514 n1_M2_46500_37860 0 1.582289e-05
I1515 n1_M2_46500_40020 0 1.374164e-05
I1516 n1_M2_46500_42180 0 1.520721e-05
I1517 n1_M2_46500_44340 0 1.831401e-05
I1518 n1_M2_46500_46500 0 1.495501e-05
I1519 n1_M2_46500_47580 0 9.497851e-06
I1520 n1_M2_46500_49740 0 8.048915e-06
I1521 n1_M2_46500_51900 0 1.047717e-05
I1522 n1_M2_46500_54060 0 1.267325e-05
I1523 n1_M2_46500_56220 0 1.343607e-05
I1524 n1_M2_46500_58380 0 1.610564e-05
I1525 n1_M2_46500_59460 0 1.750480e-05
I1526 n1_M2_46500_61620 0 1.735922e-05
I1527 n1_M2_46500_63780 0 1.783100e-05
I1528 n1_M2_46500_65940 0 2.225535e-05
I1529 n1_M2_46500_68100 0 2.189959e-05
I1530 n1_M2_46500_70260 0 1.926197e-05
I1531 n1_M2_46500_72420 0 1.158519e-05
I1532 n1_M2_46500_73500 0 7.242111e-06
I1533 n1_M2_46500_75660 0 6.776854e-06
I1534 n1_M2_46500_77820 0 1.001175e-05
I1535 n1_M2_46500_79980 0 1.691359e-05
I1536 n1_M2_46500_82140 0 2.466027e-05
I1537 n1_M2_46500_84300 0 2.520381e-05
I1538 n1_M2_46500_86460 0 2.597991e-05
I1539 n1_M2_46500_87540 0 2.612176e-05
I1540 n1_M2_46500_89700 0 2.593927e-05
I1541 n1_M2_46500_91860 0 2.577516e-05
I1542 n1_M2_46500_94020 0 2.623852e-05
I1543 n1_M2_46500_96180 0 2.416280e-05
I1544 n1_M2_46500_98340 0 2.274182e-05
I1545 n1_M2_46500_100500 0 2.210808e-05
I1546 n1_M2_46500_101580 0 2.123178e-05
I1547 n1_M2_46500_103740 0 2.195411e-05
I1548 n1_M2_46500_105900 0 2.222748e-05
I1549 n1_M2_46500_108060 0 1.754948e-05
I1550 n1_M2_46500_110220 0 7.549619e-06
I1551 n1_M2_46500_112380 0 4.382615e-06
I1552 n1_M2_46500_113460 0 3.371413e-06
I1553 n1_M2_46500_115620 0 5.621927e-06
I1554 n1_M2_46500_117780 0 1.076724e-05
I1555 n1_M2_46500_119940 0 1.242604e-05
I1556 n1_M2_46500_122100 0 1.605622e-05
I1557 n1_M2_46500_124260 0 7.438540e-06
I1558 n1_M2_46500_126420 0 2.996201e-06
I1559 n1_M2_46500_127500 0 3.205054e-06
I1560 n1_M2_47580_60 0 2.850963e-06
I1561 n1_M2_47580_2220 0 2.823176e-06
I1562 n1_M2_47580_4380 0 3.008061e-06
I1563 n1_M2_47580_5460 0 3.090322e-06
I1564 n1_M2_47580_7620 0 3.204580e-06
I1565 n1_M2_47580_9780 0 3.307928e-06
I1566 n1_M2_47580_11940 0 3.228905e-06
I1567 n1_M2_47580_14100 0 3.494899e-06
I1568 n1_M2_47580_16260 0 5.463276e-06
I1569 n1_M2_47580_18420 0 8.858432e-06
I1570 n1_M2_47580_19500 0 1.445360e-05
I1571 n1_M2_47580_21660 0 1.775844e-05
I1572 n1_M2_47580_23820 0 1.265277e-05
I1573 n1_M2_47580_25980 0 1.104762e-05
I1574 n1_M2_47580_28140 0 1.187840e-05
I1575 n1_M2_47580_30300 0 1.511890e-05
I1576 n1_M2_47580_32460 0 2.326766e-05
I1577 n1_M2_47580_33540 0 2.485300e-05
I1578 n1_M2_47580_35700 0 2.177808e-05
I1579 n1_M2_47580_37860 0 1.449342e-05
I1580 n1_M2_47580_40020 0 1.320239e-05
I1581 n1_M2_47580_42180 0 1.282266e-05
I1582 n1_M2_47580_44340 0 1.598589e-05
I1583 n1_M2_47580_46500 0 1.576376e-05
I1584 n1_M2_47580_47580 0 9.131876e-06
I1585 n1_M2_47580_49740 0 8.239189e-06
I1586 n1_M2_47580_51900 0 1.347965e-05
I1587 n1_M2_47580_54060 0 1.535275e-05
I1588 n1_M2_47580_56220 0 1.478292e-05
I1589 n1_M2_47580_58380 0 1.594707e-05
I1590 n1_M2_47580_59460 0 1.263854e-05
I1591 n1_M2_47580_61620 0 1.250513e-05
I1592 n1_M2_47580_63780 0 1.729041e-05
I1593 n1_M2_47580_65940 0 2.372370e-05
I1594 n1_M2_47580_68100 0 2.570893e-05
I1595 n1_M2_47580_70260 0 2.462292e-05
I1596 n1_M2_47580_72420 0 1.917710e-05
I1597 n1_M2_47580_73500 0 1.147959e-05
I1598 n1_M2_47580_75660 0 8.884170e-06
I1599 n1_M2_47580_77820 0 9.439911e-06
I1600 n1_M2_47580_79980 0 1.439372e-05
I1601 n1_M2_47580_82140 0 2.255354e-05
I1602 n1_M2_47580_84300 0 2.366724e-05
I1603 n1_M2_47580_86460 0 2.514476e-05
I1604 n1_M2_47580_87540 0 2.593209e-05
I1605 n1_M2_47580_89700 0 2.641728e-05
I1606 n1_M2_47580_91860 0 2.599250e-05
I1607 n1_M2_47580_94020 0 2.571666e-05
I1608 n1_M2_47580_96180 0 2.301408e-05
I1609 n1_M2_47580_98340 0 2.183616e-05
I1610 n1_M2_47580_100500 0 2.309668e-05
I1611 n1_M2_47580_101580 0 2.360494e-05
I1612 n1_M2_47580_103740 0 2.316303e-05
I1613 n1_M2_47580_105900 0 2.303149e-05
I1614 n1_M2_47580_108060 0 1.917969e-05
I1615 n1_M2_47580_110220 0 1.022371e-05
I1616 n1_M2_47580_112380 0 6.996446e-06
I1617 n1_M2_47580_113460 0 5.000951e-06
I1618 n1_M2_47580_115620 0 7.175701e-06
I1619 n1_M2_47580_117780 0 1.049937e-05
I1620 n1_M2_47580_119940 0 1.181919e-05
I1621 n1_M2_47580_122100 0 1.029488e-05
I1622 n1_M2_47580_124260 0 4.962158e-06
I1623 n1_M2_47580_126420 0 2.816770e-06
I1624 n1_M2_47580_127500 0 2.968238e-06
I1625 n1_M2_49740_60 0 2.832153e-06
I1626 n1_M2_49740_2220 0 2.841100e-06
I1627 n1_M2_49740_4380 0 3.028121e-06
I1628 n1_M2_49740_5460 0 3.109961e-06
I1629 n1_M2_49740_7620 0 3.243336e-06
I1630 n1_M2_49740_9780 0 3.317042e-06
I1631 n1_M2_49740_11940 0 3.374553e-06
I1632 n1_M2_49740_14100 0 4.571450e-06
I1633 n1_M2_49740_16260 0 7.188832e-06
I1634 n1_M2_49740_18420 0 9.863278e-06
I1635 n1_M2_49740_19500 0 1.201062e-05
I1636 n1_M2_49740_21660 0 1.195532e-05
I1637 n1_M2_49740_23820 0 8.699211e-06
I1638 n1_M2_49740_25980 0 9.216961e-06
I1639 n1_M2_49740_28140 0 1.394932e-05
I1640 n1_M2_49740_30300 0 2.021361e-05
I1641 n1_M2_49740_32460 0 2.363254e-05
I1642 n1_M2_49740_33540 0 2.432043e-05
I1643 n1_M2_49740_35700 0 2.183579e-05
I1644 n1_M2_49740_37860 0 1.665129e-05
I1645 n1_M2_49740_40020 0 1.658805e-05
I1646 n1_M2_49740_42180 0 1.376935e-05
I1647 n1_M2_49740_44340 0 1.091159e-05
I1648 n1_M2_49740_46500 0 9.395976e-06
I1649 n1_M2_49740_47580 0 6.940808e-06
I1650 n1_M2_49740_49740 0 8.498344e-06
I1651 n1_M2_49740_51900 0 1.522334e-05
I1652 n1_M2_49740_54060 0 1.584857e-05
I1653 n1_M2_49740_56220 0 1.394819e-05
I1654 n1_M2_49740_58380 0 1.422386e-05
I1655 n1_M2_49740_59460 0 1.073648e-05
I1656 n1_M2_49740_61620 0 8.852578e-06
I1657 n1_M2_49740_63780 0 1.319474e-05
I1658 n1_M2_49740_65940 0 2.099382e-05
I1659 n1_M2_49740_68100 0 2.457375e-05
I1660 n1_M2_49740_70260 0 2.478300e-05
I1661 n1_M2_49740_72420 0 2.158698e-05
I1662 n1_M2_49740_73500 0 1.473491e-05
I1663 n1_M2_49740_75660 0 1.067850e-05
I1664 n1_M2_49740_77820 0 9.028698e-06
I1665 n1_M2_49740_79980 0 1.164053e-05
I1666 n1_M2_49740_82140 0 1.921934e-05
I1667 n1_M2_49740_84300 0 2.209026e-05
I1668 n1_M2_49740_86460 0 2.462399e-05
I1669 n1_M2_49740_87540 0 2.554574e-05
I1670 n1_M2_49740_89700 0 2.601826e-05
I1671 n1_M2_49740_91860 0 2.527154e-05
I1672 n1_M2_49740_94020 0 2.296808e-05
I1673 n1_M2_49740_96180 0 1.857723e-05
I1674 n1_M2_49740_98340 0 1.782703e-05
I1675 n1_M2_49740_100500 0 2.174584e-05
I1676 n1_M2_49740_101580 0 2.359310e-05
I1677 n1_M2_49740_103740 0 2.441456e-05
I1678 n1_M2_49740_105900 0 2.405662e-05
I1679 n1_M2_49740_108060 0 2.128100e-05
I1680 n1_M2_49740_110220 0 1.411142e-05
I1681 n1_M2_49740_112380 0 1.176283e-05
I1682 n1_M2_49740_113460 0 9.571901e-06
I1683 n1_M2_49740_115620 0 9.593901e-06
I1684 n1_M2_49740_117780 0 1.117428e-05
I1685 n1_M2_49740_119940 0 1.130139e-05
I1686 n1_M2_49740_122100 0 7.121231e-06
I1687 n1_M2_49740_124260 0 3.984854e-06
I1688 n1_M2_49740_126420 0 2.806749e-06
I1689 n1_M2_49740_127500 0 2.984723e-06
I1690 n1_M2_51900_60 0 2.782743e-06
I1691 n1_M2_51900_2220 0 2.837732e-06
I1692 n1_M2_51900_4380 0 2.989180e-06
I1693 n1_M2_51900_5460 0 3.162010e-06
I1694 n1_M2_51900_7620 0 3.505615e-06
I1695 n1_M2_51900_9780 0 3.629676e-06
I1696 n1_M2_51900_11940 0 3.906386e-06
I1697 n1_M2_51900_14100 0 5.739874e-06
I1698 n1_M2_51900_16260 0 7.732759e-06
I1699 n1_M2_51900_18420 0 9.457861e-06
I1700 n1_M2_51900_19500 0 1.049694e-05
I1701 n1_M2_51900_21660 0 8.579696e-06
I1702 n1_M2_51900_23820 0 6.489688e-06
I1703 n1_M2_51900_25980 0 8.394816e-06
I1704 n1_M2_51900_28140 0 1.416658e-05
I1705 n1_M2_51900_30300 0 2.139754e-05
I1706 n1_M2_51900_32460 0 2.337404e-05
I1707 n1_M2_51900_33540 0 2.314549e-05
I1708 n1_M2_51900_35700 0 2.132332e-05
I1709 n1_M2_51900_37860 0 1.859522e-05
I1710 n1_M2_51900_40020 0 2.012057e-05
I1711 n1_M2_51900_42180 0 1.767671e-05
I1712 n1_M2_51900_44340 0 1.161003e-05
I1713 n1_M2_51900_46500 0 6.895465e-06
I1714 n1_M2_51900_47580 0 6.632501e-06
I1715 n1_M2_51900_49740 0 9.013124e-06
I1716 n1_M2_51900_51900 0 1.570447e-05
I1717 n1_M2_51900_54060 0 1.475679e-05
I1718 n1_M2_51900_56220 0 1.330806e-05
I1719 n1_M2_51900_58380 0 1.184504e-05
I1720 n1_M2_51900_59460 0 8.149618e-06
I1721 n1_M2_51900_61620 0 6.476800e-06
I1722 n1_M2_51900_63780 0 8.582741e-06
I1723 n1_M2_51900_65940 0 1.544628e-05
I1724 n1_M2_51900_68100 0 2.281206e-05
I1725 n1_M2_51900_70260 0 2.396445e-05
I1726 n1_M2_51900_72420 0 2.242759e-05
I1727 n1_M2_51900_73500 0 1.620229e-05
I1728 n1_M2_51900_75660 0 1.015869e-05
I1729 n1_M2_51900_77820 0 9.575845e-06
I1730 n1_M2_51900_79980 0 1.299039e-05
I1731 n1_M2_51900_82140 0 1.626318e-05
I1732 n1_M2_51900_84300 0 1.905718e-05
I1733 n1_M2_51900_86460 0 2.426077e-05
I1734 n1_M2_51900_87540 0 2.555046e-05
I1735 n1_M2_51900_89700 0 2.534508e-05
I1736 n1_M2_51900_91860 0 2.415182e-05
I1737 n1_M2_51900_94020 0 2.109626e-05
I1738 n1_M2_51900_96180 0 1.632409e-05
I1739 n1_M2_51900_98340 0 1.726200e-05
I1740 n1_M2_51900_100500 0 2.134862e-05
I1741 n1_M2_51900_101580 0 2.334440e-05
I1742 n1_M2_51900_103740 0 2.505656e-05
I1743 n1_M2_51900_105900 0 2.547362e-05
I1744 n1_M2_51900_108060 0 2.417972e-05
I1745 n1_M2_51900_110220 0 2.188330e-05
I1746 n1_M2_51900_112380 0 2.034089e-05
I1747 n1_M2_51900_113460 0 1.568863e-05
I1748 n1_M2_51900_115620 0 1.213501e-05
I1749 n1_M2_51900_117780 0 1.267680e-05
I1750 n1_M2_51900_119940 0 1.177777e-05
I1751 n1_M2_51900_122100 0 5.771478e-06
I1752 n1_M2_51900_124260 0 3.555555e-06
I1753 n1_M2_51900_126420 0 2.890255e-06
I1754 n1_M2_51900_127500 0 3.022227e-06
I1755 n1_M2_54060_60 0 2.744813e-06
I1756 n1_M2_54060_2220 0 2.835267e-06
I1757 n1_M2_54060_4380 0 3.037975e-06
I1758 n1_M2_54060_5460 0 3.313643e-06
I1759 n1_M2_54060_7620 0 5.152943e-06
I1760 n1_M2_54060_9780 0 6.104195e-06
I1761 n1_M2_54060_11940 0 6.309574e-06
I1762 n1_M2_54060_14100 0 7.501980e-06
I1763 n1_M2_54060_16260 0 7.975608e-06
I1764 n1_M2_54060_18420 0 9.000691e-06
I1765 n1_M2_54060_19500 0 1.067961e-05
I1766 n1_M2_54060_21660 0 8.859434e-06
I1767 n1_M2_54060_23820 0 7.332868e-06
I1768 n1_M2_54060_25980 0 9.414633e-06
I1769 n1_M2_54060_28140 0 1.475056e-05
I1770 n1_M2_54060_30300 0 2.173645e-05
I1771 n1_M2_54060_32460 0 2.368265e-05
I1772 n1_M2_54060_33540 0 2.374277e-05
I1773 n1_M2_54060_35700 0 2.239519e-05
I1774 n1_M2_54060_37860 0 2.153400e-05
I1775 n1_M2_54060_40020 0 2.272719e-05
I1776 n1_M2_54060_42180 0 2.190594e-05
I1777 n1_M2_54060_44340 0 1.781041e-05
I1778 n1_M2_54060_46500 0 1.098733e-05
I1779 n1_M2_54060_47580 0 1.075511e-05
I1780 n1_M2_54060_49740 0 1.175738e-05
I1781 n1_M2_54060_51900 0 1.857638e-05
I1782 n1_M2_54060_54060 0 1.507983e-05
I1783 n1_M2_54060_56220 0 1.232681e-05
I1784 n1_M2_54060_58380 0 9.555268e-06
I1785 n1_M2_54060_59460 0 6.038693e-06
I1786 n1_M2_54060_61620 0 5.029347e-06
I1787 n1_M2_54060_63780 0 6.191885e-06
I1788 n1_M2_54060_65940 0 1.001167e-05
I1789 n1_M2_54060_68100 0 1.990801e-05
I1790 n1_M2_54060_70260 0 2.246610e-05
I1791 n1_M2_54060_72420 0 2.114450e-05
I1792 n1_M2_54060_73500 0 1.314665e-05
I1793 n1_M2_54060_75660 0 7.159832e-06
I1794 n1_M2_54060_77820 0 7.140151e-06
I1795 n1_M2_54060_79980 0 1.150893e-05
I1796 n1_M2_54060_82140 0 1.404043e-05
I1797 n1_M2_54060_84300 0 1.658042e-05
I1798 n1_M2_54060_86460 0 2.323734e-05
I1799 n1_M2_54060_87540 0 2.516289e-05
I1800 n1_M2_54060_89700 0 2.425737e-05
I1801 n1_M2_54060_91860 0 2.296163e-05
I1802 n1_M2_54060_94020 0 2.243942e-05
I1803 n1_M2_54060_96180 0 1.850730e-05
I1804 n1_M2_54060_98340 0 1.662049e-05
I1805 n1_M2_54060_100500 0 2.016542e-05
I1806 n1_M2_54060_101580 0 2.360418e-05
I1807 n1_M2_54060_103740 0 2.584415e-05
I1808 n1_M2_54060_105900 0 2.500590e-05
I1809 n1_M2_54060_108060 0 2.617562e-05
I1810 n1_M2_54060_110220 0 2.600866e-05
I1811 n1_M2_54060_112380 0 2.512527e-05
I1812 n1_M2_54060_113460 0 2.056837e-05
I1813 n1_M2_54060_115620 0 1.330029e-05
I1814 n1_M2_54060_117780 0 1.143745e-05
I1815 n1_M2_54060_119940 0 1.040770e-05
I1816 n1_M2_54060_122100 0 5.492567e-06
I1817 n1_M2_54060_124260 0 3.691032e-06
I1818 n1_M2_54060_126420 0 2.946604e-06
I1819 n1_M2_54060_127500 0 3.003780e-06
I1820 n1_M2_56220_60 0 2.858392e-06
I1821 n1_M2_56220_2220 0 2.839243e-06
I1822 n1_M2_56220_4380 0 3.021759e-06
I1823 n1_M2_56220_5460 0 4.369257e-06
I1824 n1_M2_56220_7620 0 1.196087e-05
I1825 n1_M2_56220_9780 0 1.302365e-05
I1826 n1_M2_56220_11940 0 1.004501e-05
I1827 n1_M2_56220_14100 0 8.664285e-06
I1828 n1_M2_56220_16260 0 7.769900e-06
I1829 n1_M2_56220_18420 0 7.819357e-06
I1830 n1_M2_56220_19500 0 9.581160e-06
I1831 n1_M2_56220_21660 0 1.012486e-05
I1832 n1_M2_56220_23820 0 1.011622e-05
I1833 n1_M2_56220_25980 0 1.063670e-05
I1834 n1_M2_56220_28140 0 1.436590e-05
I1835 n1_M2_56220_30300 0 2.132266e-05
I1836 n1_M2_56220_32460 0 2.444993e-05
I1837 n1_M2_56220_33540 0 2.528346e-05
I1838 n1_M2_56220_35700 0 2.397819e-05
I1839 n1_M2_56220_37860 0 2.270913e-05
I1840 n1_M2_56220_40020 0 2.356611e-05
I1841 n1_M2_56220_42180 0 2.308842e-05
I1842 n1_M2_56220_44340 0 2.110331e-05
I1843 n1_M2_56220_46500 0 1.804425e-05
I1844 n1_M2_56220_47580 0 1.658807e-05
I1845 n1_M2_56220_49740 0 1.566955e-05
I1846 n1_M2_56220_51900 0 2.038230e-05
I1847 n1_M2_56220_54060 0 1.666548e-05
I1848 n1_M2_56220_56220 0 1.201956e-05
I1849 n1_M2_56220_58380 0 8.595199e-06
I1850 n1_M2_56220_59460 0 6.032664e-06
I1851 n1_M2_56220_61620 0 5.488642e-06
I1852 n1_M2_56220_63780 0 7.211240e-06
I1853 n1_M2_56220_65940 0 1.222647e-05
I1854 n1_M2_56220_68100 0 1.793356e-05
I1855 n1_M2_56220_70260 0 2.094392e-05
I1856 n1_M2_56220_72420 0 2.014347e-05
I1857 n1_M2_56220_73500 0 1.106724e-05
I1858 n1_M2_56220_75660 0 5.517980e-06
I1859 n1_M2_56220_77820 0 6.453488e-06
I1860 n1_M2_56220_79980 0 9.685463e-06
I1861 n1_M2_56220_82140 0 1.178380e-05
I1862 n1_M2_56220_84300 0 1.425609e-05
I1863 n1_M2_56220_86460 0 2.252698e-05
I1864 n1_M2_56220_87540 0 2.449054e-05
I1865 n1_M2_56220_89700 0 2.405852e-05
I1866 n1_M2_56220_91860 0 2.356221e-05
I1867 n1_M2_56220_94020 0 2.409257e-05
I1868 n1_M2_56220_96180 0 2.154698e-05
I1869 n1_M2_56220_98340 0 1.913259e-05
I1870 n1_M2_56220_100500 0 1.862875e-05
I1871 n1_M2_56220_101580 0 2.197911e-05
I1872 n1_M2_56220_103740 0 2.584791e-05
I1873 n1_M2_56220_105900 0 2.546542e-05
I1874 n1_M2_56220_108060 0 2.621419e-05
I1875 n1_M2_56220_110220 0 2.619523e-05
I1876 n1_M2_56220_112380 0 2.611186e-05
I1877 n1_M2_56220_113460 0 2.189817e-05
I1878 n1_M2_56220_115620 0 1.347168e-05
I1879 n1_M2_56220_117780 0 1.048114e-05
I1880 n1_M2_56220_119940 0 9.365781e-06
I1881 n1_M2_56220_122100 0 7.613754e-06
I1882 n1_M2_56220_124260 0 4.433686e-06
I1883 n1_M2_56220_126420 0 3.326665e-06
I1884 n1_M2_56220_127500 0 2.963145e-06
I1885 n1_M2_58380_60 0 2.948898e-06
I1886 n1_M2_58380_2220 0 2.842168e-06
I1887 n1_M2_58380_4380 0 2.996632e-06
I1888 n1_M2_58380_5460 0 5.382969e-06
I1889 n1_M2_58380_7620 0 1.624603e-05
I1890 n1_M2_58380_9780 0 1.582178e-05
I1891 n1_M2_58380_11940 0 8.874327e-06
I1892 n1_M2_58380_14100 0 6.247909e-06
I1893 n1_M2_58380_16260 0 5.549839e-06
I1894 n1_M2_58380_18420 0 5.951185e-06
I1895 n1_M2_58380_19500 0 7.879259e-06
I1896 n1_M2_58380_21660 0 9.523773e-06
I1897 n1_M2_58380_23820 0 7.373735e-06
I1898 n1_M2_58380_25980 0 8.095735e-06
I1899 n1_M2_58380_28140 0 9.930311e-06
I1900 n1_M2_58380_30300 0 1.722630e-05
I1901 n1_M2_58380_32460 0 2.438517e-05
I1902 n1_M2_58380_33540 0 2.594220e-05
I1903 n1_M2_58380_35700 0 2.433584e-05
I1904 n1_M2_58380_37860 0 2.286495e-05
I1905 n1_M2_58380_40020 0 2.296144e-05
I1906 n1_M2_58380_42180 0 2.278584e-05
I1907 n1_M2_58380_44340 0 2.241236e-05
I1908 n1_M2_58380_46500 0 2.158562e-05
I1909 n1_M2_58380_47580 0 1.995013e-05
I1910 n1_M2_58380_49740 0 1.931001e-05
I1911 n1_M2_58380_51900 0 2.131630e-05
I1912 n1_M2_58380_54060 0 1.562689e-05
I1913 n1_M2_58380_56220 0 9.597639e-06
I1914 n1_M2_58380_58380 0 6.319914e-06
I1915 n1_M2_58380_59460 0 4.080162e-06
I1916 n1_M2_58380_61620 0 4.118309e-06
I1917 n1_M2_58380_63780 0 5.539792e-06
I1918 n1_M2_58380_65940 0 1.072473e-05
I1919 n1_M2_58380_68100 0 1.488219e-05
I1920 n1_M2_58380_70260 0 1.671495e-05
I1921 n1_M2_58380_72420 0 1.505502e-05
I1922 n1_M2_58380_73500 0 8.056091e-06
I1923 n1_M2_58380_75660 0 4.032557e-06
I1924 n1_M2_58380_77820 0 5.186753e-06
I1925 n1_M2_58380_79980 0 6.902048e-06
I1926 n1_M2_58380_82140 0 6.797020e-06
I1927 n1_M2_58380_84300 0 8.836845e-06
I1928 n1_M2_58380_86460 0 2.006782e-05
I1929 n1_M2_58380_87540 0 2.298574e-05
I1930 n1_M2_58380_89700 0 2.236199e-05
I1931 n1_M2_58380_91860 0 2.289478e-05
I1932 n1_M2_58380_94020 0 2.275496e-05
I1933 n1_M2_58380_96180 0 2.136512e-05
I1934 n1_M2_58380_98340 0 1.887257e-05
I1935 n1_M2_58380_100500 0 1.290583e-05
I1936 n1_M2_58380_101580 0 1.037270e-05
I1937 n1_M2_58380_103740 0 1.471929e-05
I1938 n1_M2_58380_105900 0 2.095832e-05
I1939 n1_M2_58380_108060 0 2.428339e-05
I1940 n1_M2_58380_110220 0 2.534835e-05
I1941 n1_M2_58380_112380 0 2.572327e-05
I1942 n1_M2_58380_113460 0 2.190255e-05
I1943 n1_M2_58380_115620 0 1.441400e-05
I1944 n1_M2_58380_117780 0 1.114717e-05
I1945 n1_M2_58380_119940 0 8.626819e-06
I1946 n1_M2_58380_122100 0 7.865498e-06
I1947 n1_M2_58380_124260 0 4.313903e-06
I1948 n1_M2_58380_126420 0 3.262036e-06
I1949 n1_M2_58380_127500 0 2.969206e-06
I1950 n1_M2_59460_60 0 2.948918e-06
I1951 n1_M2_59460_2220 0 2.869751e-06
I1952 n1_M2_59460_4380 0 3.031590e-06
I1953 n1_M2_59460_5460 0 5.609540e-06
I1954 n1_M2_59460_7620 0 1.499413e-05
I1955 n1_M2_59460_9780 0 1.586849e-05
I1956 n1_M2_59460_11940 0 8.890310e-06
I1957 n1_M2_59460_14100 0 5.424403e-06
I1958 n1_M2_59460_16260 0 4.796137e-06
I1959 n1_M2_59460_18420 0 4.594671e-06
I1960 n1_M2_59460_19500 0 7.256004e-06
I1961 n1_M2_59460_21660 0 1.089879e-05
I1962 n1_M2_59460_23820 0 8.516736e-06
I1963 n1_M2_59460_25980 0 7.030640e-06
I1964 n1_M2_59460_28140 0 8.048405e-06
I1965 n1_M2_59460_30300 0 1.298101e-05
I1966 n1_M2_59460_32460 0 2.301437e-05
I1967 n1_M2_59460_33540 0 2.618826e-05
I1968 n1_M2_59460_35700 0 2.508260e-05
I1969 n1_M2_59460_37860 0 2.354968e-05
I1970 n1_M2_59460_40020 0 2.387987e-05
I1971 n1_M2_59460_42180 0 2.291370e-05
I1972 n1_M2_59460_44340 0 2.353641e-05
I1973 n1_M2_59460_46500 0 2.421224e-05
I1974 n1_M2_59460_47580 0 2.285494e-05
I1975 n1_M2_59460_49740 0 2.210775e-05
I1976 n1_M2_59460_51900 0 2.219769e-05
I1977 n1_M2_59460_54060 0 1.549008e-05
I1978 n1_M2_59460_56220 0 9.296561e-06
I1979 n1_M2_59460_58380 0 6.463007e-06
I1980 n1_M2_59460_59460 0 4.141537e-06
I1981 n1_M2_59460_61620 0 3.728221e-06
I1982 n1_M2_59460_63780 0 4.165402e-06
I1983 n1_M2_59460_65940 0 6.336054e-06
I1984 n1_M2_59460_68100 0 8.963525e-06
I1985 n1_M2_59460_70260 0 1.067871e-05
I1986 n1_M2_59460_72420 0 8.304565e-06
I1987 n1_M2_59460_73500 0 5.090508e-06
I1988 n1_M2_59460_75660 0 4.611924e-06
I1989 n1_M2_59460_77820 0 4.320447e-06
I1990 n1_M2_59460_79980 0 4.648924e-06
I1991 n1_M2_59460_82140 0 6.267522e-06
I1992 n1_M2_59460_84300 0 6.666677e-06
I1993 n1_M2_59460_86460 0 1.318235e-05
I1994 n1_M2_59460_87540 0 2.083703e-05
I1995 n1_M2_59460_89700 0 2.118199e-05
I1996 n1_M2_59460_91860 0 2.153309e-05
I1997 n1_M2_59460_94020 0 2.096542e-05
I1998 n1_M2_59460_96180 0 1.479505e-05
I1999 n1_M2_59460_98340 0 9.064446e-06
I2000 n1_M2_59460_100500 0 6.373207e-06
I2001 n1_M2_59460_101580 0 3.813330e-06
I2002 n1_M2_59460_103740 0 4.266921e-06
I2003 n1_M2_59460_105900 0 7.130754e-06
I2004 n1_M2_59460_108060 0 1.433690e-05
I2005 n1_M2_59460_110220 0 1.892191e-05
I2006 n1_M2_59460_112380 0 2.298641e-05
I2007 n1_M2_59460_113460 0 2.148564e-05
I2008 n1_M2_59460_115620 0 1.508874e-05
I2009 n1_M2_59460_117780 0 1.293968e-05
I2010 n1_M2_59460_119940 0 1.189027e-05
I2011 n1_M2_59460_122100 0 1.176150e-05
I2012 n1_M2_59460_124260 0 7.239939e-06
I2013 n1_M2_59460_126420 0 3.741563e-06
I2014 n1_M2_59460_127500 0 3.064565e-06
I2015 n1_M2_61620_60 0 2.951824e-06
I2016 n1_M2_61620_2220 0 2.926910e-06
I2017 n1_M2_61620_4380 0 3.129960e-06
I2018 n1_M2_61620_5460 0 5.936221e-06
I2019 n1_M2_61620_7620 0 1.355729e-05
I2020 n1_M2_61620_9780 0 1.451742e-05
I2021 n1_M2_61620_11940 0 1.002433e-05
I2022 n1_M2_61620_14100 0 5.932890e-06
I2023 n1_M2_61620_16260 0 4.697372e-06
I2024 n1_M2_61620_18420 0 4.384586e-06
I2025 n1_M2_61620_19500 0 7.150836e-06
I2026 n1_M2_61620_21660 0 1.097663e-05
I2027 n1_M2_61620_23820 0 7.950148e-06
I2028 n1_M2_61620_25980 0 5.743639e-06
I2029 n1_M2_61620_28140 0 7.284742e-06
I2030 n1_M2_61620_30300 0 1.098025e-05
I2031 n1_M2_61620_32460 0 2.122857e-05
I2032 n1_M2_61620_33540 0 2.529718e-05
I2033 n1_M2_61620_35700 0 2.546518e-05
I2034 n1_M2_61620_37860 0 2.466167e-05
I2035 n1_M2_61620_40020 0 2.507950e-05
I2036 n1_M2_61620_42180 0 2.468306e-05
I2037 n1_M2_61620_44340 0 2.507606e-05
I2038 n1_M2_61620_46500 0 2.552518e-05
I2039 n1_M2_61620_47580 0 2.446111e-05
I2040 n1_M2_61620_49740 0 2.354592e-05
I2041 n1_M2_61620_51900 0 2.327497e-05
I2042 n1_M2_61620_54060 0 1.746593e-05
I2043 n1_M2_61620_56220 0 1.012018e-05
I2044 n1_M2_61620_58380 0 6.705662e-06
I2045 n1_M2_61620_59460 0 4.679733e-06
I2046 n1_M2_61620_61620 0 4.121745e-06
I2047 n1_M2_61620_63780 0 3.831812e-06
I2048 n1_M2_61620_65940 0 4.799040e-06
I2049 n1_M2_61620_68100 0 6.310800e-06
I2050 n1_M2_61620_70260 0 9.519877e-06
I2051 n1_M2_61620_72420 0 9.121076e-06
I2052 n1_M2_61620_73500 0 6.241691e-06
I2053 n1_M2_61620_75660 0 5.945789e-06
I2054 n1_M2_61620_77820 0 6.369286e-06
I2055 n1_M2_61620_79980 0 7.330699e-06
I2056 n1_M2_61620_82140 0 8.499256e-06
I2057 n1_M2_61620_84300 0 1.086501e-05
I2058 n1_M2_61620_86460 0 1.599783e-05
I2059 n1_M2_61620_87540 0 2.232667e-05
I2060 n1_M2_61620_89700 0 2.436682e-05
I2061 n1_M2_61620_91860 0 2.324815e-05
I2062 n1_M2_61620_94020 0 1.930103e-05
I2063 n1_M2_61620_96180 0 8.320295e-06
I2064 n1_M2_61620_98340 0 5.445618e-06
I2065 n1_M2_61620_100500 0 4.095328e-06
I2066 n1_M2_61620_101580 0 3.437016e-06
I2067 n1_M2_61620_103740 0 3.320722e-06
I2068 n1_M2_61620_105900 0 3.571561e-06
I2069 n1_M2_61620_108060 0 6.197967e-06
I2070 n1_M2_61620_110220 0 1.004817e-05
I2071 n1_M2_61620_112380 0 1.616048e-05
I2072 n1_M2_61620_113460 0 1.968253e-05
I2073 n1_M2_61620_115620 0 1.467048e-05
I2074 n1_M2_61620_117780 0 1.230587e-05
I2075 n1_M2_61620_119940 0 1.419887e-05
I2076 n1_M2_61620_122100 0 1.656215e-05
I2077 n1_M2_61620_124260 0 1.009537e-05
I2078 n1_M2_61620_126420 0 3.891927e-06
I2079 n1_M2_61620_127500 0 3.110493e-06
I2080 n1_M2_63780_60 0 2.925897e-06
I2081 n1_M2_63780_2220 0 2.879172e-06
I2082 n1_M2_63780_4380 0 3.133087e-06
I2083 n1_M2_63780_5460 0 6.236158e-06
I2084 n1_M2_63780_7620 0 1.277321e-05
I2085 n1_M2_63780_9780 0 1.245041e-05
I2086 n1_M2_63780_11940 0 9.730938e-06
I2087 n1_M2_63780_14100 0 7.290963e-06
I2088 n1_M2_63780_16260 0 5.414407e-06
I2089 n1_M2_63780_18420 0 5.800172e-06
I2090 n1_M2_63780_19500 0 8.034108e-06
I2091 n1_M2_63780_21660 0 9.655403e-06
I2092 n1_M2_63780_23820 0 7.103404e-06
I2093 n1_M2_63780_25980 0 5.836234e-06
I2094 n1_M2_63780_28140 0 6.591412e-06
I2095 n1_M2_63780_30300 0 9.357271e-06
I2096 n1_M2_63780_32460 0 2.087849e-05
I2097 n1_M2_63780_33540 0 2.509481e-05
I2098 n1_M2_63780_35700 0 2.562226e-05
I2099 n1_M2_63780_37860 0 2.536600e-05
I2100 n1_M2_63780_40020 0 2.616101e-05
I2101 n1_M2_63780_42180 0 2.607186e-05
I2102 n1_M2_63780_44340 0 2.561165e-05
I2103 n1_M2_63780_46500 0 2.590840e-05
I2104 n1_M2_63780_47580 0 2.545478e-05
I2105 n1_M2_63780_49740 0 2.500992e-05
I2106 n1_M2_63780_51900 0 2.490087e-05
I2107 n1_M2_63780_54060 0 2.066770e-05
I2108 n1_M2_63780_56220 0 1.333525e-05
I2109 n1_M2_63780_58380 0 9.639068e-06
I2110 n1_M2_63780_59460 0 7.287177e-06
I2111 n1_M2_63780_61620 0 6.323589e-06
I2112 n1_M2_63780_63780 0 5.901976e-06
I2113 n1_M2_63780_65940 0 7.999007e-06
I2114 n1_M2_63780_68100 0 1.027966e-05
I2115 n1_M2_63780_70260 0 1.296581e-05
I2116 n1_M2_63780_72420 0 1.191949e-05
I2117 n1_M2_63780_73500 0 8.447799e-06
I2118 n1_M2_63780_75660 0 9.806672e-06
I2119 n1_M2_63780_77820 0 1.380035e-05
I2120 n1_M2_63780_79980 0 1.784974e-05
I2121 n1_M2_63780_82140 0 1.673428e-05
I2122 n1_M2_63780_84300 0 1.731115e-05
I2123 n1_M2_63780_86460 0 2.235066e-05
I2124 n1_M2_63780_87540 0 2.436406e-05
I2125 n1_M2_63780_89700 0 2.590271e-05
I2126 n1_M2_63780_91860 0 2.581676e-05
I2127 n1_M2_63780_94020 0 2.266135e-05
I2128 n1_M2_63780_96180 0 1.596170e-05
I2129 n1_M2_63780_98340 0 1.052006e-05
I2130 n1_M2_63780_100500 0 7.375102e-06
I2131 n1_M2_63780_101580 0 5.042327e-06
I2132 n1_M2_63780_103740 0 3.518275e-06
I2133 n1_M2_63780_105900 0 3.527266e-06
I2134 n1_M2_63780_108060 0 4.576236e-06
I2135 n1_M2_63780_110220 0 7.390556e-06
I2136 n1_M2_63780_112380 0 1.625805e-05
I2137 n1_M2_63780_113460 0 2.030252e-05
I2138 n1_M2_63780_115620 0 1.710114e-05
I2139 n1_M2_63780_117780 0 1.292787e-05
I2140 n1_M2_63780_119940 0 1.575335e-05
I2141 n1_M2_63780_122100 0 2.080578e-05
I2142 n1_M2_63780_124260 0 1.244552e-05
I2143 n1_M2_63780_126420 0 4.191940e-06
I2144 n1_M2_63780_127500 0 3.014693e-06
I2145 n1_M2_65940_60 0 2.894961e-06
I2146 n1_M2_65940_2220 0 2.811205e-06
I2147 n1_M2_65940_4380 0 3.442865e-06
I2148 n1_M2_65940_5460 0 9.256436e-06
I2149 n1_M2_65940_7620 0 1.607643e-05
I2150 n1_M2_65940_9780 0 1.547512e-05
I2151 n1_M2_65940_11940 0 1.273199e-05
I2152 n1_M2_65940_14100 0 1.138792e-05
I2153 n1_M2_65940_16260 0 1.075206e-05
I2154 n1_M2_65940_18420 0 1.125297e-05
I2155 n1_M2_65940_19500 0 1.382706e-05
I2156 n1_M2_65940_21660 0 1.525749e-05
I2157 n1_M2_65940_23820 0 1.265284e-05
I2158 n1_M2_65940_25980 0 1.087663e-05
I2159 n1_M2_65940_28140 0 1.169255e-05
I2160 n1_M2_65940_30300 0 1.089089e-05
I2161 n1_M2_65940_32460 0 1.777029e-05
I2162 n1_M2_65940_33540 0 2.454176e-05
I2163 n1_M2_65940_35700 0 2.578148e-05
I2164 n1_M2_65940_37860 0 2.547819e-05
I2165 n1_M2_65940_40020 0 2.635902e-05
I2166 n1_M2_65940_42180 0 2.565742e-05
I2167 n1_M2_65940_44340 0 2.514670e-05
I2168 n1_M2_65940_46500 0 2.586737e-05
I2169 n1_M2_65940_47580 0 2.593706e-05
I2170 n1_M2_65940_49740 0 2.532689e-05
I2171 n1_M2_65940_51900 0 2.476058e-05
I2172 n1_M2_65940_54060 0 1.875534e-05
I2173 n1_M2_65940_56220 0 1.150338e-05
I2174 n1_M2_65940_58380 0 1.132450e-05
I2175 n1_M2_65940_59460 0 1.061168e-05
I2176 n1_M2_65940_61620 0 9.899493e-06
I2177 n1_M2_65940_63780 0 1.125691e-05
I2178 n1_M2_65940_65940 0 1.200826e-05
I2179 n1_M2_65940_68100 0 1.276115e-05
I2180 n1_M2_65940_70260 0 1.316152e-05
I2181 n1_M2_65940_72420 0 9.576495e-06
I2182 n1_M2_65940_73500 0 1.027214e-05
I2183 n1_M2_65940_75660 0 1.544859e-05
I2184 n1_M2_65940_77820 0 1.842308e-05
I2185 n1_M2_65940_79980 0 2.216789e-05
I2186 n1_M2_65940_82140 0 2.279807e-05
I2187 n1_M2_65940_84300 0 2.218373e-05
I2188 n1_M2_65940_86460 0 2.480825e-05
I2189 n1_M2_65940_87540 0 2.589462e-05
I2190 n1_M2_65940_89700 0 2.614129e-05
I2191 n1_M2_65940_91860 0 2.627007e-05
I2192 n1_M2_65940_94020 0 2.628890e-05
I2193 n1_M2_65940_96180 0 2.478502e-05
I2194 n1_M2_65940_98340 0 2.328170e-05
I2195 n1_M2_65940_100500 0 1.778102e-05
I2196 n1_M2_65940_101580 0 9.768617e-06
I2197 n1_M2_65940_103740 0 6.012745e-06
I2198 n1_M2_65940_105900 0 5.115051e-06
I2199 n1_M2_65940_108060 0 5.345012e-06
I2200 n1_M2_65940_110220 0 8.407528e-06
I2201 n1_M2_65940_112380 0 1.905162e-05
I2202 n1_M2_65940_113460 0 1.991022e-05
I2203 n1_M2_65940_115620 0 1.592921e-05
I2204 n1_M2_65940_117780 0 1.390093e-05
I2205 n1_M2_65940_119940 0 1.994238e-05
I2206 n1_M2_65940_122100 0 2.231377e-05
I2207 n1_M2_65940_124260 0 1.414537e-05
I2208 n1_M2_65940_126420 0 4.416416e-06
I2209 n1_M2_65940_127500 0 3.087351e-06
I2210 n1_M2_68100_60 0 2.842643e-06
I2211 n1_M2_68100_2220 0 2.912779e-06
I2212 n1_M2_68100_4380 0 4.459015e-06
I2213 n1_M2_68100_5460 0 1.447761e-05
I2214 n1_M2_68100_7620 0 2.151703e-05
I2215 n1_M2_68100_9780 0 2.139811e-05
I2216 n1_M2_68100_11940 0 1.936403e-05
I2217 n1_M2_68100_14100 0 1.830611e-05
I2218 n1_M2_68100_16260 0 1.626547e-05
I2219 n1_M2_68100_18420 0 1.841684e-05
I2220 n1_M2_68100_19500 0 2.215474e-05
I2221 n1_M2_68100_21660 0 2.255157e-05
I2222 n1_M2_68100_23820 0 2.122747e-05
I2223 n1_M2_68100_25980 0 1.926353e-05
I2224 n1_M2_68100_28140 0 1.820000e-05
I2225 n1_M2_68100_30300 0 1.370491e-05
I2226 n1_M2_68100_32460 0 1.550920e-05
I2227 n1_M2_68100_33540 0 2.421473e-05
I2228 n1_M2_68100_35700 0 2.603138e-05
I2229 n1_M2_68100_37860 0 2.562872e-05
I2230 n1_M2_68100_40020 0 2.612601e-05
I2231 n1_M2_68100_42180 0 2.518210e-05
I2232 n1_M2_68100_44340 0 2.451362e-05
I2233 n1_M2_68100_46500 0 2.528052e-05
I2234 n1_M2_68100_47580 0 2.575072e-05
I2235 n1_M2_68100_49740 0 2.530209e-05
I2236 n1_M2_68100_51900 0 2.255840e-05
I2237 n1_M2_68100_54060 0 1.158841e-05
I2238 n1_M2_68100_56220 0 7.906519e-06
I2239 n1_M2_68100_58380 0 1.010777e-05
I2240 n1_M2_68100_59460 0 1.465867e-05
I2241 n1_M2_68100_61620 0 1.677580e-05
I2242 n1_M2_68100_63780 0 1.743658e-05
I2243 n1_M2_68100_65940 0 1.603665e-05
I2244 n1_M2_68100_68100 0 1.495240e-05
I2245 n1_M2_68100_70260 0 1.510078e-05
I2246 n1_M2_68100_72420 0 1.215787e-05
I2247 n1_M2_68100_73500 0 1.276276e-05
I2248 n1_M2_68100_75660 0 1.937493e-05
I2249 n1_M2_68100_77820 0 2.196293e-05
I2250 n1_M2_68100_79980 0 2.437511e-05
I2251 n1_M2_68100_82140 0 2.570037e-05
I2252 n1_M2_68100_84300 0 2.489251e-05
I2253 n1_M2_68100_86460 0 2.586379e-05
I2254 n1_M2_68100_87540 0 2.605259e-05
I2255 n1_M2_68100_89700 0 2.620455e-05
I2256 n1_M2_68100_91860 0 2.643622e-05
I2257 n1_M2_68100_94020 0 2.579739e-05
I2258 n1_M2_68100_96180 0 2.583537e-05
I2259 n1_M2_68100_98340 0 2.568210e-05
I2260 n1_M2_68100_100500 0 2.522696e-05
I2261 n1_M2_68100_101580 0 1.977181e-05
I2262 n1_M2_68100_103740 0 1.035832e-05
I2263 n1_M2_68100_105900 0 8.179093e-06
I2264 n1_M2_68100_108060 0 6.611826e-06
I2265 n1_M2_68100_110220 0 1.113820e-05
I2266 n1_M2_68100_112380 0 2.089418e-05
I2267 n1_M2_68100_113460 0 2.097235e-05
I2268 n1_M2_68100_115620 0 1.874987e-05
I2269 n1_M2_68100_117780 0 1.894465e-05
I2270 n1_M2_68100_119940 0 2.397416e-05
I2271 n1_M2_68100_122100 0 2.478571e-05
I2272 n1_M2_68100_124260 0 1.624813e-05
I2273 n1_M2_68100_126420 0 4.627330e-06
I2274 n1_M2_68100_127500 0 3.010610e-06
I2275 n1_M2_70260_60 0 2.761076e-06
I2276 n1_M2_70260_2220 0 2.916789e-06
I2277 n1_M2_70260_4380 0 4.843947e-06
I2278 n1_M2_70260_5460 0 1.652850e-05
I2279 n1_M2_70260_7620 0 2.330473e-05
I2280 n1_M2_70260_9780 0 2.402508e-05
I2281 n1_M2_70260_11940 0 2.292643e-05
I2282 n1_M2_70260_14100 0 2.200446e-05
I2283 n1_M2_70260_16260 0 2.125484e-05
I2284 n1_M2_70260_18420 0 2.146603e-05
I2285 n1_M2_70260_19500 0 2.391897e-05
I2286 n1_M2_70260_21660 0 2.464247e-05
I2287 n1_M2_70260_23820 0 2.500225e-05
I2288 n1_M2_70260_25980 0 2.464413e-05
I2289 n1_M2_70260_28140 0 2.269044e-05
I2290 n1_M2_70260_30300 0 1.678530e-05
I2291 n1_M2_70260_32460 0 1.731510e-05
I2292 n1_M2_70260_33540 0 2.466604e-05
I2293 n1_M2_70260_35700 0 2.632282e-05
I2294 n1_M2_70260_37860 0 2.542196e-05
I2295 n1_M2_70260_40020 0 2.565806e-05
I2296 n1_M2_70260_42180 0 2.397660e-05
I2297 n1_M2_70260_44340 0 2.375210e-05
I2298 n1_M2_70260_46500 0 2.508320e-05
I2299 n1_M2_70260_47580 0 2.514354e-05
I2300 n1_M2_70260_49740 0 2.427892e-05
I2301 n1_M2_70260_51900 0 1.617971e-05
I2302 n1_M2_70260_54060 0 5.864208e-06
I2303 n1_M2_70260_56220 0 6.970861e-06
I2304 n1_M2_70260_58380 0 1.217765e-05
I2305 n1_M2_70260_59460 0 2.034966e-05
I2306 n1_M2_70260_61620 0 2.248284e-05
I2307 n1_M2_70260_63780 0 2.139372e-05
I2308 n1_M2_70260_65940 0 1.901186e-05
I2309 n1_M2_70260_68100 0 1.701782e-05
I2310 n1_M2_70260_70260 0 1.692125e-05
I2311 n1_M2_70260_72420 0 1.385132e-05
I2312 n1_M2_70260_73500 0 1.153571e-05
I2313 n1_M2_70260_75660 0 1.681286e-05
I2314 n1_M2_70260_77820 0 1.964945e-05
I2315 n1_M2_70260_79980 0 2.312661e-05
I2316 n1_M2_70260_82140 0 2.421410e-05
I2317 n1_M2_70260_84300 0 2.415795e-05
I2318 n1_M2_70260_86460 0 2.506748e-05
I2319 n1_M2_70260_87540 0 2.643376e-05
I2320 n1_M2_70260_89700 0 2.561759e-05
I2321 n1_M2_70260_91860 0 2.452032e-05
I2322 n1_M2_70260_94020 0 2.505791e-05
I2323 n1_M2_70260_96180 0 2.540453e-05
I2324 n1_M2_70260_98340 0 2.562385e-05
I2325 n1_M2_70260_100500 0 2.538700e-05
I2326 n1_M2_70260_101580 0 2.002103e-05
I2327 n1_M2_70260_103740 0 1.104089e-05
I2328 n1_M2_70260_105900 0 8.059909e-06
I2329 n1_M2_70260_108060 0 5.325822e-06
I2330 n1_M2_70260_110220 0 9.789362e-06
I2331 n1_M2_70260_112380 0 2.131732e-05
I2332 n1_M2_70260_113460 0 2.175191e-05
I2333 n1_M2_70260_115620 0 2.135560e-05
I2334 n1_M2_70260_117780 0 2.220587e-05
I2335 n1_M2_70260_119940 0 2.531380e-05
I2336 n1_M2_70260_122100 0 2.481167e-05
I2337 n1_M2_70260_124260 0 1.433706e-05
I2338 n1_M2_70260_126420 0 3.940433e-06
I2339 n1_M2_70260_127500 0 3.001489e-06
I2340 n1_M2_72420_60 0 2.770183e-06
I2341 n1_M2_72420_2220 0 2.890777e-06
I2342 n1_M2_72420_4380 0 4.643254e-06
I2343 n1_M2_72420_5460 0 1.655312e-05
I2344 n1_M2_72420_7620 0 2.324188e-05
I2345 n1_M2_72420_9780 0 2.515702e-05
I2346 n1_M2_72420_11940 0 2.481859e-05
I2347 n1_M2_72420_14100 0 2.437421e-05
I2348 n1_M2_72420_16260 0 2.343286e-05
I2349 n1_M2_72420_18420 0 2.248190e-05
I2350 n1_M2_72420_19500 0 2.411793e-05
I2351 n1_M2_72420_21660 0 2.581281e-05
I2352 n1_M2_72420_23820 0 2.605634e-05
I2353 n1_M2_72420_25980 0 2.619274e-05
I2354 n1_M2_72420_28140 0 2.382113e-05
I2355 n1_M2_72420_30300 0 1.634101e-05
I2356 n1_M2_72420_32460 0 1.798445e-05
I2357 n1_M2_72420_33540 0 2.488075e-05
I2358 n1_M2_72420_35700 0 2.597569e-05
I2359 n1_M2_72420_37860 0 2.491366e-05
I2360 n1_M2_72420_40020 0 2.447431e-05
I2361 n1_M2_72420_42180 0 2.236574e-05
I2362 n1_M2_72420_44340 0 2.238170e-05
I2363 n1_M2_72420_46500 0 2.484244e-05
I2364 n1_M2_72420_47580 0 2.438027e-05
I2365 n1_M2_72420_49740 0 2.187954e-05
I2366 n1_M2_72420_51900 0 1.032947e-05
I2367 n1_M2_72420_54060 0 4.591662e-06
I2368 n1_M2_72420_56220 0 6.132694e-06
I2369 n1_M2_72420_58380 0 1.616306e-05
I2370 n1_M2_72420_59460 0 2.367173e-05
I2371 n1_M2_72420_61620 0 2.492401e-05
I2372 n1_M2_72420_63780 0 2.376795e-05
I2373 n1_M2_72420_65940 0 2.169473e-05
I2374 n1_M2_72420_68100 0 2.036013e-05
I2375 n1_M2_72420_70260 0 1.927765e-05
I2376 n1_M2_72420_72420 0 1.240880e-05
I2377 n1_M2_72420_73500 0 9.478781e-06
I2378 n1_M2_72420_75660 0 1.144808e-05
I2379 n1_M2_72420_77820 0 1.092792e-05
I2380 n1_M2_72420_79980 0 1.654389e-05
I2381 n1_M2_72420_82140 0 2.084398e-05
I2382 n1_M2_72420_84300 0 2.130416e-05
I2383 n1_M2_72420_86460 0 2.478842e-05
I2384 n1_M2_72420_87540 0 2.472965e-05
I2385 n1_M2_72420_89700 0 2.073829e-05
I2386 n1_M2_72420_91860 0 1.615225e-05
I2387 n1_M2_72420_94020 0 2.071891e-05
I2388 n1_M2_72420_96180 0 2.161104e-05
I2389 n1_M2_72420_98340 0 2.134532e-05
I2390 n1_M2_72420_100500 0 2.056890e-05
I2391 n1_M2_72420_101580 0 1.319353e-05
I2392 n1_M2_72420_103740 0 8.859546e-06
I2393 n1_M2_72420_105900 0 7.173636e-06
I2394 n1_M2_72420_108060 0 4.691347e-06
I2395 n1_M2_72420_110220 0 7.792052e-06
I2396 n1_M2_72420_112380 0 2.057267e-05
I2397 n1_M2_72420_113460 0 2.265426e-05
I2398 n1_M2_72420_115620 0 2.202332e-05
I2399 n1_M2_72420_117780 0 2.320538e-05
I2400 n1_M2_72420_119940 0 2.581246e-05
I2401 n1_M2_72420_122100 0 2.417927e-05
I2402 n1_M2_72420_124260 0 1.228079e-05
I2403 n1_M2_72420_126420 0 3.567234e-06
I2404 n1_M2_72420_127500 0 2.843871e-06
I2405 n1_M2_73500_60 0 2.813474e-06
I2406 n1_M2_73500_2220 0 2.848758e-06
I2407 n1_M2_73500_4380 0 3.986299e-06
I2408 n1_M2_73500_5460 0 1.475085e-05
I2409 n1_M2_73500_7620 0 2.286232e-05
I2410 n1_M2_73500_9780 0 2.565817e-05
I2411 n1_M2_73500_11940 0 2.517896e-05
I2412 n1_M2_73500_14100 0 2.498976e-05
I2413 n1_M2_73500_16260 0 2.450668e-05
I2414 n1_M2_73500_18420 0 2.249374e-05
I2415 n1_M2_73500_19500 0 2.258520e-05
I2416 n1_M2_73500_21660 0 2.443241e-05
I2417 n1_M2_73500_23820 0 2.491857e-05
I2418 n1_M2_73500_25980 0 2.550334e-05
I2419 n1_M2_73500_28140 0 2.353975e-05
I2420 n1_M2_73500_30300 0 1.723934e-05
I2421 n1_M2_73500_32460 0 1.544617e-05
I2422 n1_M2_73500_33540 0 2.422183e-05
I2423 n1_M2_73500_35700 0 2.413892e-05
I2424 n1_M2_73500_37860 0 2.134729e-05
I2425 n1_M2_73500_40020 0 2.124973e-05
I2426 n1_M2_73500_42180 0 1.963814e-05
I2427 n1_M2_73500_44340 0 1.944610e-05
I2428 n1_M2_73500_46500 0 2.293994e-05
I2429 n1_M2_73500_47580 0 2.208867e-05
I2430 n1_M2_73500_49740 0 1.791609e-05
I2431 n1_M2_73500_51900 0 8.430546e-06
I2432 n1_M2_73500_54060 0 4.428067e-06
I2433 n1_M2_73500_56220 0 7.440765e-06
I2434 n1_M2_73500_58380 0 1.819601e-05
I2435 n1_M2_73500_59460 0 2.442067e-05
I2436 n1_M2_73500_61620 0 2.488569e-05
I2437 n1_M2_73500_63780 0 2.335408e-05
I2438 n1_M2_73500_65940 0 2.241512e-05
I2439 n1_M2_73500_68100 0 2.161192e-05
I2440 n1_M2_73500_70260 0 2.037459e-05
I2441 n1_M2_73500_72420 0 1.478715e-05
I2442 n1_M2_73500_73500 0 1.123641e-05
I2443 n1_M2_73500_75660 0 1.204417e-05
I2444 n1_M2_73500_77820 0 1.146874e-05
I2445 n1_M2_73500_79980 0 1.374835e-05
I2446 n1_M2_73500_82140 0 1.535400e-05
I2447 n1_M2_73500_84300 0 1.722234e-05
I2448 n1_M2_73500_86460 0 2.263837e-05
I2449 n1_M2_73500_87540 0 2.132368e-05
I2450 n1_M2_73500_89700 0 1.350111e-05
I2451 n1_M2_73500_91860 0 8.594051e-06
I2452 n1_M2_73500_94020 0 9.821279e-06
I2453 n1_M2_73500_96180 0 1.040981e-05
I2454 n1_M2_73500_98340 0 8.419329e-06
I2455 n1_M2_73500_100500 0 9.242495e-06
I2456 n1_M2_73500_101580 0 7.628879e-06
I2457 n1_M2_73500_103740 0 6.757754e-06
I2458 n1_M2_73500_105900 0 6.088939e-06
I2459 n1_M2_73500_108060 0 4.429716e-06
I2460 n1_M2_73500_110220 0 5.913351e-06
I2461 n1_M2_73500_112380 0 1.872781e-05
I2462 n1_M2_73500_113460 0 2.370167e-05
I2463 n1_M2_73500_115620 0 2.281444e-05
I2464 n1_M2_73500_117780 0 2.301603e-05
I2465 n1_M2_73500_119940 0 2.478221e-05
I2466 n1_M2_73500_122100 0 2.231894e-05
I2467 n1_M2_73500_124260 0 1.037208e-05
I2468 n1_M2_73500_126420 0 3.473853e-06
I2469 n1_M2_73500_127500 0 2.770954e-06
I2470 n1_M2_75660_60 0 2.731615e-06
I2471 n1_M2_75660_2220 0 2.795414e-06
I2472 n1_M2_75660_4380 0 3.380694e-06
I2473 n1_M2_75660_5460 0 1.139090e-05
I2474 n1_M2_75660_7620 0 1.949716e-05
I2475 n1_M2_75660_9780 0 2.446588e-05
I2476 n1_M2_75660_11940 0 2.462469e-05
I2477 n1_M2_75660_14100 0 2.475239e-05
I2478 n1_M2_75660_16260 0 2.394850e-05
I2479 n1_M2_75660_18420 0 2.160972e-05
I2480 n1_M2_75660_19500 0 1.907032e-05
I2481 n1_M2_75660_21660 0 2.024897e-05
I2482 n1_M2_75660_23820 0 2.060472e-05
I2483 n1_M2_75660_25980 0 2.235969e-05
I2484 n1_M2_75660_28140 0 2.154873e-05
I2485 n1_M2_75660_30300 0 1.622103e-05
I2486 n1_M2_75660_32460 0 1.556763e-05
I2487 n1_M2_75660_33540 0 2.229461e-05
I2488 n1_M2_75660_35700 0 1.995912e-05
I2489 n1_M2_75660_37860 0 1.430467e-05
I2490 n1_M2_75660_40020 0 1.560752e-05
I2491 n1_M2_75660_42180 0 1.745547e-05
I2492 n1_M2_75660_44340 0 1.750657e-05
I2493 n1_M2_75660_46500 0 2.067066e-05
I2494 n1_M2_75660_47580 0 1.758317e-05
I2495 n1_M2_75660_49740 0 1.562918e-05
I2496 n1_M2_75660_51900 0 1.144321e-05
I2497 n1_M2_75660_54060 0 7.567794e-06
I2498 n1_M2_75660_56220 0 1.228357e-05
I2499 n1_M2_75660_58380 0 2.121251e-05
I2500 n1_M2_75660_59460 0 2.431624e-05
I2501 n1_M2_75660_61620 0 2.383644e-05
I2502 n1_M2_75660_63780 0 2.316252e-05
I2503 n1_M2_75660_65940 0 2.304509e-05
I2504 n1_M2_75660_68100 0 2.288198e-05
I2505 n1_M2_75660_70260 0 2.243895e-05
I2506 n1_M2_75660_72420 0 1.846578e-05
I2507 n1_M2_75660_73500 0 1.398901e-05
I2508 n1_M2_75660_75660 0 1.362193e-05
I2509 n1_M2_75660_77820 0 1.272882e-05
I2510 n1_M2_75660_79980 0 1.367219e-05
I2511 n1_M2_75660_82140 0 1.400422e-05
I2512 n1_M2_75660_84300 0 1.425844e-05
I2513 n1_M2_75660_86460 0 1.971171e-05
I2514 n1_M2_75660_87540 0 1.686510e-05
I2515 n1_M2_75660_89700 0 9.438484e-06
I2516 n1_M2_75660_91860 0 5.490460e-06
I2517 n1_M2_75660_94020 0 5.430066e-06
I2518 n1_M2_75660_96180 0 4.750639e-06
I2519 n1_M2_75660_98340 0 5.828769e-06
I2520 n1_M2_75660_100500 0 7.968140e-06
I2521 n1_M2_75660_101580 0 1.011330e-05
I2522 n1_M2_75660_103740 0 8.663157e-06
I2523 n1_M2_75660_105900 0 7.633996e-06
I2524 n1_M2_75660_108060 0 5.512541e-06
I2525 n1_M2_75660_110220 0 7.317715e-06
I2526 n1_M2_75660_112380 0 1.969231e-05
I2527 n1_M2_75660_113460 0 2.414708e-05
I2528 n1_M2_75660_115620 0 2.305837e-05
I2529 n1_M2_75660_117780 0 2.160796e-05
I2530 n1_M2_75660_119940 0 2.188137e-05
I2531 n1_M2_75660_122100 0 1.775968e-05
I2532 n1_M2_75660_124260 0 7.588153e-06
I2533 n1_M2_75660_126420 0 3.457863e-06
I2534 n1_M2_75660_127500 0 2.922369e-06
I2535 n1_M2_77820_60 0 2.799826e-06
I2536 n1_M2_77820_2220 0 2.803990e-06
I2537 n1_M2_77820_4380 0 3.804867e-06
I2538 n1_M2_77820_5460 0 1.155330e-05
I2539 n1_M2_77820_7620 0 1.817079e-05
I2540 n1_M2_77820_9780 0 2.382729e-05
I2541 n1_M2_77820_11940 0 2.456745e-05
I2542 n1_M2_77820_14100 0 2.490637e-05
I2543 n1_M2_77820_16260 0 2.483808e-05
I2544 n1_M2_77820_18420 0 2.116432e-05
I2545 n1_M2_77820_19500 0 1.428458e-05
I2546 n1_M2_77820_21660 0 1.483343e-05
I2547 n1_M2_77820_23820 0 1.546184e-05
I2548 n1_M2_77820_25980 0 1.795237e-05
I2549 n1_M2_77820_28140 0 1.844731e-05
I2550 n1_M2_77820_30300 0 1.718159e-05
I2551 n1_M2_77820_32460 0 1.732278e-05
I2552 n1_M2_77820_33540 0 2.227950e-05
I2553 n1_M2_77820_35700 0 1.833789e-05
I2554 n1_M2_77820_37860 0 1.282402e-05
I2555 n1_M2_77820_40020 0 1.498597e-05
I2556 n1_M2_77820_42180 0 2.061469e-05
I2557 n1_M2_77820_44340 0 2.090335e-05
I2558 n1_M2_77820_46500 0 2.116030e-05
I2559 n1_M2_77820_47580 0 1.620186e-05
I2560 n1_M2_77820_49740 0 1.603816e-05
I2561 n1_M2_77820_51900 0 1.807900e-05
I2562 n1_M2_77820_54060 0 1.582203e-05
I2563 n1_M2_77820_56220 0 1.907288e-05
I2564 n1_M2_77820_58380 0 2.359968e-05
I2565 n1_M2_77820_59460 0 2.429375e-05
I2566 n1_M2_77820_61620 0 2.316980e-05
I2567 n1_M2_77820_63780 0 2.208869e-05
I2568 n1_M2_77820_65940 0 2.056282e-05
I2569 n1_M2_77820_68100 0 1.987221e-05
I2570 n1_M2_77820_70260 0 1.956673e-05
I2571 n1_M2_77820_72420 0 1.522117e-05
I2572 n1_M2_77820_73500 0 1.310499e-05
I2573 n1_M2_77820_75660 0 1.216688e-05
I2574 n1_M2_77820_77820 0 1.233053e-05
I2575 n1_M2_77820_79980 0 1.343269e-05
I2576 n1_M2_77820_82140 0 1.689191e-05
I2577 n1_M2_77820_84300 0 1.753783e-05
I2578 n1_M2_77820_86460 0 1.942447e-05
I2579 n1_M2_77820_87540 0 1.920706e-05
I2580 n1_M2_77820_89700 0 1.297671e-05
I2581 n1_M2_77820_91860 0 8.569442e-06
I2582 n1_M2_77820_94020 0 8.146642e-06
I2583 n1_M2_77820_96180 0 5.959436e-06
I2584 n1_M2_77820_98340 0 6.635291e-06
I2585 n1_M2_77820_100500 0 9.458965e-06
I2586 n1_M2_77820_101580 0 1.359875e-05
I2587 n1_M2_77820_103740 0 1.246300e-05
I2588 n1_M2_77820_105900 0 1.197271e-05
I2589 n1_M2_77820_108060 0 8.891183e-06
I2590 n1_M2_77820_110220 0 9.911581e-06
I2591 n1_M2_77820_112380 0 2.076608e-05
I2592 n1_M2_77820_113460 0 2.410670e-05
I2593 n1_M2_77820_115620 0 2.258920e-05
I2594 n1_M2_77820_117780 0 1.915126e-05
I2595 n1_M2_77820_119940 0 1.710373e-05
I2596 n1_M2_77820_122100 0 1.120988e-05
I2597 n1_M2_77820_124260 0 4.830479e-06
I2598 n1_M2_77820_126420 0 3.179040e-06
I2599 n1_M2_77820_127500 0 2.978284e-06
I2600 n1_M2_79980_60 0 2.859509e-06
I2601 n1_M2_79980_2220 0 2.794119e-06
I2602 n1_M2_79980_4380 0 4.386872e-06
I2603 n1_M2_79980_5460 0 1.381486e-05
I2604 n1_M2_79980_7620 0 1.945292e-05
I2605 n1_M2_79980_9780 0 2.372394e-05
I2606 n1_M2_79980_11940 0 2.422110e-05
I2607 n1_M2_79980_14100 0 2.421803e-05
I2608 n1_M2_79980_16260 0 2.411879e-05
I2609 n1_M2_79980_18420 0 2.097530e-05
I2610 n1_M2_79980_19500 0 1.296697e-05
I2611 n1_M2_79980_21660 0 1.074395e-05
I2612 n1_M2_79980_23820 0 1.213379e-05
I2613 n1_M2_79980_25980 0 1.445898e-05
I2614 n1_M2_79980_28140 0 1.713621e-05
I2615 n1_M2_79980_30300 0 2.001671e-05
I2616 n1_M2_79980_32460 0 2.138926e-05
I2617 n1_M2_79980_33540 0 2.310679e-05
I2618 n1_M2_79980_35700 0 2.018924e-05
I2619 n1_M2_79980_37860 0 1.619076e-05
I2620 n1_M2_79980_40020 0 1.820913e-05
I2621 n1_M2_79980_42180 0 2.216382e-05
I2622 n1_M2_79980_44340 0 2.247718e-05
I2623 n1_M2_79980_46500 0 2.236024e-05
I2624 n1_M2_79980_47580 0 2.012194e-05
I2625 n1_M2_79980_49740 0 1.990903e-05
I2626 n1_M2_79980_51900 0 2.334522e-05
I2627 n1_M2_79980_54060 0 2.356772e-05
I2628 n1_M2_79980_56220 0 2.415573e-05
I2629 n1_M2_79980_58380 0 2.526986e-05
I2630 n1_M2_79980_59460 0 2.529821e-05
I2631 n1_M2_79980_61620 0 2.343265e-05
I2632 n1_M2_79980_63780 0 2.040327e-05
I2633 n1_M2_79980_65940 0 1.653020e-05
I2634 n1_M2_79980_68100 0 1.371477e-05
I2635 n1_M2_79980_70260 0 1.233063e-05
I2636 n1_M2_79980_72420 0 1.247737e-05
I2637 n1_M2_79980_73500 0 1.282527e-05
I2638 n1_M2_79980_75660 0 1.191782e-05
I2639 n1_M2_79980_77820 0 1.178824e-05
I2640 n1_M2_79980_79980 0 1.367605e-05
I2641 n1_M2_79980_82140 0 1.829912e-05
I2642 n1_M2_79980_84300 0 2.105794e-05
I2643 n1_M2_79980_86460 0 2.048833e-05
I2644 n1_M2_79980_87540 0 1.753720e-05
I2645 n1_M2_79980_89700 0 1.687583e-05
I2646 n1_M2_79980_91860 0 1.333276e-05
I2647 n1_M2_79980_94020 0 1.090777e-05
I2648 n1_M2_79980_96180 0 1.029034e-05
I2649 n1_M2_79980_98340 0 1.011976e-05
I2650 n1_M2_79980_100500 0 1.130336e-05
I2651 n1_M2_79980_101580 0 1.673323e-05
I2652 n1_M2_79980_103740 0 1.802480e-05
I2653 n1_M2_79980_105900 0 1.614785e-05
I2654 n1_M2_79980_108060 0 1.392932e-05
I2655 n1_M2_79980_110220 0 1.334526e-05
I2656 n1_M2_79980_112380 0 2.080711e-05
I2657 n1_M2_79980_113460 0 2.385981e-05
I2658 n1_M2_79980_115620 0 2.211424e-05
I2659 n1_M2_79980_117780 0 1.840074e-05
I2660 n1_M2_79980_119940 0 1.485553e-05
I2661 n1_M2_79980_122100 0 8.863210e-06
I2662 n1_M2_79980_124260 0 3.956021e-06
I2663 n1_M2_79980_126420 0 3.089227e-06
I2664 n1_M2_79980_127500 0 3.014390e-06
I2665 n1_M2_82140_60 0 2.886400e-06
I2666 n1_M2_82140_2220 0 2.908296e-06
I2667 n1_M2_82140_4380 0 4.342492e-06
I2668 n1_M2_82140_5460 0 1.460734e-05
I2669 n1_M2_82140_7620 0 2.004913e-05
I2670 n1_M2_82140_9780 0 2.399109e-05
I2671 n1_M2_82140_11940 0 2.302723e-05
I2672 n1_M2_82140_14100 0 2.251070e-05
I2673 n1_M2_82140_16260 0 2.267409e-05
I2674 n1_M2_82140_18420 0 2.191612e-05
I2675 n1_M2_82140_19500 0 1.983344e-05
I2676 n1_M2_82140_21660 0 1.401117e-05
I2677 n1_M2_82140_23820 0 1.102512e-05
I2678 n1_M2_82140_25980 0 1.190167e-05
I2679 n1_M2_82140_28140 0 1.671530e-05
I2680 n1_M2_82140_30300 0 2.257862e-05
I2681 n1_M2_82140_32460 0 2.550134e-05
I2682 n1_M2_82140_33540 0 2.573249e-05
I2683 n1_M2_82140_35700 0 2.520966e-05
I2684 n1_M2_82140_37860 0 2.301858e-05
I2685 n1_M2_82140_40020 0 2.158235e-05
I2686 n1_M2_82140_42180 0 2.073942e-05
I2687 n1_M2_82140_44340 0 2.128476e-05
I2688 n1_M2_82140_46500 0 2.280791e-05
I2689 n1_M2_82140_47580 0 2.262420e-05
I2690 n1_M2_82140_49740 0 2.240728e-05
I2691 n1_M2_82140_51900 0 2.433213e-05
I2692 n1_M2_82140_54060 0 2.435829e-05
I2693 n1_M2_82140_56220 0 2.558515e-05
I2694 n1_M2_82140_58380 0 2.620176e-05
I2695 n1_M2_82140_59460 0 2.602124e-05
I2696 n1_M2_82140_61620 0 2.514609e-05
I2697 n1_M2_82140_63780 0 2.358271e-05
I2698 n1_M2_82140_65940 0 1.750946e-05
I2699 n1_M2_82140_68100 0 1.294851e-05
I2700 n1_M2_82140_70260 0 1.091117e-05
I2701 n1_M2_82140_72420 0 1.089699e-05
I2702 n1_M2_82140_73500 0 1.330507e-05
I2703 n1_M2_82140_75660 0 1.317793e-05
I2704 n1_M2_82140_77820 0 1.231186e-05
I2705 n1_M2_82140_79980 0 1.617885e-05
I2706 n1_M2_82140_82140 0 2.100072e-05
I2707 n1_M2_82140_84300 0 2.172947e-05
I2708 n1_M2_82140_86460 0 2.098207e-05
I2709 n1_M2_82140_87540 0 1.826252e-05
I2710 n1_M2_82140_89700 0 1.835742e-05
I2711 n1_M2_82140_91860 0 1.747994e-05
I2712 n1_M2_82140_94020 0 1.763222e-05
I2713 n1_M2_82140_96180 0 1.602231e-05
I2714 n1_M2_82140_98340 0 1.595381e-05
I2715 n1_M2_82140_100500 0 1.532624e-05
I2716 n1_M2_82140_101580 0 1.779138e-05
I2717 n1_M2_82140_103740 0 2.017629e-05
I2718 n1_M2_82140_105900 0 1.859211e-05
I2719 n1_M2_82140_108060 0 1.631256e-05
I2720 n1_M2_82140_110220 0 1.541508e-05
I2721 n1_M2_82140_112380 0 2.025306e-05
I2722 n1_M2_82140_113460 0 2.268206e-05
I2723 n1_M2_82140_115620 0 2.191616e-05
I2724 n1_M2_82140_117780 0 2.145321e-05
I2725 n1_M2_82140_119940 0 2.079326e-05
I2726 n1_M2_82140_122100 0 1.352704e-05
I2727 n1_M2_82140_124260 0 4.320673e-06
I2728 n1_M2_82140_126420 0 3.041685e-06
I2729 n1_M2_82140_127500 0 3.000876e-06
I2730 n1_M2_84300_60 0 2.705261e-06
I2731 n1_M2_84300_2220 0 2.787453e-06
I2732 n1_M2_84300_4380 0 4.192209e-06
I2733 n1_M2_84300_5460 0 1.179815e-05
I2734 n1_M2_84300_7620 0 1.774983e-05
I2735 n1_M2_84300_9780 0 2.374646e-05
I2736 n1_M2_84300_11940 0 2.247671e-05
I2737 n1_M2_84300_14100 0 2.145364e-05
I2738 n1_M2_84300_16260 0 2.107230e-05
I2739 n1_M2_84300_18420 0 2.068290e-05
I2740 n1_M2_84300_19500 0 2.204054e-05
I2741 n1_M2_84300_21660 0 2.034249e-05
I2742 n1_M2_84300_23820 0 1.166603e-05
I2743 n1_M2_84300_25980 0 8.996191e-06
I2744 n1_M2_84300_28140 0 1.269928e-05
I2745 n1_M2_84300_30300 0 2.153555e-05
I2746 n1_M2_84300_32460 0 2.638376e-05
I2747 n1_M2_84300_33540 0 2.631356e-05
I2748 n1_M2_84300_35700 0 2.650436e-05
I2749 n1_M2_84300_37860 0 2.522317e-05
I2750 n1_M2_84300_40020 0 2.208817e-05
I2751 n1_M2_84300_42180 0 1.715781e-05
I2752 n1_M2_84300_44340 0 1.714125e-05
I2753 n1_M2_84300_46500 0 2.226220e-05
I2754 n1_M2_84300_47580 0 2.287834e-05
I2755 n1_M2_84300_49740 0 2.310570e-05
I2756 n1_M2_84300_51900 0 2.418562e-05
I2757 n1_M2_84300_54060 0 2.381822e-05
I2758 n1_M2_84300_56220 0 2.558452e-05
I2759 n1_M2_84300_58380 0 2.655863e-05
I2760 n1_M2_84300_59460 0 2.647569e-05
I2761 n1_M2_84300_61620 0 2.617113e-05
I2762 n1_M2_84300_63780 0 2.519940e-05
I2763 n1_M2_84300_65940 0 1.967235e-05
I2764 n1_M2_84300_68100 0 1.309611e-05
I2765 n1_M2_84300_70260 0 1.153187e-05
I2766 n1_M2_84300_72420 0 1.014090e-05
I2767 n1_M2_84300_73500 0 1.282570e-05
I2768 n1_M2_84300_75660 0 1.200806e-05
I2769 n1_M2_84300_77820 0 9.141570e-06
I2770 n1_M2_84300_79980 0 1.203067e-05
I2771 n1_M2_84300_82140 0 2.168496e-05
I2772 n1_M2_84300_84300 0 2.349708e-05
I2773 n1_M2_84300_86460 0 2.313162e-05
I2774 n1_M2_84300_87540 0 2.200549e-05
I2775 n1_M2_84300_89700 0 2.263489e-05
I2776 n1_M2_84300_91860 0 2.329109e-05
I2777 n1_M2_84300_94020 0 2.415964e-05
I2778 n1_M2_84300_96180 0 2.431857e-05
I2779 n1_M2_84300_98340 0 2.311701e-05
I2780 n1_M2_84300_100500 0 2.147757e-05
I2781 n1_M2_84300_101580 0 2.050484e-05
I2782 n1_M2_84300_103740 0 2.183285e-05
I2783 n1_M2_84300_105900 0 2.210159e-05
I2784 n1_M2_84300_108060 0 1.977153e-05
I2785 n1_M2_84300_110220 0 1.781888e-05
I2786 n1_M2_84300_112380 0 2.081232e-05
I2787 n1_M2_84300_113460 0 2.273453e-05
I2788 n1_M2_84300_115620 0 2.293432e-05
I2789 n1_M2_84300_117780 0 2.445911e-05
I2790 n1_M2_84300_119940 0 2.551621e-05
I2791 n1_M2_84300_122100 0 2.229647e-05
I2792 n1_M2_84300_124260 0 7.618634e-06
I2793 n1_M2_84300_126420 0 3.011351e-06
I2794 n1_M2_84300_127500 0 2.735806e-06
I2795 n1_M2_86460_60 0 2.719822e-06
I2796 n1_M2_86460_2220 0 2.782843e-06
I2797 n1_M2_86460_4380 0 3.755563e-06
I2798 n1_M2_86460_5460 0 7.926128e-06
I2799 n1_M2_86460_7620 0 1.136283e-05
I2800 n1_M2_86460_9780 0 2.059750e-05
I2801 n1_M2_86460_11940 0 2.156601e-05
I2802 n1_M2_86460_14100 0 1.922213e-05
I2803 n1_M2_86460_16260 0 1.928054e-05
I2804 n1_M2_86460_18420 0 2.115541e-05
I2805 n1_M2_86460_19500 0 2.251148e-05
I2806 n1_M2_86460_21660 0 2.033993e-05
I2807 n1_M2_86460_23820 0 1.293695e-05
I2808 n1_M2_86460_25980 0 8.385328e-06
I2809 n1_M2_86460_28140 0 9.562400e-06
I2810 n1_M2_86460_30300 0 2.069101e-05
I2811 n1_M2_86460_32460 0 2.606973e-05
I2812 n1_M2_86460_33540 0 2.636022e-05
I2813 n1_M2_86460_35700 0 2.611904e-05
I2814 n1_M2_86460_37860 0 2.475271e-05
I2815 n1_M2_86460_40020 0 2.116613e-05
I2816 n1_M2_86460_42180 0 1.496046e-05
I2817 n1_M2_86460_44340 0 1.394191e-05
I2818 n1_M2_86460_46500 0 1.959370e-05
I2819 n1_M2_86460_47580 0 2.106214e-05
I2820 n1_M2_86460_49740 0 2.121310e-05
I2821 n1_M2_86460_51900 0 2.179941e-05
I2822 n1_M2_86460_54060 0 2.125690e-05
I2823 n1_M2_86460_56220 0 2.373714e-05
I2824 n1_M2_86460_58380 0 2.599335e-05
I2825 n1_M2_86460_59460 0 2.595253e-05
I2826 n1_M2_86460_61620 0 2.566245e-05
I2827 n1_M2_86460_63780 0 2.502767e-05
I2828 n1_M2_86460_65940 0 2.167675e-05
I2829 n1_M2_86460_68100 0 1.545177e-05
I2830 n1_M2_86460_70260 0 1.315727e-05
I2831 n1_M2_86460_72420 0 1.209746e-05
I2832 n1_M2_86460_73500 0 1.559697e-05
I2833 n1_M2_86460_75660 0 1.240923e-05
I2834 n1_M2_86460_77820 0 8.907915e-06
I2835 n1_M2_86460_79980 0 1.035486e-05
I2836 n1_M2_86460_82140 0 1.846619e-05
I2837 n1_M2_86460_84300 0 2.208465e-05
I2838 n1_M2_86460_86460 0 2.296568e-05
I2839 n1_M2_86460_87540 0 2.200964e-05
I2840 n1_M2_86460_89700 0 2.314027e-05
I2841 n1_M2_86460_91860 0 2.533264e-05
I2842 n1_M2_86460_94020 0 2.563928e-05
I2843 n1_M2_86460_96180 0 2.628630e-05
I2844 n1_M2_86460_98340 0 2.584205e-05
I2845 n1_M2_86460_100500 0 2.417981e-05
I2846 n1_M2_86460_101580 0 2.338145e-05
I2847 n1_M2_86460_103740 0 2.426093e-05
I2848 n1_M2_86460_105900 0 2.327065e-05
I2849 n1_M2_86460_108060 0 2.039555e-05
I2850 n1_M2_86460_110220 0 1.843668e-05
I2851 n1_M2_86460_112380 0 2.120381e-05
I2852 n1_M2_86460_113460 0 2.254845e-05
I2853 n1_M2_86460_115620 0 2.335796e-05
I2854 n1_M2_86460_117780 0 2.538487e-05
I2855 n1_M2_86460_119940 0 2.614948e-05
I2856 n1_M2_86460_122100 0 2.517102e-05
I2857 n1_M2_86460_124260 0 1.208238e-05
I2858 n1_M2_86460_126420 0 3.275269e-06
I2859 n1_M2_86460_127500 0 2.949085e-06
I2860 n1_M2_87540_60 0 2.696836e-06
I2861 n1_M2_87540_2220 0 2.760599e-06
I2862 n1_M2_87540_4380 0 3.311082e-06
I2863 n1_M2_87540_5460 0 5.169637e-06
I2864 n1_M2_87540_7620 0 8.324899e-06
I2865 n1_M2_87540_9780 0 1.337219e-05
I2866 n1_M2_87540_11940 0 1.642284e-05
I2867 n1_M2_87540_14100 0 1.431272e-05
I2868 n1_M2_87540_16260 0 1.587879e-05
I2869 n1_M2_87540_18420 0 1.824915e-05
I2870 n1_M2_87540_19500 0 2.168411e-05
I2871 n1_M2_87540_21660 0 1.991244e-05
I2872 n1_M2_87540_23820 0 1.169483e-05
I2873 n1_M2_87540_25980 0 1.116255e-05
I2874 n1_M2_87540_28140 0 1.136895e-05
I2875 n1_M2_87540_30300 0 1.597495e-05
I2876 n1_M2_87540_32460 0 2.451568e-05
I2877 n1_M2_87540_33540 0 2.610319e-05
I2878 n1_M2_87540_35700 0 2.545051e-05
I2879 n1_M2_87540_37860 0 2.324977e-05
I2880 n1_M2_87540_40020 0 2.016502e-05
I2881 n1_M2_87540_42180 0 1.344442e-05
I2882 n1_M2_87540_44340 0 1.327597e-05
I2883 n1_M2_87540_46500 0 1.479698e-05
I2884 n1_M2_87540_47580 0 1.282936e-05
I2885 n1_M2_87540_49740 0 1.459839e-05
I2886 n1_M2_87540_51900 0 1.760528e-05
I2887 n1_M2_87540_54060 0 1.436520e-05
I2888 n1_M2_87540_56220 0 1.858483e-05
I2889 n1_M2_87540_58380 0 2.382537e-05
I2890 n1_M2_87540_59460 0 2.322353e-05
I2891 n1_M2_87540_61620 0 2.356416e-05
I2892 n1_M2_87540_63780 0 2.453381e-05
I2893 n1_M2_87540_65940 0 2.292546e-05
I2894 n1_M2_87540_68100 0 2.047369e-05
I2895 n1_M2_87540_70260 0 1.707495e-05
I2896 n1_M2_87540_72420 0 1.085237e-05
I2897 n1_M2_87540_73500 0 1.364389e-05
I2898 n1_M2_87540_75660 0 1.031689e-05
I2899 n1_M2_87540_77820 0 9.101288e-06
I2900 n1_M2_87540_79980 0 1.133274e-05
I2901 n1_M2_87540_82140 0 1.610936e-05
I2902 n1_M2_87540_84300 0 1.695552e-05
I2903 n1_M2_87540_86460 0 2.089944e-05
I2904 n1_M2_87540_87540 0 2.116051e-05
I2905 n1_M2_87540_89700 0 2.217594e-05
I2906 n1_M2_87540_91860 0 2.428212e-05
I2907 n1_M2_87540_94020 0 2.558398e-05
I2908 n1_M2_87540_96180 0 2.623584e-05
I2909 n1_M2_87540_98340 0 2.585967e-05
I2910 n1_M2_87540_100500 0 2.452893e-05
I2911 n1_M2_87540_101580 0 2.310809e-05
I2912 n1_M2_87540_103740 0 2.319952e-05
I2913 n1_M2_87540_105900 0 2.221240e-05
I2914 n1_M2_87540_108060 0 1.677981e-05
I2915 n1_M2_87540_110220 0 1.442168e-05
I2916 n1_M2_87540_112380 0 1.917630e-05
I2917 n1_M2_87540_113460 0 2.132955e-05
I2918 n1_M2_87540_115620 0 2.222650e-05
I2919 n1_M2_87540_117780 0 2.487952e-05
I2920 n1_M2_87540_119940 0 2.623199e-05
I2921 n1_M2_87540_122100 0 2.534816e-05
I2922 n1_M2_87540_124260 0 1.307214e-05
I2923 n1_M2_87540_126420 0 3.610077e-06
I2924 n1_M2_87540_127500 0 2.832493e-06
I2925 n1_M2_89700_60 0 2.605533e-06
I2926 n1_M2_89700_2220 0 2.717315e-06
I2927 n1_M2_89700_4380 0 3.129827e-06
I2928 n1_M2_89700_5460 0 3.992010e-06
I2929 n1_M2_89700_7620 0 5.759986e-06
I2930 n1_M2_89700_9780 0 1.017034e-05
I2931 n1_M2_89700_11940 0 1.330991e-05
I2932 n1_M2_89700_14100 0 1.241817e-05
I2933 n1_M2_89700_16260 0 1.508943e-05
I2934 n1_M2_89700_18420 0 1.753255e-05
I2935 n1_M2_89700_19500 0 1.686752e-05
I2936 n1_M2_89700_21660 0 1.622966e-05
I2937 n1_M2_89700_23820 0 9.503639e-06
I2938 n1_M2_89700_25980 0 8.623243e-06
I2939 n1_M2_89700_28140 0 1.050247e-05
I2940 n1_M2_89700_30300 0 1.269112e-05
I2941 n1_M2_89700_32460 0 2.062335e-05
I2942 n1_M2_89700_33540 0 2.489484e-05
I2943 n1_M2_89700_35700 0 2.472185e-05
I2944 n1_M2_89700_37860 0 2.193475e-05
I2945 n1_M2_89700_40020 0 1.892988e-05
I2946 n1_M2_89700_42180 0 1.406829e-05
I2947 n1_M2_89700_44340 0 1.092452e-05
I2948 n1_M2_89700_46500 0 1.101206e-05
I2949 n1_M2_89700_47580 0 9.196022e-06
I2950 n1_M2_89700_49740 0 1.084533e-05
I2951 n1_M2_89700_51900 0 1.381815e-05
I2952 n1_M2_89700_54060 0 1.254502e-05
I2953 n1_M2_89700_56220 0 1.433248e-05
I2954 n1_M2_89700_58380 0 1.908292e-05
I2955 n1_M2_89700_59460 0 1.904022e-05
I2956 n1_M2_89700_61620 0 2.113828e-05
I2957 n1_M2_89700_63780 0 2.442703e-05
I2958 n1_M2_89700_65940 0 2.447974e-05
I2959 n1_M2_89700_68100 0 2.227986e-05
I2960 n1_M2_89700_70260 0 1.923835e-05
I2961 n1_M2_89700_72420 0 1.206572e-05
I2962 n1_M2_89700_73500 0 1.182393e-05
I2963 n1_M2_89700_75660 0 1.100725e-05
I2964 n1_M2_89700_77820 0 1.070526e-05
I2965 n1_M2_89700_79980 0 1.056046e-05
I2966 n1_M2_89700_82140 0 1.692387e-05
I2967 n1_M2_89700_84300 0 1.863350e-05
I2968 n1_M2_89700_86460 0 1.870529e-05
I2969 n1_M2_89700_87540 0 2.048795e-05
I2970 n1_M2_89700_89700 0 2.193322e-05
I2971 n1_M2_89700_91860 0 2.336484e-05
I2972 n1_M2_89700_94020 0 2.466898e-05
I2973 n1_M2_89700_96180 0 2.569771e-05
I2974 n1_M2_89700_98340 0 2.514944e-05
I2975 n1_M2_89700_100500 0 2.256955e-05
I2976 n1_M2_89700_101580 0 1.979059e-05
I2977 n1_M2_89700_103740 0 1.790263e-05
I2978 n1_M2_89700_105900 0 1.589652e-05
I2979 n1_M2_89700_108060 0 9.890474e-06
I2980 n1_M2_89700_110220 0 7.016843e-06
I2981 n1_M2_89700_112380 0 1.023652e-05
I2982 n1_M2_89700_113460 0 1.608779e-05
I2983 n1_M2_89700_115620 0 1.769649e-05
I2984 n1_M2_89700_117780 0 2.162897e-05
I2985 n1_M2_89700_119940 0 2.492945e-05
I2986 n1_M2_89700_122100 0 2.360114e-05
I2987 n1_M2_89700_124260 0 1.275058e-05
I2988 n1_M2_89700_126420 0 3.468337e-06
I2989 n1_M2_89700_127500 0 2.950975e-06
I2990 n1_M2_91860_60 0 2.707278e-06
I2991 n1_M2_91860_2220 0 2.727557e-06
I2992 n1_M2_91860_4380 0 3.146266e-06
I2993 n1_M2_91860_5460 0 4.113821e-06
I2994 n1_M2_91860_7620 0 5.655732e-06
I2995 n1_M2_91860_9780 0 7.597362e-06
I2996 n1_M2_91860_11940 0 1.148913e-05
I2997 n1_M2_91860_14100 0 1.304256e-05
I2998 n1_M2_91860_16260 0 1.496495e-05
I2999 n1_M2_91860_18420 0 1.568961e-05
I3000 n1_M2_91860_19500 0 9.832619e-06
I3001 n1_M2_91860_21660 0 9.425042e-06
I3002 n1_M2_91860_23820 0 9.170597e-06
I3003 n1_M2_91860_25980 0 1.041174e-05
I3004 n1_M2_91860_28140 0 1.029937e-05
I3005 n1_M2_91860_30300 0 1.234975e-05
I3006 n1_M2_91860_32460 0 1.268907e-05
I3007 n1_M2_91860_33540 0 2.068150e-05
I3008 n1_M2_91860_35700 0 2.265233e-05
I3009 n1_M2_91860_37860 0 2.162255e-05
I3010 n1_M2_91860_40020 0 2.110105e-05
I3011 n1_M2_91860_42180 0 1.619197e-05
I3012 n1_M2_91860_44340 0 1.045952e-05
I3013 n1_M2_91860_46500 0 9.216304e-06
I3014 n1_M2_91860_47580 0 8.443820e-06
I3015 n1_M2_91860_49740 0 9.218402e-06
I3016 n1_M2_91860_51900 0 1.152640e-05
I3017 n1_M2_91860_54060 0 1.150049e-05
I3018 n1_M2_91860_56220 0 1.180445e-05
I3019 n1_M2_91860_58380 0 1.230246e-05
I3020 n1_M2_91860_59460 0 1.585860e-05
I3021 n1_M2_91860_61620 0 1.927966e-05
I3022 n1_M2_91860_63780 0 2.373339e-05
I3023 n1_M2_91860_65940 0 2.464989e-05
I3024 n1_M2_91860_68100 0 2.283910e-05
I3025 n1_M2_91860_70260 0 1.836339e-05
I3026 n1_M2_91860_72420 0 1.235878e-05
I3027 n1_M2_91860_73500 0 1.078343e-05
I3028 n1_M2_91860_75660 0 1.178304e-05
I3029 n1_M2_91860_77820 0 1.284552e-05
I3030 n1_M2_91860_79980 0 1.087161e-05
I3031 n1_M2_91860_82140 0 1.370837e-05
I3032 n1_M2_91860_84300 0 1.925406e-05
I3033 n1_M2_91860_86460 0 1.658671e-05
I3034 n1_M2_91860_87540 0 1.766013e-05
I3035 n1_M2_91860_89700 0 2.090104e-05
I3036 n1_M2_91860_91860 0 2.242571e-05
I3037 n1_M2_91860_94020 0 2.324169e-05
I3038 n1_M2_91860_96180 0 2.564849e-05
I3039 n1_M2_91860_98340 0 2.477205e-05
I3040 n1_M2_91860_100500 0 2.023974e-05
I3041 n1_M2_91860_101580 0 1.621897e-05
I3042 n1_M2_91860_103740 0 1.387394e-05
I3043 n1_M2_91860_105900 0 9.242760e-06
I3044 n1_M2_91860_108060 0 4.515900e-06
I3045 n1_M2_91860_110220 0 4.500408e-06
I3046 n1_M2_91860_112380 0 6.764954e-06
I3047 n1_M2_91860_113460 0 1.160234e-05
I3048 n1_M2_91860_115620 0 1.374811e-05
I3049 n1_M2_91860_117780 0 1.597790e-05
I3050 n1_M2_91860_119940 0 2.084895e-05
I3051 n1_M2_91860_122100 0 1.700433e-05
I3052 n1_M2_91860_124260 0 7.489210e-06
I3053 n1_M2_91860_126420 0 3.165229e-06
I3054 n1_M2_91860_127500 0 2.859314e-06
I3055 n1_M2_94020_60 0 2.717406e-06
I3056 n1_M2_94020_2220 0 2.767382e-06
I3057 n1_M2_94020_4380 0 3.201036e-06
I3058 n1_M2_94020_5460 0 4.299601e-06
I3059 n1_M2_94020_7620 0 6.208466e-06
I3060 n1_M2_94020_9780 0 6.471646e-06
I3061 n1_M2_94020_11940 0 8.321163e-06
I3062 n1_M2_94020_14100 0 1.189014e-05
I3063 n1_M2_94020_16260 0 1.343603e-05
I3064 n1_M2_94020_18420 0 1.187092e-05
I3065 n1_M2_94020_19500 0 8.906720e-06
I3066 n1_M2_94020_21660 0 6.781645e-06
I3067 n1_M2_94020_23820 0 7.585023e-06
I3068 n1_M2_94020_25980 0 9.755521e-06
I3069 n1_M2_94020_28140 0 1.020502e-05
I3070 n1_M2_94020_30300 0 9.971088e-06
I3071 n1_M2_94020_32460 0 1.215522e-05
I3072 n1_M2_94020_33540 0 1.703487e-05
I3073 n1_M2_94020_35700 0 2.054944e-05
I3074 n1_M2_94020_37860 0 2.067577e-05
I3075 n1_M2_94020_40020 0 2.096194e-05
I3076 n1_M2_94020_42180 0 1.709018e-05
I3077 n1_M2_94020_44340 0 1.383232e-05
I3078 n1_M2_94020_46500 0 1.056351e-05
I3079 n1_M2_94020_47580 0 1.017130e-05
I3080 n1_M2_94020_49740 0 1.177625e-05
I3081 n1_M2_94020_51900 0 1.109524e-05
I3082 n1_M2_94020_54060 0 9.312754e-06
I3083 n1_M2_94020_56220 0 1.138992e-05
I3084 n1_M2_94020_58380 0 1.233748e-05
I3085 n1_M2_94020_59460 0 1.546102e-05
I3086 n1_M2_94020_61620 0 2.025758e-05
I3087 n1_M2_94020_63780 0 2.410094e-05
I3088 n1_M2_94020_65940 0 2.464303e-05
I3089 n1_M2_94020_68100 0 2.395859e-05
I3090 n1_M2_94020_70260 0 2.146384e-05
I3091 n1_M2_94020_72420 0 1.634666e-05
I3092 n1_M2_94020_73500 0 1.426883e-05
I3093 n1_M2_94020_75660 0 1.350848e-05
I3094 n1_M2_94020_77820 0 1.343752e-05
I3095 n1_M2_94020_79980 0 1.497373e-05
I3096 n1_M2_94020_82140 0 1.397874e-05
I3097 n1_M2_94020_84300 0 1.621948e-05
I3098 n1_M2_94020_86460 0 1.961688e-05
I3099 n1_M2_94020_87540 0 2.091358e-05
I3100 n1_M2_94020_89700 0 2.061814e-05
I3101 n1_M2_94020_91860 0 2.292594e-05
I3102 n1_M2_94020_94020 0 2.462923e-05
I3103 n1_M2_94020_96180 0 2.646347e-05
I3104 n1_M2_94020_98340 0 2.541911e-05
I3105 n1_M2_94020_100500 0 2.046106e-05
I3106 n1_M2_94020_101580 0 1.618145e-05
I3107 n1_M2_94020_103740 0 1.398296e-05
I3108 n1_M2_94020_105900 0 9.916575e-06
I3109 n1_M2_94020_108060 0 4.309446e-06
I3110 n1_M2_94020_110220 0 4.484832e-06
I3111 n1_M2_94020_112380 0 7.338311e-06
I3112 n1_M2_94020_113460 0 1.216924e-05
I3113 n1_M2_94020_115620 0 1.361353e-05
I3114 n1_M2_94020_117780 0 1.356106e-05
I3115 n1_M2_94020_119940 0 1.314925e-05
I3116 n1_M2_94020_122100 0 8.074334e-06
I3117 n1_M2_94020_124260 0 3.702871e-06
I3118 n1_M2_94020_126420 0 3.178320e-06
I3119 n1_M2_94020_127500 0 2.957435e-06
I3120 n1_M2_96180_60 0 2.736013e-06
I3121 n1_M2_96180_2220 0 2.796451e-06
I3122 n1_M2_96180_4380 0 3.300372e-06
I3123 n1_M2_96180_5460 0 4.578618e-06
I3124 n1_M2_96180_7620 0 6.402019e-06
I3125 n1_M2_96180_9780 0 9.394263e-06
I3126 n1_M2_96180_11940 0 8.854154e-06
I3127 n1_M2_96180_14100 0 1.056923e-05
I3128 n1_M2_96180_16260 0 1.356994e-05
I3129 n1_M2_96180_18420 0 1.202200e-05
I3130 n1_M2_96180_19500 0 1.082579e-05
I3131 n1_M2_96180_21660 0 1.017699e-05
I3132 n1_M2_96180_23820 0 7.609971e-06
I3133 n1_M2_96180_25980 0 9.701939e-06
I3134 n1_M2_96180_28140 0 1.388590e-05
I3135 n1_M2_96180_30300 0 1.135409e-05
I3136 n1_M2_96180_32460 0 1.521672e-05
I3137 n1_M2_96180_33540 0 2.206637e-05
I3138 n1_M2_96180_35700 0 2.136718e-05
I3139 n1_M2_96180_37860 0 1.762596e-05
I3140 n1_M2_96180_40020 0 1.595458e-05
I3141 n1_M2_96180_42180 0 1.145804e-05
I3142 n1_M2_96180_44340 0 1.177503e-05
I3143 n1_M2_96180_46500 0 8.255249e-06
I3144 n1_M2_96180_47580 0 5.739822e-06
I3145 n1_M2_96180_49740 0 5.088863e-06
I3146 n1_M2_96180_51900 0 5.930278e-06
I3147 n1_M2_96180_54060 0 4.444007e-06
I3148 n1_M2_96180_56220 0 4.349744e-06
I3149 n1_M2_96180_58380 0 6.872297e-06
I3150 n1_M2_96180_59460 0 8.618887e-06
I3151 n1_M2_96180_61620 0 1.558057e-05
I3152 n1_M2_96180_63780 0 2.195162e-05
I3153 n1_M2_96180_65940 0 2.293437e-05
I3154 n1_M2_96180_68100 0 2.465250e-05
I3155 n1_M2_96180_70260 0 2.506065e-05
I3156 n1_M2_96180_72420 0 2.163970e-05
I3157 n1_M2_96180_73500 0 1.596306e-05
I3158 n1_M2_96180_75660 0 1.149637e-05
I3159 n1_M2_96180_77820 0 7.518582e-06
I3160 n1_M2_96180_79980 0 8.342700e-06
I3161 n1_M2_96180_82140 0 1.560554e-05
I3162 n1_M2_96180_84300 0 1.762317e-05
I3163 n1_M2_96180_86460 0 2.069723e-05
I3164 n1_M2_96180_87540 0 2.142730e-05
I3165 n1_M2_96180_89700 0 1.986028e-05
I3166 n1_M2_96180_91860 0 2.237594e-05
I3167 n1_M2_96180_94020 0 2.560224e-05
I3168 n1_M2_96180_96180 0 2.623914e-05
I3169 n1_M2_96180_98340 0 2.623722e-05
I3170 n1_M2_96180_100500 0 2.155678e-05
I3171 n1_M2_96180_101580 0 1.538069e-05
I3172 n1_M2_96180_103740 0 1.190718e-05
I3173 n1_M2_96180_105900 0 8.457183e-06
I3174 n1_M2_96180_108060 0 5.067992e-06
I3175 n1_M2_96180_110220 0 5.188997e-06
I3176 n1_M2_96180_112380 0 8.301204e-06
I3177 n1_M2_96180_113460 0 1.467421e-05
I3178 n1_M2_96180_115620 0 1.581302e-05
I3179 n1_M2_96180_117780 0 1.397863e-05
I3180 n1_M2_96180_119940 0 1.303211e-05
I3181 n1_M2_96180_122100 0 5.835067e-06
I3182 n1_M2_96180_124260 0 3.538074e-06
I3183 n1_M2_96180_126420 0 3.187960e-06
I3184 n1_M2_96180_127500 0 2.877648e-06
I3185 n1_M2_98340_60 0 2.832179e-06
I3186 n1_M2_98340_2220 0 2.858422e-06
I3187 n1_M2_98340_4380 0 3.461450e-06
I3188 n1_M2_98340_5460 0 6.030872e-06
I3189 n1_M2_98340_7620 0 8.320182e-06
I3190 n1_M2_98340_9780 0 1.108099e-05
I3191 n1_M2_98340_11940 0 9.831685e-06
I3192 n1_M2_98340_14100 0 1.035097e-05
I3193 n1_M2_98340_16260 0 1.227376e-05
I3194 n1_M2_98340_18420 0 1.590456e-05
I3195 n1_M2_98340_19500 0 1.455006e-05
I3196 n1_M2_98340_21660 0 1.377827e-05
I3197 n1_M2_98340_23820 0 1.100967e-05
I3198 n1_M2_98340_25980 0 1.154436e-05
I3199 n1_M2_98340_28140 0 1.756456e-05
I3200 n1_M2_98340_30300 0 1.649602e-05
I3201 n1_M2_98340_32460 0 1.852438e-05
I3202 n1_M2_98340_33540 0 2.289915e-05
I3203 n1_M2_98340_35700 0 2.188416e-05
I3204 n1_M2_98340_37860 0 1.765184e-05
I3205 n1_M2_98340_40020 0 1.466213e-05
I3206 n1_M2_98340_42180 0 1.369133e-05
I3207 n1_M2_98340_44340 0 1.089607e-05
I3208 n1_M2_98340_46500 0 8.224709e-06
I3209 n1_M2_98340_47580 0 6.869622e-06
I3210 n1_M2_98340_49740 0 6.350671e-06
I3211 n1_M2_98340_51900 0 6.828815e-06
I3212 n1_M2_98340_54060 0 5.833884e-06
I3213 n1_M2_98340_56220 0 5.877993e-06
I3214 n1_M2_98340_58380 0 6.487795e-06
I3215 n1_M2_98340_59460 0 8.783543e-06
I3216 n1_M2_98340_61620 0 1.444008e-05
I3217 n1_M2_98340_63780 0 2.022767e-05
I3218 n1_M2_98340_65940 0 2.245596e-05
I3219 n1_M2_98340_68100 0 2.477702e-05
I3220 n1_M2_98340_70260 0 2.629846e-05
I3221 n1_M2_98340_72420 0 2.501717e-05
I3222 n1_M2_98340_73500 0 2.121851e-05
I3223 n1_M2_98340_75660 0 1.353905e-05
I3224 n1_M2_98340_77820 0 7.862794e-06
I3225 n1_M2_98340_79980 0 6.746221e-06
I3226 n1_M2_98340_82140 0 1.398308e-05
I3227 n1_M2_98340_84300 0 1.764565e-05
I3228 n1_M2_98340_86460 0 2.060890e-05
I3229 n1_M2_98340_87540 0 2.032838e-05
I3230 n1_M2_98340_89700 0 1.829021e-05
I3231 n1_M2_98340_91860 0 2.011815e-05
I3232 n1_M2_98340_94020 0 2.544413e-05
I3233 n1_M2_98340_96180 0 2.641941e-05
I3234 n1_M2_98340_98340 0 2.605530e-05
I3235 n1_M2_98340_100500 0 2.199838e-05
I3236 n1_M2_98340_101580 0 1.878578e-05
I3237 n1_M2_98340_103740 0 1.618402e-05
I3238 n1_M2_98340_105900 0 1.125730e-05
I3239 n1_M2_98340_108060 0 7.185328e-06
I3240 n1_M2_98340_110220 0 7.945666e-06
I3241 n1_M2_98340_112380 0 1.008130e-05
I3242 n1_M2_98340_113460 0 1.711314e-05
I3243 n1_M2_98340_115620 0 1.784930e-05
I3244 n1_M2_98340_117780 0 1.424021e-05
I3245 n1_M2_98340_119940 0 1.146881e-05
I3246 n1_M2_98340_122100 0 5.994097e-06
I3247 n1_M2_98340_124260 0 3.430969e-06
I3248 n1_M2_98340_126420 0 3.073185e-06
I3249 n1_M2_98340_127500 0 2.957569e-06
I3250 n1_M2_100500_60 0 2.671589e-06
I3251 n1_M2_100500_2220 0 2.742802e-06
I3252 n1_M2_100500_4380 0 3.226346e-06
I3253 n1_M2_100500_5460 0 5.500277e-06
I3254 n1_M2_100500_7620 0 9.734254e-06
I3255 n1_M2_100500_9780 0 1.068882e-05
I3256 n1_M2_100500_11940 0 8.964866e-06
I3257 n1_M2_100500_14100 0 9.017097e-06
I3258 n1_M2_100500_16260 0 9.983314e-06
I3259 n1_M2_100500_18420 0 1.399356e-05
I3260 n1_M2_100500_19500 0 1.418549e-05
I3261 n1_M2_100500_21660 0 1.140986e-05
I3262 n1_M2_100500_23820 0 8.653255e-06
I3263 n1_M2_100500_25980 0 1.031980e-05
I3264 n1_M2_100500_28140 0 1.560316e-05
I3265 n1_M2_100500_30300 0 1.448003e-05
I3266 n1_M2_100500_32460 0 1.733772e-05
I3267 n1_M2_100500_33540 0 2.024467e-05
I3268 n1_M2_100500_35700 0 1.749457e-05
I3269 n1_M2_100500_37860 0 1.467006e-05
I3270 n1_M2_100500_40020 0 1.344856e-05
I3271 n1_M2_100500_42180 0 1.438932e-05
I3272 n1_M2_100500_44340 0 1.359708e-05
I3273 n1_M2_100500_46500 0 1.057397e-05
I3274 n1_M2_100500_47580 0 7.784192e-06
I3275 n1_M2_100500_49740 0 9.400698e-06
I3276 n1_M2_100500_51900 0 9.150392e-06
I3277 n1_M2_100500_54060 0 7.595317e-06
I3278 n1_M2_100500_56220 0 9.415030e-06
I3279 n1_M2_100500_58380 0 9.110053e-06
I3280 n1_M2_100500_59460 0 9.336188e-06
I3281 n1_M2_100500_61620 0 1.352088e-05
I3282 n1_M2_100500_63780 0 1.947115e-05
I3283 n1_M2_100500_65940 0 2.252722e-05
I3284 n1_M2_100500_68100 0 2.520824e-05
I3285 n1_M2_100500_70260 0 2.588708e-05
I3286 n1_M2_100500_72420 0 2.532804e-05
I3287 n1_M2_100500_73500 0 2.334558e-05
I3288 n1_M2_100500_75660 0 1.919067e-05
I3289 n1_M2_100500_77820 0 1.255902e-05
I3290 n1_M2_100500_79980 0 1.222463e-05
I3291 n1_M2_100500_82140 0 1.671530e-05
I3292 n1_M2_100500_84300 0 1.881787e-05
I3293 n1_M2_100500_86460 0 2.110216e-05
I3294 n1_M2_100500_87540 0 2.089317e-05
I3295 n1_M2_100500_89700 0 1.818510e-05
I3296 n1_M2_100500_91860 0 1.758182e-05
I3297 n1_M2_100500_94020 0 2.477825e-05
I3298 n1_M2_100500_96180 0 2.644175e-05
I3299 n1_M2_100500_98340 0 2.495472e-05
I3300 n1_M2_100500_100500 0 1.979615e-05
I3301 n1_M2_100500_101580 0 2.087052e-05
I3302 n1_M2_100500_103740 0 2.091510e-05
I3303 n1_M2_100500_105900 0 1.494962e-05
I3304 n1_M2_100500_108060 0 9.194158e-06
I3305 n1_M2_100500_110220 0 9.034208e-06
I3306 n1_M2_100500_112380 0 1.088257e-05
I3307 n1_M2_100500_113460 0 1.883988e-05
I3308 n1_M2_100500_115620 0 1.852451e-05
I3309 n1_M2_100500_117780 0 1.442119e-05
I3310 n1_M2_100500_119940 0 1.210648e-05
I3311 n1_M2_100500_122100 0 6.872311e-06
I3312 n1_M2_100500_124260 0 3.533210e-06
I3313 n1_M2_100500_126420 0 3.016877e-06
I3314 n1_M2_100500_127500 0 2.904953e-06
I3315 n1_M2_101580_60 0 2.662548e-06
I3316 n1_M2_101580_2220 0 2.727777e-06
I3317 n1_M2_101580_4380 0 3.221738e-06
I3318 n1_M2_101580_5460 0 5.172810e-06
I3319 n1_M2_101580_7620 0 7.501836e-06
I3320 n1_M2_101580_9780 0 9.097621e-06
I3321 n1_M2_101580_11940 0 9.497063e-06
I3322 n1_M2_101580_14100 0 1.072121e-05
I3323 n1_M2_101580_16260 0 1.108817e-05
I3324 n1_M2_101580_18420 0 1.412111e-05
I3325 n1_M2_101580_19500 0 1.244226e-05
I3326 n1_M2_101580_21660 0 9.344424e-06
I3327 n1_M2_101580_23820 0 7.698724e-06
I3328 n1_M2_101580_25980 0 9.210873e-06
I3329 n1_M2_101580_28140 0 1.541779e-05
I3330 n1_M2_101580_30300 0 1.060780e-05
I3331 n1_M2_101580_32460 0 1.226396e-05
I3332 n1_M2_101580_33540 0 1.626183e-05
I3333 n1_M2_101580_35700 0 1.369249e-05
I3334 n1_M2_101580_37860 0 1.218872e-05
I3335 n1_M2_101580_40020 0 1.477321e-05
I3336 n1_M2_101580_42180 0 1.619890e-05
I3337 n1_M2_101580_44340 0 1.385147e-05
I3338 n1_M2_101580_46500 0 1.332930e-05
I3339 n1_M2_101580_47580 0 9.408726e-06
I3340 n1_M2_101580_49740 0 1.109719e-05
I3341 n1_M2_101580_51900 0 1.104593e-05
I3342 n1_M2_101580_54060 0 9.927859e-06
I3343 n1_M2_101580_56220 0 1.267854e-05
I3344 n1_M2_101580_58380 0 1.442423e-05
I3345 n1_M2_101580_59460 0 1.173889e-05
I3346 n1_M2_101580_61620 0 1.262756e-05
I3347 n1_M2_101580_63780 0 1.923027e-05
I3348 n1_M2_101580_65940 0 2.310031e-05
I3349 n1_M2_101580_68100 0 2.605792e-05
I3350 n1_M2_101580_70260 0 2.545335e-05
I3351 n1_M2_101580_72420 0 2.562557e-05
I3352 n1_M2_101580_73500 0 2.404749e-05
I3353 n1_M2_101580_75660 0 2.175024e-05
I3354 n1_M2_101580_77820 0 1.691065e-05
I3355 n1_M2_101580_79980 0 1.640480e-05
I3356 n1_M2_101580_82140 0 2.127187e-05
I3357 n1_M2_101580_84300 0 1.962224e-05
I3358 n1_M2_101580_86460 0 1.869657e-05
I3359 n1_M2_101580_87540 0 2.085160e-05
I3360 n1_M2_101580_89700 0 1.864543e-05
I3361 n1_M2_101580_91860 0 1.555334e-05
I3362 n1_M2_101580_94020 0 2.379778e-05
I3363 n1_M2_101580_96180 0 2.586601e-05
I3364 n1_M2_101580_98340 0 2.400751e-05
I3365 n1_M2_101580_100500 0 1.962903e-05
I3366 n1_M2_101580_101580 0 2.235267e-05
I3367 n1_M2_101580_103740 0 2.302145e-05
I3368 n1_M2_101580_105900 0 1.922067e-05
I3369 n1_M2_101580_108060 0 1.234273e-05
I3370 n1_M2_101580_110220 0 1.076178e-05
I3371 n1_M2_101580_112380 0 1.247073e-05
I3372 n1_M2_101580_113460 0 1.965344e-05
I3373 n1_M2_101580_115620 0 1.900230e-05
I3374 n1_M2_101580_117780 0 1.515316e-05
I3375 n1_M2_101580_119940 0 1.276443e-05
I3376 n1_M2_101580_122100 0 7.974031e-06
I3377 n1_M2_101580_124260 0 3.619774e-06
I3378 n1_M2_101580_126420 0 2.913655e-06
I3379 n1_M2_101580_127500 0 2.903992e-06
I3380 n1_M2_103740_60 0 2.657599e-06
I3381 n1_M2_103740_2220 0 2.731473e-06
I3382 n1_M2_103740_4380 0 3.221120e-06
I3383 n1_M2_103740_5460 0 5.231315e-06
I3384 n1_M2_103740_7620 0 8.214530e-06
I3385 n1_M2_103740_9780 0 1.026332e-05
I3386 n1_M2_103740_11940 0 1.245855e-05
I3387 n1_M2_103740_14100 0 1.446126e-05
I3388 n1_M2_103740_16260 0 1.513089e-05
I3389 n1_M2_103740_18420 0 1.822852e-05
I3390 n1_M2_103740_19500 0 1.286067e-05
I3391 n1_M2_103740_21660 0 7.537020e-06
I3392 n1_M2_103740_23820 0 5.816035e-06
I3393 n1_M2_103740_25980 0 6.524154e-06
I3394 n1_M2_103740_28140 0 8.831421e-06
I3395 n1_M2_103740_30300 0 7.620220e-06
I3396 n1_M2_103740_32460 0 6.532508e-06
I3397 n1_M2_103740_33540 0 8.948141e-06
I3398 n1_M2_103740_35700 0 1.170809e-05
I3399 n1_M2_103740_37860 0 1.118810e-05
I3400 n1_M2_103740_40020 0 1.189581e-05
I3401 n1_M2_103740_42180 0 1.731766e-05
I3402 n1_M2_103740_44340 0 9.520814e-06
I3403 n1_M2_103740_46500 0 8.092948e-06
I3404 n1_M2_103740_47580 0 8.965581e-06
I3405 n1_M2_103740_49740 0 8.561844e-06
I3406 n1_M2_103740_51900 0 8.957175e-06
I3407 n1_M2_103740_54060 0 1.195606e-05
I3408 n1_M2_103740_56220 0 1.574033e-05
I3409 n1_M2_103740_58380 0 1.642250e-05
I3410 n1_M2_103740_59460 0 1.495708e-05
I3411 n1_M2_103740_61620 0 1.519678e-05
I3412 n1_M2_103740_63780 0 1.897737e-05
I3413 n1_M2_103740_65940 0 2.336829e-05
I3414 n1_M2_103740_68100 0 2.632246e-05
I3415 n1_M2_103740_70260 0 2.642110e-05
I3416 n1_M2_103740_72420 0 2.567199e-05
I3417 n1_M2_103740_73500 0 2.364634e-05
I3418 n1_M2_103740_75660 0 2.129253e-05
I3419 n1_M2_103740_77820 0 1.756043e-05
I3420 n1_M2_103740_79980 0 1.661241e-05
I3421 n1_M2_103740_82140 0 1.837411e-05
I3422 n1_M2_103740_84300 0 1.595087e-05
I3423 n1_M2_103740_86460 0 1.536522e-05
I3424 n1_M2_103740_87540 0 1.635510e-05
I3425 n1_M2_103740_89700 0 1.675662e-05
I3426 n1_M2_103740_91860 0 1.394193e-05
I3427 n1_M2_103740_94020 0 2.309648e-05
I3428 n1_M2_103740_96180 0 2.540274e-05
I3429 n1_M2_103740_98340 0 2.463821e-05
I3430 n1_M2_103740_100500 0 2.237708e-05
I3431 n1_M2_103740_101580 0 2.440989e-05
I3432 n1_M2_103740_103740 0 2.514142e-05
I3433 n1_M2_103740_105900 0 2.383537e-05
I3434 n1_M2_103740_108060 0 1.965789e-05
I3435 n1_M2_103740_110220 0 1.666003e-05
I3436 n1_M2_103740_112380 0 1.780075e-05
I3437 n1_M2_103740_113460 0 2.227596e-05
I3438 n1_M2_103740_115620 0 2.303424e-05
I3439 n1_M2_103740_117780 0 2.145829e-05
I3440 n1_M2_103740_119940 0 1.771865e-05
I3441 n1_M2_103740_122100 0 9.449106e-06
I3442 n1_M2_103740_124260 0 3.961372e-06
I3443 n1_M2_103740_126420 0 2.857519e-06
I3444 n1_M2_103740_127500 0 2.953013e-06
I3445 n1_M2_105900_60 0 2.610027e-06
I3446 n1_M2_105900_2220 0 2.771103e-06
I3447 n1_M2_105900_4380 0 3.192046e-06
I3448 n1_M2_105900_5460 0 4.369928e-06
I3449 n1_M2_105900_7620 0 7.029026e-06
I3450 n1_M2_105900_9780 0 8.846457e-06
I3451 n1_M2_105900_11940 0 1.331561e-05
I3452 n1_M2_105900_14100 0 1.823076e-05
I3453 n1_M2_105900_16260 0 2.170797e-05
I3454 n1_M2_105900_18420 0 2.175305e-05
I3455 n1_M2_105900_19500 0 1.614168e-05
I3456 n1_M2_105900_21660 0 8.714395e-06
I3457 n1_M2_105900_23820 0 4.401620e-06
I3458 n1_M2_105900_25980 0 4.529952e-06
I3459 n1_M2_105900_28140 0 5.706756e-06
I3460 n1_M2_105900_30300 0 4.877298e-06
I3461 n1_M2_105900_32460 0 4.932140e-06
I3462 n1_M2_105900_33540 0 6.303035e-06
I3463 n1_M2_105900_35700 0 9.275624e-06
I3464 n1_M2_105900_37860 0 1.406997e-05
I3465 n1_M2_105900_40020 0 1.305719e-05
I3466 n1_M2_105900_42180 0 1.538758e-05
I3467 n1_M2_105900_44340 0 1.285853e-05
I3468 n1_M2_105900_46500 0 8.503341e-06
I3469 n1_M2_105900_47580 0 7.600795e-06
I3470 n1_M2_105900_49740 0 1.029547e-05
I3471 n1_M2_105900_51900 0 9.290055e-06
I3472 n1_M2_105900_54060 0 1.068806e-05
I3473 n1_M2_105900_56220 0 1.711018e-05
I3474 n1_M2_105900_58380 0 2.102948e-05
I3475 n1_M2_105900_59460 0 1.901815e-05
I3476 n1_M2_105900_61620 0 1.888773e-05
I3477 n1_M2_105900_63780 0 2.045511e-05
I3478 n1_M2_105900_65940 0 2.236256e-05
I3479 n1_M2_105900_68100 0 2.534651e-05
I3480 n1_M2_105900_70260 0 2.626098e-05
I3481 n1_M2_105900_72420 0 2.468598e-05
I3482 n1_M2_105900_73500 0 2.273927e-05
I3483 n1_M2_105900_75660 0 2.039470e-05
I3484 n1_M2_105900_77820 0 1.643362e-05
I3485 n1_M2_105900_79980 0 1.639287e-05
I3486 n1_M2_105900_82140 0 1.298478e-05
I3487 n1_M2_105900_84300 0 1.012345e-05
I3488 n1_M2_105900_86460 0 1.059163e-05
I3489 n1_M2_105900_87540 0 1.267708e-05
I3490 n1_M2_105900_89700 0 1.346213e-05
I3491 n1_M2_105900_91860 0 1.268955e-05
I3492 n1_M2_105900_94020 0 2.223395e-05
I3493 n1_M2_105900_96180 0 2.480388e-05
I3494 n1_M2_105900_98340 0 2.475181e-05
I3495 n1_M2_105900_100500 0 2.375720e-05
I3496 n1_M2_105900_101580 0 2.528323e-05
I3497 n1_M2_105900_103740 0 2.650919e-05
I3498 n1_M2_105900_105900 0 2.613633e-05
I3499 n1_M2_105900_108060 0 2.347701e-05
I3500 n1_M2_105900_110220 0 2.215300e-05
I3501 n1_M2_105900_112380 0 2.282301e-05
I3502 n1_M2_105900_113460 0 2.425951e-05
I3503 n1_M2_105900_115620 0 2.538250e-05
I3504 n1_M2_105900_117780 0 2.534247e-05
I3505 n1_M2_105900_119940 0 2.356535e-05
I3506 n1_M2_105900_122100 0 1.349667e-05
I3507 n1_M2_105900_124260 0 4.424881e-06
I3508 n1_M2_105900_126420 0 2.892020e-06
I3509 n1_M2_105900_127500 0 2.913753e-06
I3510 n1_M2_108060_60 0 2.661559e-06
I3511 n1_M2_108060_2220 0 2.777321e-06
I3512 n1_M2_108060_4380 0 3.139584e-06
I3513 n1_M2_108060_5460 0 4.058296e-06
I3514 n1_M2_108060_7620 0 6.303944e-06
I3515 n1_M2_108060_9780 0 9.086214e-06
I3516 n1_M2_108060_11940 0 1.324296e-05
I3517 n1_M2_108060_14100 0 1.870968e-05
I3518 n1_M2_108060_16260 0 2.318703e-05
I3519 n1_M2_108060_18420 0 2.408445e-05
I3520 n1_M2_108060_19500 0 2.043759e-05
I3521 n1_M2_108060_21660 0 1.157529e-05
I3522 n1_M2_108060_23820 0 5.062743e-06
I3523 n1_M2_108060_25980 0 4.380713e-06
I3524 n1_M2_108060_28140 0 4.900489e-06
I3525 n1_M2_108060_30300 0 4.552134e-06
I3526 n1_M2_108060_32460 0 4.819040e-06
I3527 n1_M2_108060_33540 0 4.974469e-06
I3528 n1_M2_108060_35700 0 9.592812e-06
I3529 n1_M2_108060_37860 0 1.406554e-05
I3530 n1_M2_108060_40020 0 1.673391e-05
I3531 n1_M2_108060_42180 0 1.582470e-05
I3532 n1_M2_108060_44340 0 1.243986e-05
I3533 n1_M2_108060_46500 0 1.199734e-05
I3534 n1_M2_108060_47580 0 8.691942e-06
I3535 n1_M2_108060_49740 0 9.263007e-06
I3536 n1_M2_108060_51900 0 8.234465e-06
I3537 n1_M2_108060_54060 0 7.766779e-06
I3538 n1_M2_108060_56220 0 1.388435e-05
I3539 n1_M2_108060_58380 0 2.143596e-05
I3540 n1_M2_108060_59460 0 1.956799e-05
I3541 n1_M2_108060_61620 0 1.760616e-05
I3542 n1_M2_108060_63780 0 1.836542e-05
I3543 n1_M2_108060_65940 0 1.796250e-05
I3544 n1_M2_108060_68100 0 2.303194e-05
I3545 n1_M2_108060_70260 0 2.504614e-05
I3546 n1_M2_108060_72420 0 2.267134e-05
I3547 n1_M2_108060_73500 0 2.083987e-05
I3548 n1_M2_108060_75660 0 1.743441e-05
I3549 n1_M2_108060_77820 0 1.326218e-05
I3550 n1_M2_108060_79980 0 1.209054e-05
I3551 n1_M2_108060_82140 0 9.638910e-06
I3552 n1_M2_108060_84300 0 5.076841e-06
I3553 n1_M2_108060_86460 0 4.764393e-06
I3554 n1_M2_108060_87540 0 7.722610e-06
I3555 n1_M2_108060_89700 0 9.922567e-06
I3556 n1_M2_108060_91860 0 1.099061e-05
I3557 n1_M2_108060_94020 0 2.223037e-05
I3558 n1_M2_108060_96180 0 2.515176e-05
I3559 n1_M2_108060_98340 0 2.405272e-05
I3560 n1_M2_108060_100500 0 2.370159e-05
I3561 n1_M2_108060_101580 0 2.511861e-05
I3562 n1_M2_108060_103740 0 2.599170e-05
I3563 n1_M2_108060_105900 0 2.523996e-05
I3564 n1_M2_108060_108060 0 2.268786e-05
I3565 n1_M2_108060_110220 0 2.180583e-05
I3566 n1_M2_108060_112380 0 2.217883e-05
I3567 n1_M2_108060_113460 0 2.300347e-05
I3568 n1_M2_108060_115620 0 2.426075e-05
I3569 n1_M2_108060_117780 0 2.432409e-05
I3570 n1_M2_108060_119940 0 2.255411e-05
I3571 n1_M2_108060_122100 0 1.149069e-05
I3572 n1_M2_108060_124260 0 3.934481e-06
I3573 n1_M2_108060_126420 0 2.745957e-06
I3574 n1_M2_108060_127500 0 2.839228e-06
I3575 n1_M2_110220_60 0 2.662557e-06
I3576 n1_M2_110220_2220 0 2.777427e-06
I3577 n1_M2_110220_4380 0 3.132078e-06
I3578 n1_M2_110220_5460 0 3.726732e-06
I3579 n1_M2_110220_7620 0 4.544323e-06
I3580 n1_M2_110220_9780 0 7.168576e-06
I3581 n1_M2_110220_11940 0 1.514959e-05
I3582 n1_M2_110220_14100 0 2.101120e-05
I3583 n1_M2_110220_16260 0 2.458215e-05
I3584 n1_M2_110220_18420 0 2.601262e-05
I3585 n1_M2_110220_19500 0 2.384189e-05
I3586 n1_M2_110220_21660 0 1.655901e-05
I3587 n1_M2_110220_23820 0 7.516069e-06
I3588 n1_M2_110220_25980 0 5.409367e-06
I3589 n1_M2_110220_28140 0 5.089564e-06
I3590 n1_M2_110220_30300 0 5.019856e-06
I3591 n1_M2_110220_32460 0 4.209990e-06
I3592 n1_M2_110220_33540 0 4.839695e-06
I3593 n1_M2_110220_35700 0 9.099361e-06
I3594 n1_M2_110220_37860 0 1.309358e-05
I3595 n1_M2_110220_40020 0 1.550639e-05
I3596 n1_M2_110220_42180 0 1.686910e-05
I3597 n1_M2_110220_44340 0 1.386781e-05
I3598 n1_M2_110220_46500 0 1.199546e-05
I3599 n1_M2_110220_47580 0 1.068326e-05
I3600 n1_M2_110220_49740 0 9.200484e-06
I3601 n1_M2_110220_51900 0 7.411124e-06
I3602 n1_M2_110220_54060 0 7.565377e-06
I3603 n1_M2_110220_56220 0 1.179205e-05
I3604 n1_M2_110220_58380 0 1.953733e-05
I3605 n1_M2_110220_59460 0 1.670781e-05
I3606 n1_M2_110220_61620 0 1.435498e-05
I3607 n1_M2_110220_63780 0 1.503784e-05
I3608 n1_M2_110220_65940 0 1.422048e-05
I3609 n1_M2_110220_68100 0 2.068742e-05
I3610 n1_M2_110220_70260 0 2.369526e-05
I3611 n1_M2_110220_72420 0 2.223520e-05
I3612 n1_M2_110220_73500 0 2.143665e-05
I3613 n1_M2_110220_75660 0 1.859064e-05
I3614 n1_M2_110220_77820 0 1.437554e-05
I3615 n1_M2_110220_79980 0 1.178705e-05
I3616 n1_M2_110220_82140 0 9.766259e-06
I3617 n1_M2_110220_84300 0 6.389985e-06
I3618 n1_M2_110220_86460 0 5.239244e-06
I3619 n1_M2_110220_87540 0 6.435993e-06
I3620 n1_M2_110220_89700 0 9.015843e-06
I3621 n1_M2_110220_91860 0 1.081231e-05
I3622 n1_M2_110220_94020 0 2.226461e-05
I3623 n1_M2_110220_96180 0 2.506367e-05
I3624 n1_M2_110220_98340 0 2.327334e-05
I3625 n1_M2_110220_100500 0 2.324287e-05
I3626 n1_M2_110220_101580 0 2.502837e-05
I3627 n1_M2_110220_103740 0 2.578335e-05
I3628 n1_M2_110220_105900 0 2.456099e-05
I3629 n1_M2_110220_108060 0 2.154599e-05
I3630 n1_M2_110220_110220 0 2.071856e-05
I3631 n1_M2_110220_112380 0 1.995525e-05
I3632 n1_M2_110220_113460 0 1.922850e-05
I3633 n1_M2_110220_115620 0 2.049760e-05
I3634 n1_M2_110220_117780 0 1.843744e-05
I3635 n1_M2_110220_119940 0 1.516553e-05
I3636 n1_M2_110220_122100 0 8.160791e-06
I3637 n1_M2_110220_124260 0 3.506103e-06
I3638 n1_M2_110220_126420 0 2.687691e-06
I3639 n1_M2_110220_127500 0 2.653523e-06
I3640 n1_M2_112380_60 0 2.666578e-06
I3641 n1_M2_112380_2220 0 2.773781e-06
I3642 n1_M2_112380_4380 0 3.094213e-06
I3643 n1_M2_112380_5460 0 3.472627e-06
I3644 n1_M2_112380_7620 0 3.675754e-06
I3645 n1_M2_112380_9780 0 5.471741e-06
I3646 n1_M2_112380_11940 0 1.295905e-05
I3647 n1_M2_112380_14100 0 2.200597e-05
I3648 n1_M2_112380_16260 0 2.543526e-05
I3649 n1_M2_112380_18420 0 2.565259e-05
I3650 n1_M2_112380_19500 0 2.398063e-05
I3651 n1_M2_112380_21660 0 1.831069e-05
I3652 n1_M2_112380_23820 0 1.005798e-05
I3653 n1_M2_112380_25980 0 6.716735e-06
I3654 n1_M2_112380_28140 0 5.172597e-06
I3655 n1_M2_112380_30300 0 4.659826e-06
I3656 n1_M2_112380_32460 0 4.442349e-06
I3657 n1_M2_112380_33540 0 6.078224e-06
I3658 n1_M2_112380_35700 0 9.059796e-06
I3659 n1_M2_112380_37860 0 1.294720e-05
I3660 n1_M2_112380_40020 0 1.656745e-05
I3661 n1_M2_112380_42180 0 1.918972e-05
I3662 n1_M2_112380_44340 0 1.415089e-05
I3663 n1_M2_112380_46500 0 1.047320e-05
I3664 n1_M2_112380_47580 0 1.111417e-05
I3665 n1_M2_112380_49740 0 1.006547e-05
I3666 n1_M2_112380_51900 0 9.271970e-06
I3667 n1_M2_112380_54060 0 9.668884e-06
I3668 n1_M2_112380_56220 0 1.167534e-05
I3669 n1_M2_112380_58380 0 1.694986e-05
I3670 n1_M2_112380_59460 0 1.360946e-05
I3671 n1_M2_112380_61620 0 1.232845e-05
I3672 n1_M2_112380_63780 0 1.388604e-05
I3673 n1_M2_112380_65940 0 1.283236e-05
I3674 n1_M2_112380_68100 0 1.938463e-05
I3675 n1_M2_112380_70260 0 2.330873e-05
I3676 n1_M2_112380_72420 0 2.225577e-05
I3677 n1_M2_112380_73500 0 2.240978e-05
I3678 n1_M2_112380_75660 0 2.176515e-05
I3679 n1_M2_112380_77820 0 1.998582e-05
I3680 n1_M2_112380_79980 0 1.612569e-05
I3681 n1_M2_112380_82140 0 1.229905e-05
I3682 n1_M2_112380_84300 0 8.229920e-06
I3683 n1_M2_112380_86460 0 6.575003e-06
I3684 n1_M2_112380_87540 0 7.600352e-06
I3685 n1_M2_112380_89700 0 1.032577e-05
I3686 n1_M2_112380_91860 0 1.216779e-05
I3687 n1_M2_112380_94020 0 2.100451e-05
I3688 n1_M2_112380_96180 0 2.241033e-05
I3689 n1_M2_112380_98340 0 2.062986e-05
I3690 n1_M2_112380_100500 0 2.172721e-05
I3691 n1_M2_112380_101580 0 2.362996e-05
I3692 n1_M2_112380_103740 0 2.390170e-05
I3693 n1_M2_112380_105900 0 2.250174e-05
I3694 n1_M2_112380_108060 0 1.717180e-05
I3695 n1_M2_112380_110220 0 1.641105e-05
I3696 n1_M2_112380_112380 0 1.473906e-05
I3697 n1_M2_112380_113460 0 1.039130e-05
I3698 n1_M2_112380_115620 0 1.058305e-05
I3699 n1_M2_112380_117780 0 8.863578e-06
I3700 n1_M2_112380_119940 0 7.118094e-06
I3701 n1_M2_112380_122100 0 4.406773e-06
I3702 n1_M2_112380_124260 0 3.107291e-06
I3703 n1_M2_112380_126420 0 2.744221e-06
I3704 n1_M2_112380_127500 0 2.653813e-06
I3705 n1_M2_113460_60 0 2.719831e-06
I3706 n1_M2_113460_2220 0 2.732550e-06
I3707 n1_M2_113460_4380 0 3.069374e-06
I3708 n1_M2_113460_5460 0 3.144953e-06
I3709 n1_M2_113460_7620 0 3.285891e-06
I3710 n1_M2_113460_9780 0 4.033613e-06
I3711 n1_M2_113460_11940 0 9.110857e-06
I3712 n1_M2_113460_14100 0 2.124070e-05
I3713 n1_M2_113460_16260 0 2.552672e-05
I3714 n1_M2_113460_18420 0 2.620653e-05
I3715 n1_M2_113460_19500 0 2.558667e-05
I3716 n1_M2_113460_21660 0 2.244844e-05
I3717 n1_M2_113460_23820 0 1.977452e-05
I3718 n1_M2_113460_25980 0 1.187092e-05
I3719 n1_M2_113460_28140 0 7.105551e-06
I3720 n1_M2_113460_30300 0 5.580810e-06
I3721 n1_M2_113460_32460 0 5.441732e-06
I3722 n1_M2_113460_33540 0 5.976476e-06
I3723 n1_M2_113460_35700 0 9.669361e-06
I3724 n1_M2_113460_37860 0 1.319193e-05
I3725 n1_M2_113460_40020 0 2.043476e-05
I3726 n1_M2_113460_42180 0 2.140629e-05
I3727 n1_M2_113460_44340 0 1.677744e-05
I3728 n1_M2_113460_46500 0 1.039093e-05
I3729 n1_M2_113460_47580 0 9.309482e-06
I3730 n1_M2_113460_49740 0 9.491108e-06
I3731 n1_M2_113460_51900 0 1.028560e-05
I3732 n1_M2_113460_54060 0 1.046173e-05
I3733 n1_M2_113460_56220 0 1.106532e-05
I3734 n1_M2_113460_58380 0 1.450801e-05
I3735 n1_M2_113460_59460 0 1.132788e-05
I3736 n1_M2_113460_61620 0 1.123083e-05
I3737 n1_M2_113460_63780 0 1.728063e-05
I3738 n1_M2_113460_65940 0 1.696054e-05
I3739 n1_M2_113460_68100 0 2.069239e-05
I3740 n1_M2_113460_70260 0 2.331374e-05
I3741 n1_M2_113460_72420 0 2.157481e-05
I3742 n1_M2_113460_73500 0 2.124425e-05
I3743 n1_M2_113460_75660 0 2.135614e-05
I3744 n1_M2_113460_77820 0 1.809681e-05
I3745 n1_M2_113460_79980 0 1.478072e-05
I3746 n1_M2_113460_82140 0 1.237566e-05
I3747 n1_M2_113460_84300 0 1.000261e-05
I3748 n1_M2_113460_86460 0 8.626544e-06
I3749 n1_M2_113460_87540 0 1.099532e-05
I3750 n1_M2_113460_89700 0 1.275296e-05
I3751 n1_M2_113460_91860 0 1.372852e-05
I3752 n1_M2_113460_94020 0 1.930842e-05
I3753 n1_M2_113460_96180 0 2.024196e-05
I3754 n1_M2_113460_98340 0 1.682728e-05
I3755 n1_M2_113460_100500 0 1.492776e-05
I3756 n1_M2_113460_101580 0 1.423645e-05
I3757 n1_M2_113460_103740 0 1.365542e-05
I3758 n1_M2_113460_105900 0 1.268797e-05
I3759 n1_M2_113460_108060 0 9.735131e-06
I3760 n1_M2_113460_110220 0 9.218832e-06
I3761 n1_M2_113460_112380 0 9.321953e-06
I3762 n1_M2_113460_113460 0 6.017218e-06
I3763 n1_M2_113460_115620 0 4.868126e-06
I3764 n1_M2_113460_117780 0 4.002667e-06
I3765 n1_M2_113460_119940 0 3.682226e-06
I3766 n1_M2_113460_122100 0 3.414699e-06
I3767 n1_M2_113460_124260 0 3.078602e-06
I3768 n1_M2_113460_126420 0 2.760037e-06
I3769 n1_M2_113460_127500 0 2.701995e-06
I3770 n1_M2_115620_60 0 2.774582e-06
I3771 n1_M2_115620_2220 0 2.746923e-06
I3772 n1_M2_115620_4380 0 3.071090e-06
I3773 n1_M2_115620_5460 0 3.130468e-06
I3774 n1_M2_115620_7620 0 3.226281e-06
I3775 n1_M2_115620_9780 0 3.809315e-06
I3776 n1_M2_115620_11940 0 7.593386e-06
I3777 n1_M2_115620_14100 0 2.125568e-05
I3778 n1_M2_115620_16260 0 2.529832e-05
I3779 n1_M2_115620_18420 0 2.622796e-05
I3780 n1_M2_115620_19500 0 2.604100e-05
I3781 n1_M2_115620_21660 0 2.506479e-05
I3782 n1_M2_115620_23820 0 2.316392e-05
I3783 n1_M2_115620_25980 0 1.482738e-05
I3784 n1_M2_115620_28140 0 7.660577e-06
I3785 n1_M2_115620_30300 0 4.743084e-06
I3786 n1_M2_115620_32460 0 4.235831e-06
I3787 n1_M2_115620_33540 0 6.003197e-06
I3788 n1_M2_115620_35700 0 9.279849e-06
I3789 n1_M2_115620_37860 0 1.045358e-05
I3790 n1_M2_115620_40020 0 1.715116e-05
I3791 n1_M2_115620_42180 0 2.179621e-05
I3792 n1_M2_115620_44340 0 2.039537e-05
I3793 n1_M2_115620_46500 0 1.422772e-05
I3794 n1_M2_115620_47580 0 1.207253e-05
I3795 n1_M2_115620_49740 0 9.529831e-06
I3796 n1_M2_115620_51900 0 8.006871e-06
I3797 n1_M2_115620_54060 0 7.694248e-06
I3798 n1_M2_115620_56220 0 7.627669e-06
I3799 n1_M2_115620_58380 0 1.129076e-05
I3800 n1_M2_115620_59460 0 9.996136e-06
I3801 n1_M2_115620_61620 0 1.103731e-05
I3802 n1_M2_115620_63780 0 1.791099e-05
I3803 n1_M2_115620_65940 0 1.646873e-05
I3804 n1_M2_115620_68100 0 1.858777e-05
I3805 n1_M2_115620_70260 0 2.208195e-05
I3806 n1_M2_115620_72420 0 1.954410e-05
I3807 n1_M2_115620_73500 0 1.807356e-05
I3808 n1_M2_115620_75660 0 1.769629e-05
I3809 n1_M2_115620_77820 0 1.316859e-05
I3810 n1_M2_115620_79980 0 1.015054e-05
I3811 n1_M2_115620_82140 0 8.996779e-06
I3812 n1_M2_115620_84300 0 1.110022e-05
I3813 n1_M2_115620_86460 0 1.240854e-05
I3814 n1_M2_115620_87540 0 1.207242e-05
I3815 n1_M2_115620_89700 0 1.249201e-05
I3816 n1_M2_115620_91860 0 1.351437e-05
I3817 n1_M2_115620_94020 0 1.868083e-05
I3818 n1_M2_115620_96180 0 1.718817e-05
I3819 n1_M2_115620_98340 0 1.260868e-05
I3820 n1_M2_115620_100500 0 7.418776e-06
I3821 n1_M2_115620_101580 0 4.598493e-06
I3822 n1_M2_115620_103740 0 4.478444e-06
I3823 n1_M2_115620_105900 0 4.909544e-06
I3824 n1_M2_115620_108060 0 4.479324e-06
I3825 n1_M2_115620_110220 0 5.717007e-06
I3826 n1_M2_115620_112380 0 6.229610e-06
I3827 n1_M2_115620_113460 0 3.656387e-06
I3828 n1_M2_115620_115620 0 3.310263e-06
I3829 n1_M2_115620_117780 0 3.165914e-06
I3830 n1_M2_115620_119940 0 3.136996e-06
I3831 n1_M2_115620_122100 0 3.183681e-06
I3832 n1_M2_115620_124260 0 2.963477e-06
I3833 n1_M2_115620_126420 0 2.669420e-06
I3834 n1_M2_115620_127500 0 2.664373e-06
I3835 n1_M2_117780_60 0 2.832059e-06
I3836 n1_M2_117780_2220 0 2.815251e-06
I3837 n1_M2_117780_4380 0 3.074567e-06
I3838 n1_M2_117780_5460 0 3.161308e-06
I3839 n1_M2_117780_7620 0 3.269991e-06
I3840 n1_M2_117780_9780 0 3.483017e-06
I3841 n1_M2_117780_11940 0 5.707988e-06
I3842 n1_M2_117780_14100 0 1.775612e-05
I3843 n1_M2_117780_16260 0 2.426570e-05
I3844 n1_M2_117780_18420 0 2.638339e-05
I3845 n1_M2_117780_19500 0 2.542375e-05
I3846 n1_M2_117780_21660 0 2.542260e-05
I3847 n1_M2_117780_23820 0 2.438264e-05
I3848 n1_M2_117780_25980 0 1.825727e-05
I3849 n1_M2_117780_28140 0 1.044431e-05
I3850 n1_M2_117780_30300 0 6.264125e-06
I3851 n1_M2_117780_32460 0 4.051592e-06
I3852 n1_M2_117780_33540 0 6.019160e-06
I3853 n1_M2_117780_35700 0 8.999475e-06
I3854 n1_M2_117780_37860 0 9.660275e-06
I3855 n1_M2_117780_40020 0 1.272850e-05
I3856 n1_M2_117780_42180 0 1.968352e-05
I3857 n1_M2_117780_44340 0 2.186737e-05
I3858 n1_M2_117780_46500 0 1.767436e-05
I3859 n1_M2_117780_47580 0 1.240348e-05
I3860 n1_M2_117780_49740 0 8.544825e-06
I3861 n1_M2_117780_51900 0 6.034539e-06
I3862 n1_M2_117780_54060 0 5.599484e-06
I3863 n1_M2_117780_56220 0 5.261969e-06
I3864 n1_M2_117780_58380 0 6.364261e-06
I3865 n1_M2_117780_59460 0 6.211651e-06
I3866 n1_M2_117780_61620 0 6.875786e-06
I3867 n1_M2_117780_63780 0 8.717389e-06
I3868 n1_M2_117780_65940 0 8.159015e-06
I3869 n1_M2_117780_68100 0 1.179244e-05
I3870 n1_M2_117780_70260 0 1.699765e-05
I3871 n1_M2_117780_72420 0 1.413462e-05
I3872 n1_M2_117780_73500 0 1.230460e-05
I3873 n1_M2_117780_75660 0 1.014461e-05
I3874 n1_M2_117780_77820 0 7.117323e-06
I3875 n1_M2_117780_79980 0 6.344660e-06
I3876 n1_M2_117780_82140 0 5.843958e-06
I3877 n1_M2_117780_84300 0 7.392330e-06
I3878 n1_M2_117780_86460 0 9.787332e-06
I3879 n1_M2_117780_87540 0 9.848609e-06
I3880 n1_M2_117780_89700 0 9.804734e-06
I3881 n1_M2_117780_91860 0 1.462959e-05
I3882 n1_M2_117780_94020 0 2.178354e-05
I3883 n1_M2_117780_96180 0 2.079986e-05
I3884 n1_M2_117780_98340 0 1.445134e-05
I3885 n1_M2_117780_100500 0 6.257861e-06
I3886 n1_M2_117780_101580 0 3.682658e-06
I3887 n1_M2_117780_103740 0 3.580340e-06
I3888 n1_M2_117780_105900 0 3.785280e-06
I3889 n1_M2_117780_108060 0 3.839663e-06
I3890 n1_M2_117780_110220 0 4.790180e-06
I3891 n1_M2_117780_112380 0 4.712041e-06
I3892 n1_M2_117780_113460 0 3.349484e-06
I3893 n1_M2_117780_115620 0 3.220873e-06
I3894 n1_M2_117780_117780 0 3.144589e-06
I3895 n1_M2_117780_119940 0 3.137704e-06
I3896 n1_M2_117780_122100 0 3.003899e-06
I3897 n1_M2_117780_124260 0 2.818420e-06
I3898 n1_M2_117780_126420 0 2.583466e-06
I3899 n1_M2_117780_127500 0 2.624439e-06
I3900 n1_M2_119940_60 0 2.839814e-06
I3901 n1_M2_119940_2220 0 2.764988e-06
I3902 n1_M2_119940_4380 0 3.069240e-06
I3903 n1_M2_119940_5460 0 3.178688e-06
I3904 n1_M2_119940_7620 0 3.288766e-06
I3905 n1_M2_119940_9780 0 3.277961e-06
I3906 n1_M2_119940_11940 0 4.170566e-06
I3907 n1_M2_119940_14100 0 1.240429e-05
I3908 n1_M2_119940_16260 0 2.037748e-05
I3909 n1_M2_119940_18420 0 2.577126e-05
I3910 n1_M2_119940_19500 0 2.563658e-05
I3911 n1_M2_119940_21660 0 2.509296e-05
I3912 n1_M2_119940_23820 0 2.270387e-05
I3913 n1_M2_119940_25980 0 1.741057e-05
I3914 n1_M2_119940_28140 0 9.241040e-06
I3915 n1_M2_119940_30300 0 4.130761e-06
I3916 n1_M2_119940_32460 0 3.506693e-06
I3917 n1_M2_119940_33540 0 3.935396e-06
I3918 n1_M2_119940_35700 0 4.874517e-06
I3919 n1_M2_119940_37860 0 5.457858e-06
I3920 n1_M2_119940_40020 0 8.011799e-06
I3921 n1_M2_119940_42180 0 1.124501e-05
I3922 n1_M2_119940_44340 0 1.867454e-05
I3923 n1_M2_119940_46500 0 1.794220e-05
I3924 n1_M2_119940_47580 0 1.111685e-05
I3925 n1_M2_119940_49740 0 7.156878e-06
I3926 n1_M2_119940_51900 0 4.915726e-06
I3927 n1_M2_119940_54060 0 4.146657e-06
I3928 n1_M2_119940_56220 0 3.999756e-06
I3929 n1_M2_119940_58380 0 5.359104e-06
I3930 n1_M2_119940_59460 0 4.419630e-06
I3931 n1_M2_119940_61620 0 3.827223e-06
I3932 n1_M2_119940_63780 0 4.950851e-06
I3933 n1_M2_119940_65940 0 4.722048e-06
I3934 n1_M2_119940_68100 0 7.419548e-06
I3935 n1_M2_119940_70260 0 1.216855e-05
I3936 n1_M2_119940_72420 0 1.029280e-05
I3937 n1_M2_119940_73500 0 8.332030e-06
I3938 n1_M2_119940_75660 0 7.088593e-06
I3939 n1_M2_119940_77820 0 4.775866e-06
I3940 n1_M2_119940_79980 0 4.321271e-06
I3941 n1_M2_119940_82140 0 4.169437e-06
I3942 n1_M2_119940_84300 0 4.197703e-06
I3943 n1_M2_119940_86460 0 4.991418e-06
I3944 n1_M2_119940_87540 0 5.593445e-06
I3945 n1_M2_119940_89700 0 7.552561e-06
I3946 n1_M2_119940_91860 0 1.712866e-05
I3947 n1_M2_119940_94020 0 2.535388e-05
I3948 n1_M2_119940_96180 0 2.530596e-05
I3949 n1_M2_119940_98340 0 2.044283e-05
I3950 n1_M2_119940_100500 0 7.199125e-06
I3951 n1_M2_119940_101580 0 4.241570e-06
I3952 n1_M2_119940_103740 0 3.313978e-06
I3953 n1_M2_119940_105900 0 3.351346e-06
I3954 n1_M2_119940_108060 0 3.307902e-06
I3955 n1_M2_119940_110220 0 3.699525e-06
I3956 n1_M2_119940_112380 0 3.669777e-06
I3957 n1_M2_119940_113460 0 3.245138e-06
I3958 n1_M2_119940_115620 0 3.111889e-06
I3959 n1_M2_119940_117780 0 3.081273e-06
I3960 n1_M2_119940_119940 0 3.002326e-06
I3961 n1_M2_119940_122100 0 2.859453e-06
I3962 n1_M2_119940_124260 0 2.702243e-06
I3963 n1_M2_119940_126420 0 2.548746e-06
I3964 n1_M2_119940_127500 0 2.604430e-06
I3965 n1_M2_122100_60 0 2.900440e-06
I3966 n1_M2_122100_2220 0 2.743674e-06
I3967 n1_M2_122100_4380 0 2.967337e-06
I3968 n1_M2_122100_5460 0 3.050433e-06
I3969 n1_M2_122100_7620 0 3.086883e-06
I3970 n1_M2_122100_9780 0 3.121839e-06
I3971 n1_M2_122100_11940 0 3.517471e-06
I3972 n1_M2_122100_14100 0 5.131646e-06
I3973 n1_M2_122100_16260 0 8.832719e-06
I3974 n1_M2_122100_18420 0 1.516973e-05
I3975 n1_M2_122100_19500 0 1.644842e-05
I3976 n1_M2_122100_21660 0 1.339040e-05
I3977 n1_M2_122100_23820 0 9.812092e-06
I3978 n1_M2_122100_25980 0 7.123231e-06
I3979 n1_M2_122100_28140 0 4.589315e-06
I3980 n1_M2_122100_30300 0 3.461632e-06
I3981 n1_M2_122100_32460 0 3.317235e-06
I3982 n1_M2_122100_33540 0 3.243786e-06
I3983 n1_M2_122100_35700 0 3.352324e-06
I3984 n1_M2_122100_37860 0 3.473022e-06
I3985 n1_M2_122100_40020 0 4.364137e-06
I3986 n1_M2_122100_42180 0 6.376002e-06
I3987 n1_M2_122100_44340 0 1.082540e-05
I3988 n1_M2_122100_46500 0 1.736838e-05
I3989 n1_M2_122100_47580 0 1.378039e-05
I3990 n1_M2_122100_49740 0 8.921811e-06
I3991 n1_M2_122100_51900 0 5.647079e-06
I3992 n1_M2_122100_54060 0 5.685553e-06
I3993 n1_M2_122100_56220 0 5.874882e-06
I3994 n1_M2_122100_58380 0 5.390166e-06
I3995 n1_M2_122100_59460 0 4.582535e-06
I3996 n1_M2_122100_61620 0 3.948937e-06
I3997 n1_M2_122100_63780 0 3.609189e-06
I3998 n1_M2_122100_65940 0 3.641695e-06
I3999 n1_M2_122100_68100 0 4.109565e-06
I4000 n1_M2_122100_70260 0 4.786845e-06
I4001 n1_M2_122100_72420 0 4.764431e-06
I4002 n1_M2_122100_73500 0 4.570365e-06
I4003 n1_M2_122100_75660 0 3.982362e-06
I4004 n1_M2_122100_77820 0 3.486844e-06
I4005 n1_M2_122100_79980 0 3.321792e-06
I4006 n1_M2_122100_82140 0 3.377589e-06
I4007 n1_M2_122100_84300 0 3.378164e-06
I4008 n1_M2_122100_86460 0 3.316057e-06
I4009 n1_M2_122100_87540 0 3.389486e-06
I4010 n1_M2_122100_89700 0 4.247369e-06
I4011 n1_M2_122100_91860 0 1.037274e-05
I4012 n1_M2_122100_94020 0 2.173957e-05
I4013 n1_M2_122100_96180 0 2.237384e-05
I4014 n1_M2_122100_98340 0 1.568780e-05
I4015 n1_M2_122100_100500 0 6.305910e-06
I4016 n1_M2_122100_101580 0 3.702156e-06
I4017 n1_M2_122100_103740 0 3.286869e-06
I4018 n1_M2_122100_105900 0 3.135019e-06
I4019 n1_M2_122100_108060 0 3.132899e-06
I4020 n1_M2_122100_110220 0 3.188862e-06
I4021 n1_M2_122100_112380 0 3.149914e-06
I4022 n1_M2_122100_113460 0 3.110999e-06
I4023 n1_M2_122100_115620 0 3.118974e-06
I4024 n1_M2_122100_117780 0 3.036776e-06
I4025 n1_M2_122100_119940 0 2.821935e-06
I4026 n1_M2_122100_122100 0 2.688445e-06
I4027 n1_M2_122100_124260 0 2.618929e-06
I4028 n1_M2_122100_126420 0 2.536809e-06
I4029 n1_M2_122100_127500 0 2.570102e-06
I4030 n1_M2_124260_60 0 2.840364e-06
I4031 n1_M2_124260_2220 0 2.671427e-06
I4032 n1_M2_124260_4380 0 2.786721e-06
I4033 n1_M2_124260_5460 0 2.824070e-06
I4034 n1_M2_124260_7620 0 2.937400e-06
I4035 n1_M2_124260_9780 0 2.919048e-06
I4036 n1_M2_124260_11940 0 3.019042e-06
I4037 n1_M2_124260_14100 0 3.069353e-06
I4038 n1_M2_124260_16260 0 3.458719e-06
I4039 n1_M2_124260_18420 0 3.724168e-06
I4040 n1_M2_124260_19500 0 3.536807e-06
I4041 n1_M2_124260_21660 0 3.551232e-06
I4042 n1_M2_124260_23820 0 3.312544e-06
I4043 n1_M2_124260_25980 0 3.189654e-06
I4044 n1_M2_124260_28140 0 3.229487e-06
I4045 n1_M2_124260_30300 0 3.346979e-06
I4046 n1_M2_124260_32460 0 3.155365e-06
I4047 n1_M2_124260_33540 0 3.084637e-06
I4048 n1_M2_124260_35700 0 3.181788e-06
I4049 n1_M2_124260_37860 0 3.191979e-06
I4050 n1_M2_124260_40020 0 3.136470e-06
I4051 n1_M2_124260_42180 0 3.337412e-06
I4052 n1_M2_124260_44340 0 4.328822e-06
I4053 n1_M2_124260_46500 0 7.692204e-06
I4054 n1_M2_124260_47580 0 7.250853e-06
I4055 n1_M2_124260_49740 0 5.027004e-06
I4056 n1_M2_124260_51900 0 4.039152e-06
I4057 n1_M2_124260_54060 0 4.076479e-06
I4058 n1_M2_124260_56220 0 3.806815e-06
I4059 n1_M2_124260_58380 0 3.513269e-06
I4060 n1_M2_124260_59460 0 3.447717e-06
I4061 n1_M2_124260_61620 0 3.364085e-06
I4062 n1_M2_124260_63780 0 3.236013e-06
I4063 n1_M2_124260_65940 0 3.199276e-06
I4064 n1_M2_124260_68100 0 3.228448e-06
I4065 n1_M2_124260_70260 0 3.211745e-06
I4066 n1_M2_124260_72420 0 3.207316e-06
I4067 n1_M2_124260_73500 0 3.205607e-06
I4068 n1_M2_124260_75660 0 3.171961e-06
I4069 n1_M2_124260_77820 0 3.125885e-06
I4070 n1_M2_124260_79980 0 3.127106e-06
I4071 n1_M2_124260_82140 0 3.149999e-06
I4072 n1_M2_124260_84300 0 3.200009e-06
I4073 n1_M2_124260_86460 0 3.185010e-06
I4074 n1_M2_124260_87540 0 3.145532e-06
I4075 n1_M2_124260_89700 0 3.275822e-06
I4076 n1_M2_124260_91860 0 3.491514e-06
I4077 n1_M2_124260_94020 0 5.899172e-06
I4078 n1_M2_124260_96180 0 6.517207e-06
I4079 n1_M2_124260_98340 0 4.460244e-06
I4080 n1_M2_124260_100500 0 3.229608e-06
I4081 n1_M2_124260_101580 0 3.204275e-06
I4082 n1_M2_124260_103740 0 3.264880e-06
I4083 n1_M2_124260_105900 0 2.989144e-06
I4084 n1_M2_124260_108060 0 2.961511e-06
I4085 n1_M2_124260_110220 0 2.909391e-06
I4086 n1_M2_124260_112380 0 2.854114e-06
I4087 n1_M2_124260_113460 0 2.893660e-06
I4088 n1_M2_124260_115620 0 2.887357e-06
I4089 n1_M2_124260_117780 0 2.832443e-06
I4090 n1_M2_124260_119940 0 2.718417e-06
I4091 n1_M2_124260_122100 0 2.608495e-06
I4092 n1_M2_124260_124260 0 2.524810e-06
I4093 n1_M2_124260_126420 0 2.492890e-06
I4094 n1_M2_124260_127500 0 2.610567e-06
I4095 n1_M2_126420_60 0 2.900815e-06
I4096 n1_M2_126420_2220 0 2.657770e-06
I4097 n1_M2_126420_4380 0 2.683441e-06
I4098 n1_M2_126420_5460 0 2.613555e-06
I4099 n1_M2_126420_7620 0 2.666534e-06
I4100 n1_M2_126420_9780 0 2.636658e-06
I4101 n1_M2_126420_11940 0 2.716797e-06
I4102 n1_M2_126420_14100 0 2.712063e-06
I4103 n1_M2_126420_16260 0 2.636499e-06
I4104 n1_M2_126420_18420 0 2.786325e-06
I4105 n1_M2_126420_19500 0 2.784450e-06
I4106 n1_M2_126420_21660 0 2.810488e-06
I4107 n1_M2_126420_23820 0 2.902771e-06
I4108 n1_M2_126420_25980 0 2.958515e-06
I4109 n1_M2_126420_28140 0 3.003739e-06
I4110 n1_M2_126420_30300 0 2.976286e-06
I4111 n1_M2_126420_32460 0 2.905702e-06
I4112 n1_M2_126420_33540 0 2.887492e-06
I4113 n1_M2_126420_35700 0 2.846806e-06
I4114 n1_M2_126420_37860 0 2.845749e-06
I4115 n1_M2_126420_40020 0 2.845434e-06
I4116 n1_M2_126420_42180 0 3.019680e-06
I4117 n1_M2_126420_44340 0 2.966502e-06
I4118 n1_M2_126420_46500 0 3.183677e-06
I4119 n1_M2_126420_47580 0 3.166496e-06
I4120 n1_M2_126420_49740 0 2.955461e-06
I4121 n1_M2_126420_51900 0 2.951303e-06
I4122 n1_M2_126420_54060 0 2.958112e-06
I4123 n1_M2_126420_56220 0 2.949566e-06
I4124 n1_M2_126420_58380 0 2.947226e-06
I4125 n1_M2_126420_59460 0 2.981316e-06
I4126 n1_M2_126420_61620 0 3.032447e-06
I4127 n1_M2_126420_63780 0 2.978489e-06
I4128 n1_M2_126420_65940 0 2.953391e-06
I4129 n1_M2_126420_68100 0 2.904949e-06
I4130 n1_M2_126420_70260 0 2.841418e-06
I4131 n1_M2_126420_72420 0 2.795717e-06
I4132 n1_M2_126420_73500 0 2.731377e-06
I4133 n1_M2_126420_75660 0 2.826502e-06
I4134 n1_M2_126420_77820 0 2.778657e-06
I4135 n1_M2_126420_79980 0 2.834998e-06
I4136 n1_M2_126420_82140 0 2.916429e-06
I4137 n1_M2_126420_84300 0 3.022602e-06
I4138 n1_M2_126420_86460 0 2.999509e-06
I4139 n1_M2_126420_87540 0 2.852620e-06
I4140 n1_M2_126420_89700 0 2.675073e-06
I4141 n1_M2_126420_91860 0 2.582219e-06
I4142 n1_M2_126420_94020 0 2.815670e-06
I4143 n1_M2_126420_96180 0 2.877040e-06
I4144 n1_M2_126420_98340 0 2.798602e-06
I4145 n1_M2_126420_100500 0 2.838199e-06
I4146 n1_M2_126420_101580 0 2.909075e-06
I4147 n1_M2_126420_103740 0 2.953116e-06
I4148 n1_M2_126420_105900 0 2.810814e-06
I4149 n1_M2_126420_108060 0 2.789434e-06
I4150 n1_M2_126420_110220 0 2.699419e-06
I4151 n1_M2_126420_112380 0 2.702435e-06
I4152 n1_M2_126420_113460 0 2.669697e-06
I4153 n1_M2_126420_115620 0 2.596891e-06
I4154 n1_M2_126420_117780 0 2.560708e-06
I4155 n1_M2_126420_119940 0 2.589889e-06
I4156 n1_M2_126420_122100 0 2.540230e-06
I4157 n1_M2_126420_124260 0 2.522154e-06
I4158 n1_M2_126420_126420 0 2.508367e-06
I4159 n1_M2_126420_127500 0 2.753158e-06
I4160 n1_M2_127500_60 0 3.530126e-06
I4161 n1_M2_127500_2220 0 3.008115e-06
I4162 n1_M2_127500_4380 0 2.983980e-06
I4163 n1_M2_127500_5460 0 2.903995e-06
I4164 n1_M2_127500_7620 0 2.885517e-06
I4165 n1_M2_127500_9780 0 2.877014e-06
I4166 n1_M2_127500_11940 0 2.790959e-06
I4167 n1_M2_127500_14100 0 2.642854e-06
I4168 n1_M2_127500_16260 0 2.530597e-06
I4169 n1_M2_127500_18420 0 2.725079e-06
I4170 n1_M2_127500_19500 0 2.788398e-06
I4171 n1_M2_127500_21660 0 2.846972e-06
I4172 n1_M2_127500_23820 0 2.931473e-06
I4173 n1_M2_127500_25980 0 2.838202e-06
I4174 n1_M2_127500_28140 0 2.807785e-06
I4175 n1_M2_127500_30300 0 3.002426e-06
I4176 n1_M2_127500_32460 0 2.950760e-06
I4177 n1_M2_127500_33540 0 2.853231e-06
I4178 n1_M2_127500_35700 0 2.839502e-06
I4179 n1_M2_127500_37860 0 2.776604e-06
I4180 n1_M2_127500_40020 0 2.846297e-06
I4181 n1_M2_127500_42180 0 2.708678e-06
I4182 n1_M2_127500_44340 0 2.767772e-06
I4183 n1_M2_127500_46500 0 2.781370e-06
I4184 n1_M2_127500_47580 0 2.954428e-06
I4185 n1_M2_127500_49740 0 2.816315e-06
I4186 n1_M2_127500_51900 0 2.769436e-06
I4187 n1_M2_127500_54060 0 2.835870e-06
I4188 n1_M2_127500_56220 0 2.785457e-06
I4189 n1_M2_127500_58380 0 2.783348e-06
I4190 n1_M2_127500_59460 0 2.815603e-06
I4191 n1_M2_127500_61620 0 2.843857e-06
I4192 n1_M2_127500_63780 0 2.814056e-06
I4193 n1_M2_127500_65940 0 2.786630e-06
I4194 n1_M2_127500_68100 0 2.784128e-06
I4195 n1_M2_127500_70260 0 2.781075e-06
I4196 n1_M2_127500_72420 0 2.755567e-06
I4197 n1_M2_127500_73500 0 2.717590e-06
I4198 n1_M2_127500_75660 0 2.724350e-06
I4199 n1_M2_127500_77820 0 2.776921e-06
I4200 n1_M2_127500_79980 0 2.833154e-06
I4201 n1_M2_127500_82140 0 2.894958e-06
I4202 n1_M2_127500_84300 0 2.890093e-06
I4203 n1_M2_127500_86460 0 2.820074e-06
I4204 n1_M2_127500_87540 0 2.755068e-06
I4205 n1_M2_127500_89700 0 2.869349e-06
I4206 n1_M2_127500_91860 0 2.810332e-06
I4207 n1_M2_127500_94020 0 2.686282e-06
I4208 n1_M2_127500_96180 0 2.868832e-06
I4209 n1_M2_127500_98340 0 2.873955e-06
I4210 n1_M2_127500_100500 0 2.736725e-06
I4211 n1_M2_127500_101580 0 2.878209e-06
I4212 n1_M2_127500_103740 0 2.913486e-06
I4213 n1_M2_127500_105900 0 2.993877e-06
I4214 n1_M2_127500_108060 0 2.962355e-06
I4215 n1_M2_127500_110220 0 2.896922e-06
I4216 n1_M2_127500_112380 0 2.833107e-06
I4217 n1_M2_127500_113460 0 2.786613e-06
I4218 n1_M2_127500_115620 0 2.715312e-06
I4219 n1_M2_127500_117780 0 2.719124e-06
I4220 n1_M2_127500_119940 0 2.827303e-06
I4221 n1_M2_127500_122100 0 2.874589e-06
I4222 n1_M2_127500_124260 0 2.791342e-06
I4223 n1_M2_127500_126420 0 2.787431e-06
I4224 n1_M2_127500_127500 0 3.131003e-06
.op
.end
